# Allegro board LAG871PR10-0220.brd (continued)
## Nets (continued)
VR_LPM_R#: PR430.1 RC660.2 RC867.2 UC9.4(O)
VR_READY_CPU_CORE: PR612.2 PR614.2 PU602.39(VR_READY)
VRALERT#: RC73.1 UC1.CC36(GPP_B2/VRALERT#)
VSET_5105: CE38.1 RE77.1 UE1.C9(VSET)
VSYS_CHG: PC745.1 PR721.1 PU700.3(VSYS)
VTTREF_DDR: PC218.1 PC227.1 PU200.3(VTTREF)
WIGIG_32KHZ: JNGFF1.50(SUSCLK(32KHZ)) RZ56.2
WLAN_COEX1: JNGFF1.48(COEX1) RZ130.2
WLAN_COEX2: JNGFF1.46(COEX2) RZ129.2
WLAN_COEX3: JNGFF1.44(COEX3) RZ128.2
WLAN_PWR_EN: DZ9.1 RZ38.2 RZ70.2 RZ71.2 UZ47.5(ON2)
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.1 UE1.L13(GPIO112/PS2_CLK1A)
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.56(W_DISABLE1#)
WP_GPU_SMCLK: PD901.3 PR953.2 RE525.1 RE818.2
WP_GPU_SMCLK_R: RE818.1 UE1.F7(GPIO142/SMB05_CLK/SPI1_MOSI/UAR)
WP_GPU_SMDAT: PD901.2 PR954.2 RE524.1 RE817.2
WP_GPU_SMDAT_R: RE817.1 UE1.B6(GPIO141/SMB05_DATA/SPI1_CLK/UAR)
WP_INT_C: PR955.1 WC1.6
WP_SMBCLK_C: PR953.1 WC1.4
WP_SMBDAT_C: PR954.1 WC1.5
WWAN_ANT_CONFIG: JNGFF2.68(SUSCLK) RZ1450.1
WWAN_COEX1: JNGFF2.64(COEX1) RZ130.1 RZ373.1
WWAN_COEX2: JNGFF2.62(COEX2) RZ129.1 RZ372.1
WWAN_COEX3: JNGFF2.60(COEX3) RZ128.1 RZ374.1
WWAN_FULL_PWR_EN: CZ198.1 JNGFF2.6(FULL_CARD_POWER_OFF#) RZ43.1 UC1.CM23(GPP_D15/ISH_UART0_RTS#/GSPI2_CS)
WWAN_MIPI_ANT_CLK: JANT1.4 JANT2.4 JNGFF2.58(NC_2)
WWAN_MIPI_ANT_DAT: JANT1.5 JANT2.5 JNGFF2.56(NC_1)
WWAN_RADIO_DIS#: DZ5.1 RE10.1 UE1.F12(GPIO123/BCM0_CLK/PVT_IO2)
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8(W_DISABLE#)
WWAN_WAKE#: JNGFF2.23(WOWWAN#) RE38.1 UE1.M13(GPIO110/PS2_CLK2)
XCLK_BIASREF: RC402.1 UC1.CJ1(XCLK_BIASREF)
XDP_DBRESET#: CC78.1 CC326.1 JXDP1.48 RC137.1 RC243.1 RC248.1
XDP_JTAGX: CC305.1 RC87.1 RC328.2 UC1.P6(PCH_JTAGX)
XDP_OBS0: JXDP1.21 RC239.2
XDP_OBS0_R: RC239.1 UC1.U1(BPM#_0)
XDP_OBS1: JXDP1.23 RC240.2
XDP_OBS1_R: RC240.1 UC1.U2(BPM#_1)
XDP_OBS2_R: T366.1 UC1.U3(BPM#_2)
XDP_OBS3_R: T367.1 UC1.U4(BPM#_3)
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XDP_TMS: JXDP1.58 RC735.1 RC852.2
XTAL24_IN: CC21.1 RC59.2 RC728.2 YC1.3(CRYSTAL3)
XTAL24_IN_CPU: RC728.1 UC1.CK3(XTAL_IN)
XTAL24_OUT: CC22.1 RC59.1 RC729.2 YC1.1(CRYSTAL1)
XTAL24_OUT_CPU: RC729.1 UC1.CK2(XTAL_OUT)
XTAL_25_IN: RT394.1 UT1.D22(XTAL_25_IN)
XTAL_25_IN_R: CT21.1 RT394.2 YT1.1(IN)
XTAL_25_OUT: RT40.1 UT1.D23(XTAL_25_OUT)
XTAL_25_OUT_R: CT20.1 RT40.2 YT1.3(OUT)
N14048965: CT90.1 RT111.2 UT7.3(EN)
N15612276: RI14.2 UI3.16(ILIM_HI)
N15643257: CZ109.1 UZ43.10(CT2)
N15644626: CZ114.1 UZ3.10(CT2)
N15647018: CZ121.1 UZ8.6(CT)
N15655766: CZ117.1 UZ47.12(CT1)
N15655998: CZ118.1 UZ47.10(CT2)
N15670126: CZ38.2 RZ334.1
N15674340: JNGFF2.25(DPR) RZ326.1
N16783095: PC113.2 PR108.1
N16783134: PC127.2 PR117.1
N16783222: PC119.1 PU102.16(NC2) PU102.17(VCC)
N17370862: PC4.2 PQ4.4(G) PQ5.1(D) PR11.2 PR16.1
N17370885: PQ5.2(G) PR10.2 PR15.1
N17370921: PQ1.6(D1) PR15.2
N17370927: PQ7.1(D) PR16.2
N17370961: PL3.1 PQ2.1(D) PR3.1 PR6.1
N17370983: PQ2.3(S) PR3.2 PR5.1
N17370995: PQ3.2(BASE) PR6.2 PR8.1
N17370999: PQ2.2(G) PQ3.1(COLLECTOR) PR7.2
N17371029: PC6.2 PQ9.4(G) PQ11.1(D) PR12.2 PR18.1
N17371043: PQ6.1(D) PR18.2
N17371125: PQ7.2(G) PR20.1
N17371182: PQ6.2(G) PR22.2
N17372063: PQ1.3(D2) PR17.2 PR19.2
N17372074: PQ1.5(G2) PR25.1
N17372283: PQ1.2(G1) PR19.1
N17538214: PQ11.2(G) PR31.2 PR32.1
N17539406: PQ10.5(G2) PQ10.6(D1) PR33.2
N21875993: RZ64.2 UZ3.3(ON1)
N22005589: CZ113.1 UZ3.12(CT1)
N23230799: CA33.1 RA17.2
N23230891: CZ127.1 UZ5.10(CT2)
N23230909: CZ126.1 UZ5.12(CT1)
N24411441: CZ56.1 RZ63.1
N24740920: QV4.2(G) RV18.2
N24906879: PD700.1 PD702.1 PD704.1 PR708.2
N24908379: PD705.2 PR737.2
N24908381: PD705.3(1) PR735.1 PR736.2
N24908396: PR741.2 PU701.2(IN2)
N24908406: PD705.1(3) PR739.1 PU701.1(IN1)
N24908424: PR740.1 PU701.4(O)
N24908981: PC751.1 PR728.2
N25295845: QV2.1(D) RV5.2
N25300633: CZ220.1 QZ1.2(G) RZ388.2
N25301385: QV7.2(G) RV323.2 RV324.2 RV326.2
N25301415: CV635.1 QV8.2(G) RV400.2
N25301447: QV7.1(D) RV6.1 RV400.1
N25591846: PC13.2 PR47.2 PU3.5(P)
N25591872: PR43.2 PR45.1 PU3.4(O)
N25591876: PR44.2 PU3.2(A)
N25591912: PQ10.2(G1) PR41.2 PR43.1
N25591942: PQ8.1(D) PR22.1 PR27.1 PR44.1
N25591952: PR42.2 PU3.1(B)
N25709568: CE57.1 RE350.2
N25710703: QE17.1(D) RE546.2
N25852174: QE12.1(D) RE94.1
N25890123: PC647.1 PR650.2
N25907811: PC804.1 PR800.2 PR805.1 PR817.1 PU800.3(+)
N25907817: PC800.1 PR809.2 PR815.1 PU800.2(-)
N25907922: PQ803.2(G) PR801.2 PR807.1
N25907924: PQ802.6(D1) PR807.2 PR858.1
N25907948: PR853.2 PU801.1(B)
N25907954: PC814.2 PR859.2 PR860.2 PU801.5(P)
N25907966: PQ804.2(G1) PR818.2
N25907978: PQ807.1(D) PR818.1 PR822.1 PR854.1
N25907980: PQ802.5(G2) PR856.1 PR857.2
N25907988: PR855.1 PR856.2 PU801.4(O)
N25908000: PR854.2 PU801.2(A)
N25908024: PC811.1 PD802.1 PQ813.6(D1) PR831.2 PR842.1 PR870.2 PU800.5(+)
N25908041: PC813.1 PD802.2 PR835.2 PR840.1 PU800.7(O)
N25908049: PC812.1 PR832.2 PR843.1 PU800.6(-)
N25908061: PQ813.5(G2) PR840.2
N25908120: PQ804.6(D1) PR811.2
N25908122: PC803.2 PQ800.4(G) PQ803.1(D) PR803.2 PR811.1
N25908132: PQ813.3(D2) PR836.1
N25908138: PQ805.2(G) PR802.2 PR808.1
N25908140: PQ806.3(D2) PR808.2
N25908152: PC802.2 PQ801.4(G) PQ805.1(D) PR804.2 PR812.1
N25908168: PQ806.6(D1) PR813.2 PR814.2 PR852.2
N25908188: PQ804.3(D2) PR812.2
N25908210: PQ806.5(G2) PR814.1
N25908220: PQ806.2(G1) PR820.1
N25908319: PQ804.5(G2) PR816.2
N25908329: PQ810.5(G) PR825.2 PR826.2
N25908331: PQ808.5(G) PR834.2 PR841.1
N25908337: PQ808.6(D) PQ810.1(S) PR830.2 PR841.2
N25908347: PQ808.2(G) PQ808.3(D) PR833.2
N25908367: PQ811.5(G) PR829.2
N25908379: PQ810.2(G) PR824.2 PR827.2
N25908405: PQ809.6(D) PQ810.4(S) PR838.2 PR845.2
N25908421: PQ809.5(G) PR844.2
N25908431: PQ809.2(G) PQ809.3(D) PR839.2
N26019067: RZ1420.2 RZ1422.1 UZ35.1(B)
N26019799: RC425.1 UC1.BE7(VSSSA_SENSE)
N26019801: RC426.1 UC1.BG7(VCCSA_SENSE)
N26021766: CC340.1 QC7.2(G) RC432.2 RC433.1
N26021852: QC6.1(D) RC433.2
N26022763: CC77.1 RC845.2
N26125245: PR956.1 WC1.7
N26168283: PQ12.1(D) PR46.2
N26168409: PQ12.2(G) PR49.1
N26168635: PQ814.1(D) PR858.2
N26172409: PQ814.2(G) PR861.1
N26262634: T353.1 UC1.V28(DDR1_CKE_2/NC)
N26262636: T354.1 UC1.V29(DDR1_CKE_3/NC)
N26268119: CC1453.1 RC299.2
N26268121: CC1452.1 RC289.2
N26281421: T16.1 UC1.F37(RSVD_TP5)
N26281423: T17.1 UC1.F34(RSVD_TP4)
N26281433: T18.1 UC1.CP36(IST_TRIG)
N26281435: T19.1 UC1.CN36(RSVD_TP3)
N26281437: T20.1 UC1.BK34(TP_1)
N26281439: T21.1 UC1.BR18(TP_2)
N26281489: T360.1 UC1.CR4(RSVD29)
N26643986: JDIMM1.162(S2#/C0) T50.1
N26644006: JDIMM1.165(S3#/C1) T51.1
N26671961: CD31.2 RD18.1
N26693933: CD62.2 RD31.1
N26707415: PC865.1 PQ8.2(G) PR865.1
N26732492: JDIMM2.162(S2#/C0) T54.1
N26732518: JDIMM2.165(S3#/C1) T55.1
N26884945: RC848.2 UC1.BP36(VSS_434)
N26942341: CA35.1 UA1.38(VREF)
N26942651: CA51.1 RA44.1 UA1.39(LDO1-CAP)
N26943364: CA25.1 UA1.32(MIC2-CAP)
N26945044: CA52.1 UA1.21(LDO2-CAP)
N26945786: CA53.1 UA1.19(LDO3-CAP)
N26948154: RA53.1 RA54.1 UA1.33(5VSTB/AUX MODE)
N27268572: T361.1 UC1.BP34(TP_4)
N27268574: T363.1 UC1.BP35(TP_3)
N27268584: T364.1 UC1.A34(RSVD_TP1)
N27268586: T365.1 UC1.B35(RSVD_TP2)
N27268596: RC563.1 UC1.AH26(RSVD36)
N27268606: RC564.1 UC1.AJ27(RSVD37)
N27268608: RC436.2 RC564.2
N27268619: RC420.2 UC1.C34(RSVD68)
N27386991: RT104.1 UT5.K9(RPD_G1)
N27386997: RT103.2 UT5.L11(GND_24)
N27387070: RT97.2 RT98.1 RT99.2 UT5.F10(BUSPOWER_N)
N27387074: RT101.1 UT5.D6(HRESET)
N27387147: RT63.1 UT5.F1(I2C_ADDR)
N27387895: CT87.1 UT5.H7(SS)
N27388296: RT105.1 UT5.K10(RPD_G2)
N27393275: RT492.2 UT34.1(B)
N27393279: RT493.2 UT34.2(A)
N27393450: RT445.2 RT456.2 UT32.1(NO)
N27393452: RT448.2 UT32.3(NC)
N27807641: JEDP1.21 LV1.1
N27807832: JEDP1.14 RZ1470.1
N28655281: JANT1.1 RZ1460.2
N28655336: JANT2.1 RZ1461.2
N28690314: RC222.1 SW1.1
N28742748: CZ306.1 UZ53.6(CT)
N28821883: QE11.3(S) RE70.1 RE90.2
N28821903: QE4.2(BASE) RE70.2
N28822790: CV633.1 DV11.1 RV626.1 RV627.2
N28822814: CV651.1 DV12.1 RV629.1 RV631.2
N28822851: QV20.1 RV630.1
N28822863: QV20.2 RV631.1
N28822977: QV18.1 RV625.1
N28823001: QV18.2 RV627.1
N28926400: QZ3.1(C) RZ25.1
N29074842: PC307.2 PR308.1
N29161342: PR314.2 PU501.5(PG)
N29161603: PR315.1 PU402.4(PG)
N29478750: PD803.2 PR892.1
N29478753: PD803.3(1) PR893.1
N29559724: PR3012.1 PU3000.1(OUT1)
N29559810: PR3013.1 PU3000.7(OUT2)
N29694776: PC3003.2 PD3001.1 PR3004.2 PR3005.2 PU3000.3(IN+1)
N29694837: PC3004.2 PR3007.2 PR3008.2 PU3000.6(IN-2)
N29694873: PC3005.1 PD3002.1 PR3009.1 PR3010.1 PR3011.1 PU3000.5(IN+2)
N29694885: PD3000.1(3) PR3006.2 PR3007.1
N29695031: PQ3000.3(D2) PQ3000.6(D1) PR3001.1
N29695162: PC3001.2 PR3002.2 PR3003.2 PU3000.2(IN-1)
N30613280: T423.1 UC1.CR35(RSVD28)
N39469818: PC631.1 PR630.2
N39470129: PC640.1 PR646.2
N39470145: PC601.1 PR652.2
N39470173: PC632.2 PR641.1
N39470189: PH604.1 PR642.2
N46814682: PH601.2 PR610.1 PR631.2
N46814700: PC627.1 PR632.2
N46814728: PH602.1 PR628.2
N46814769: PC617.2 PR621.1
N46815164: PC621.2 PR623.1
N46815188: PC614.2 PR617.1
N46816463: PC629.2 PR639.1
N46816511: PH603.2 PR635.1 PR647.2
N46816817: PC630.2 PR644.1
N46816821: PH605.1 PR657.2
N46816907: PC639.2 PR645.1
N48704005: PL614.3 PR624.1
N49204882: PL612.3 PR661.1
N49223737: PC655.2 PU610.7(PHASE)
N49227484: PC671.2 PU613.7(PHASE)
N49231019: PC663.2 PU612.7(PHASE)

Pads without a net: CLIP17 1; DD1 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 2 16 20; JFPBTN1 3 5 7 9; JHDMI1 14; JIRTS1 16; JKBTP1 4; JNGFF1 6 8 12 16 20 66 68 70; JNGFF2 22 28 44 46 48 59 61 63 65 67; JNGFF3 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JSD1 16; JSIM1 1 C4 C6 C8; JSPK1 2; PBATT1 11 12; PD2 2; PD902 2; PU100 10 15; PU102 10; PU200 18 19; PU301 10 12; PU401 4; PU503 2 6 7; PU610 6 13 16 17 19; PU612 6 13 16 17 19; PU613 6 13 16 17 19; PU700 13; QZ7 3 4 5; RC563 2; RN100 2; RZ78 1; RZ79 1; RZ80 1; RZ326 2; RZ1473 1; RZ1477 2; UA1 1 6 7 8 9 10 11 12 13; UC1 A35 AA24 AA26 AB25 AC24 AC25 AC26 AD24 AD26 AJ1 AJ2 AJ3 AJ4 AL1 AL2 AL3 AL4 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 BC28 BH3 BH4 BJ34 BJ36 BK35 BK36 BL34 BL36 BL37 BP8 BP9 BT8 BT9 BV24 BV25 BV29 BV30 CA3 CA4 CA31 CB5 CB6 CD3 CD4 CE27 CF17 CF20 CG1 CG2 CG5 CG6 CG17 CG22 CG23 CH12 CH23 CH25 CH32 CJ30 CJ31 CK17 CK19 CK23 CM16 CM18 CM27 CM28 CN4 CN7 CN16 CN20 CN28 CP3 CP4 CP6 CP7 CP16 CP18 CP28 CR3 CR16 CR18 CR24 CR26 CR28 D34 D35 D37 G1 G2 G3 G4 H3 H4 K12 K14 K15 K17 K18 K20 L25 M24 M26 P24 P26 R24 R25 R26 V24 W3 W25 Y3 Y24 Y25; UD1 1; UE1 B8 B9 K1 K7; UE4 1 5; UI3 9 15; UR1 31; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 V18 W16 W19 Y16 Y19; UT5 B2 D7 E10 G10 G11; UT7 4; UV24 3; UZ12 3 4 5 7 10 11 12 13 15 25 26 27 28 30 31; UZ43 1 2 3 12 13 14; WC1 3 8 11 12

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 7398 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 772 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 270 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 42 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 191.4
  TOP w0.127: v1(228.92,27.11) v2(228.92,26.51)
  TOP w0.254: v1(228.92,27.11) 228.92,27.31 228.67,27.57 228.15,27.57 227.89,27.31 227.89,25.53 227.44,25.08 PR210.1
  IN1 w0.084: v1(97.28,27.26) 97.28,27.95 96.02,29.2 96.02,30.22 95.15,31.09 95.15,38.2 94.32,39.03 94.32,44.77 93.24,45.85 93.24,59.94 92.42,60.76 v1(92.42,66.03)
  IN3 w0.122: v1(97.28,27.26) 103.33,27.26 103.85,26.74 120.73,26.74 121.1,27.11 123.45,27.11 124.24,26.31 148.69,26.31 150.15,27.77 150.22,27.77 150.22,27.78 156,27.78 157.01,28.79 160.37,28.79 162.15,27.01 172.44,27.01 173.04,27.62 173.81,27.62 174.19,28 176.22,28 177.62,29.39 178.19,29.39 178.38,29.2 178.38,28.7 179.9,27.17 179.9,26.28 180.22,25.97 181.36,25.97 181.64,26.24 184.91,26.24 185.84,27.17 191.27,27.17 191.87,27.78 198.28,27.78 202.45,23.6 227.07,23.6 228.85,25.38 228.85,26.78 228.92,26.85 v1(228.92,27.11)
  BOTTOM w0.127: v1(92.42,66.03) 92.34,65.95 91.43,65.95 91.22,66.16 RD19.1 92.04,66.36 92.27,66.59 UD1.4
0.6V_DDR_VTT_ON_R: length 6.3
  TOP w0.127: PC222.1 226.5,27.68 v2(226.4,27.78)
  TOP w0.254: PU200.2 223.96,27.75 224.87,26.84 226.45,26.84 PC222.1 226.5,26.46 226.24,26.21 PR212.1 PR210.2
1.0V_PRIM_PWRGD: length 269.4
  TOP w0.127: RE361.2 284.65,71.81 v1(284.51,71.68) ; v1(233.66,44.7) v2(233.66,43.8) 233.66,40.25 235.29,38.61 239.35,38.61 240.68,37.28 240.68,35.4 241.32,34.77 242.43,34.77 243.11,34.08 243.11,33.17 243.52,32.76 243.52,30.98 240.35,27.82 235.67,27.82 234.32,26.47 v1(234.32,24.19) ; PR315.2 196.06,30.65 200.77,25.94 v1(200.77,24.19)
  TOP w0.254: v1(193.76,106.49) 193.63,106.37 193.63,105.92 193.48,105.77 193.12,105.77 192.78,106.12 PU301.9
  IN1 w0.084: v1(284.51,71.68) 283.42,70.59 281.72,70.59 281.65,70.66 280.92,70.66 279.89,71.69 278.02,71.69 277.39,71.06 275.58,71.06 275.05,70.53 271.99,70.53 271.68,70.84 269.09,70.84 268.63,70.38 v1(265.11,70.38) ; v1(234.32,24.19) 229.13,24.19 228.62,23.68 201.28,23.68 v1(200.77,24.19)
  IN3 w0.122: v1(180.57,104.48) 181.36,103.69 181.36,101.85 182.25,100.96 182.25,100.77 184.28,98.74 184.28,97.57 185.02,96.83 185.02,95.58 185.36,95.24 185.83,95.24 186.29,95.7 186.29,96.36 186.51,96.58 188.78,96.58 189.24,96.13 189.24,94.74 188.65,94.15 188.65,87.77 189.05,87.38 189.05,86.46 191.32,84.18 191.32,83 193.08,81.24 193.08,80.92 195.16,78.84 195.16,67.8 194.46,67.11 194.46,61.89 197.14,59.22 205.92,59.22 219.32,45.82 231.14,45.82 232.74,44.22 233.52,44.22 233.66,44.35 v1(233.66,44.7) 234.42,45.46 240.11,45.46 240.63,45.98 243.94,45.98 244.85,46.89 246.7,46.89 251.62,51.81 252.9,51.81 255.74,54.66 257.73,54.66 260.42,57.34 263.01,57.34 263.26,57.59 263.26,57.71 263.52,57.96 263.52,63.01 264.15,63.64 264.15,69.64 264.89,70.38 v1(265.11,70.38)
  IN4 w0.084: v1(180.57,104.48) 180.93,104.12 183.37,104.12 187.98,108.73 192.4,108.73 193.76,107.37 v1(193.76,106.49)
  BOTTOM w0.254: v1(193.76,106.49) 193.98,106.71 PC350.1 194.58,107.4 PR313.1 PR314.1
3.3V_CAM_EN#: length 240.6
  TOP w0.127: v1(47.89,105.47) 49.14,105.47 RZ388.1 ; v1(150.5,62.38) 150.91,61.97 RC834.1 v2(151.06,60.95)
  IN3 w0.122: v1(47.89,105.47) 43.42,105.47 39.19,101.23 39.19,100.32 38.23,99.37 38.23,96.89 38.75,96.37 39.1,96.37 39.87,97.14 41.83,97.14 42.14,97.45 43.42,97.45 44.03,96.84 47.72,96.84 49.14,95.42 49.14,92.14 48.31,91.3 48.31,90.37 50,88.68 54.42,88.68 54.86,88.23 54.86,87.5 53.49,86.13 53.49,84.98 50.64,82.13 50.64,76.99 49.35,75.69 49.35,73.37 48.95,72.98 47.71,72.98 46.83,72.1 46.83,66.01 48.89,63.95 51.27,63.95 54.01,61.21 54.01,57.8 53.62,57.42 53.62,48.26 54.01,47.87 54.34,47.87 54.64,48.18 60.93,48.18 61.53,48.78 82.38,48.78 83.28,49.68 92.51,49.68 94.79,51.96 141.52,51.96 145.2,48.28 146.12,48.28 147.2,47.19 151.63,47.19 153.58,49.15 155.39,49.15 159.23,52.99 164.88,52.99 165,52.86 v1(165,52.44)
  IN4 w0.084: v1(150.5,62.38) 150.5,58.6 151.26,57.85 151.26,56.71 151.98,55.99 156.51,55.99 156.84,55.65 157.1,55.65 158.96,53.79 164.84,53.79 165,53.63 v1(165,52.44)
  BOTTOM w0.076: 148.91,63.63 148.91,66.05 147.31,67.66 147.31,68.46 UC1.CC37
  BOTTOM w0.102: 148.91,63.63 149.78,62.77 150.12,62.77 v1(150.5,62.38)
3.3V_TS_EN: length 305.5
  TOP w0.102: v1(279.42,82.25) 279.11,82.56 UE1.J7
  TOP w0.127: v1(263.62,89.77) 263.87,90.02 RE547.1 ; v2(84.77,108.4) 84.37,108.01 RV323.1 84.74,106.94 v1(84.74,105.88)
  IN1 w0.084: v1(263.62,89.77) 264.59,90.74 271.88,90.74 272.11,90.52 273.16,90.52 273.42,90.79 v1(273.42,90.88)
  IN2 w0.122: v1(273.42,90.88) 273.75,90.55 275.41,90.55 275.86,90.1 276.36,90.1 277.03,89.43 277.47,89.43 278.26,88.64 282.39,88.64 282.64,88.39 282.64,87.43 282.26,87.05 282.26,83.49 281.82,83.05 279.72,83.05 279.42,82.75 v1(279.42,82.25)
  IN3 w0.122: v1(84.74,105.88) 84.74,107.01 85.25,107.53 92.18,107.53 92.43,107.28 100.62,107.28 101.25,106.64 111.3,106.64 114.76,110.1 134.64,110.1 135.2,109.54 140.97,109.54 141.14,109.71 145.37,109.71 146.36,108.72 148.46,108.72 148.73,108.45 152.84,108.45 153.32,108.93 159.19,108.93 159.52,108.6 159.52,108.35 159.73,108.13 161.49,108.13 162.76,106.86 172.58,106.86 173.8,105.65 173.8,104.35 178.9,99.25 178.9,96.37 180.41,94.86 180.41,93.99 181.88,92.52 181.88,88.7 185.41,85.16 185.41,83.28 185.57,83.12 185.57,81.78 187.9,79.45 187.9,77.59 191.1,74.39 191.1,62.48 195.74,57.84 195.74,55.38 196.43,54.69 208.52,54.69 218.73,44.48 230.57,44.48 232.17,42.88 234.4,42.88 234.54,43.02 241.7,43.02 242.52,43.85 242.52,44.07 242.99,44.54 244.4,44.54 245.19,45.33 247.34,45.33 250.38,48.38 252.54,48.38 254.22,50.05 254.22,50.74 256.15,52.67 258.09,52.67 258.84,53.43 259.74,53.43 260.45,54.14 260.45,54.76 261.69,56 264.42,56 265.76,57.34 265.76,59.52 264.97,60.31 264.97,62.56 265.49,63.08 265.49,66.29 267.44,68.24 267.44,69.97 265.91,71.5 265.91,73.43 264.39,74.95 264.39,83.45 263.72,84.12 263.72,86.42 263.09,87.05 263.09,88.61 263.61,89.14 263.61,89.76 v1(263.62,89.77)
3.3V_WIGIG_EN: length 6
  TOP w0.127: T399.1 286.5,78.44 284.24,78.44 283.91,78.77 283.91,78.95 283.05,79.82 281.76,79.82 UE1.M4
3.3V_WWAN_EN: length 50.7
  TOP w0.127: v1(273.81,81.41) 273.87,81.41 UE1.C6 ; UZ43.5 259.79,51.82 RZ40.2 260.03,51.8 260.39,51.44 v1(260.39,50.95) 260.39,49.98 v2(260.36,49.94)
  IN1 w0.084: v1(267.34,81.71) 267.34,81.85 267.79,82.3 268.44,82.3 269.05,82.91 271.36,82.91 272.56,81.7 272.56,81.29 272.83,81.01 273.23,81.01 273.62,81.41 v1(273.81,81.41)
  IN3 w0.122: v1(267.34,81.71) 267.34,81.57 268.2,80.71 269.56,80.71 269.72,80.55 269.72,72.03 269.05,71.36 269.05,70.02 268.79,69.76 268.79,67.06 268.55,66.82 268.55,63.71 268.76,63.49 268.76,61.95 268.31,61.49 267.98,61.49 267.1,60.61 267.1,56.69 264.45,54.04 264.45,52.65 263.14,51.33 260.77,51.33 v1(260.39,50.95)
3V5V_EN: length 217.4
  TOP w0.127: v1(59.16,49.69) 59.16,50.09 v2(58.93,50.31)
  TOP w0.254: PU100.12 190.23,95.22 189.81,94.81 PR116.1 188.87,94.56 188.22,93.91 v1(187.78,93.91) PC128.1 186.54,94.76 PR114.2 ; PU102.12 44.89,30.76 44.57,31.08 44.57,32.54 v1(45,32.98)
  IN2 w0.122: v1(187.78,93.91) 187.17,94.51 185.15,94.51 184.14,93.5 180.82,93.5 177.3,97.02 172.04,97.02 171.58,97.48 v1(170.36,97.48)
  IN3 w0.122: v1(59.16,49.69) 59.16,49.42 59.28,49.3 60.47,49.3 61.07,49.9 66.01,49.9 66.65,50.53 71.44,50.53 72.12,51.22 73.09,51.22 73.28,51.41 87.24,51.41 90.71,54.88 133.19,54.88 137.55,59.24 137.55,64.67 137.67,64.79 138.79,64.79 139.07,64.51 139.07,64.04 139.53,63.57 140.64,63.57 141.64,62.57 141.64,61.05 144.47,58.22 145.91,58.22 149.32,61.63 149.32,63.54 149.65,63.87 149.65,66.32 149.89,66.56 149.89,68.19 150.27,68.57 152.2,68.57 155.89,72.27 159.47,72.27 160.03,72.83 160.77,72.83 161.21,73.27 161.21,75.28 161.41,75.48 161.41,76.57 160.94,77.04 160.94,77.99 161.67,78.73 161.67,81.22 164.14,83.69 165.97,83.69 166.74,84.47 170.03,84.47 172.27,86.7 172.27,87.82 171.86,88.23 171.86,89.24 172,89.38 172,91.12 170.18,92.93 170.18,97.08 170.36,97.26 v1(170.36,97.48)
  IN4 w0.084: v1(59.16,49.69) 59.16,49.18 58.73,48.76 56.31,48.76 54.29,46.73 52.35,46.73 44.47,38.86 43.45,38.86 42.17,37.57 42.17,35.3 43.38,34.09 44.27,34.09 45,33.36 v1(45,32.98)
+0.6V_DDR_VTT: length 110.4
  IN2 w1.016: 126.82,31.87 127.32,31.87 129.29,29.9 129.74,29.9
  IN4 w1.016: 131.26,28.57 136.09,28.57 137.61,27.04 143.95,27.04 145.47,28.57 155.26,28.57 155.64,28.95 163.46,28.95 163.84,28.57 171.01,28.57 171.71,27.87 174.48,27.87 176.24,26.11 178.1,26.11 178.67,25.55 178.67,25.29 180.12,23.84 186.04,23.84 187.01,24.82 187.01,26.35 188.41,27.74 195.2,27.74 195.32,27.86 197.8,27.86 198.89,28.95 200.09,28.95 ; 226,26.98 226,25.33 224.36,23.69 205.73,23.69 201.62,27.81 201.62,28.57 201.11,29.08
  BOTTOM w0.305: JDIMM1.258 v1(123.71,32.27)
  vias: v1(126.07,31.91) v1(126.09,31.35) v1(129.74,28.57) v1(130.37,28.57) v1(200.09,29.78) v1(200.79,29.78) v1(225.88,28.44) v1(226.45,28.44) v1(226.89,28) v3(227.46,33.17)
+0.6VSP: length 1.3
  TOP w0.127: 225.33,33.6 v3(225.33,34.92)
+0.9V_TBT_CIO: length 2.9
  TOP w0.356: CT39.1 28.07,78.48 28.29,78.71 28.29,78.99 v1(28.4,79.09) 28.42,79.11 28.92,79.11 CT40.1
  TOP w0.381: CT39.1 27.75,78.46 v1(27.75,77.79) 27.79,77.76 CT38.1
+0.9V_TBT_DP: length 2.7
  TOP w0.356: CT25.1 27.01,79.84 v1(27.1,79.74) ; CT27.1 26.5,77.75 v1(26.45,77.79) ; CT26.1 26.56,79.63 v1(26.45,79.74)
  TOP w0.381: CT30.1 26.31,79.89 v1(26.45,79.74)
  vias: v1(29.05,77.79) v1(29.05,77.14) v2(30.09,77.26)
+0.9V_TBT_LVR_OUT: length 1
  TOP w0.381: v1(25.15,78.44) 25.15,78.32 24.7,77.86 CT62.1
  vias: v1(24.5,75.19) v1(25.15,75.19) v1(25.8,77.79) v1(25.8,74.54) v1(25.8,73.89) v1(26.46,73.89) v2(23.93,75.05)
+0.9V_TBT_PCIE: length 1.2
  TOP w0.127: CT35.1 28.66,73.06 v3(29.06,72.65)
  vias: v1(26.45,76.49) v1(26.45,75.84) v1(26.45,75.19) v1(26.45,74.54)
+0.9V_TBT_SVR: length 1
  TOP w0.127: v3(17.47,89.37) 17.55,89.3 v1(17.55,88.43)
  vias: v1(16.96,88.43) v1(18.13,88.43) v1(18.74,88.4) v1(23.85,77.79) v1(23.85,77.14) v1(23.85,76.49) v1(25.8,78.44) v1(26.45,78.44)
+0.9V_TBT_USB: length 1.5
  TOP w0.254: CT33.1 28.28,75.97 v1(28.4,75.84) 28.92,75.32 CT32.1
+1.0V_AMPHYPLL: length 13.2
  TOP w0.127: CC104.1 146.6,97.28 v2(146.42,97.1)
  IN4 w0.508: v1(143.85,92.32) 145.56,90.61 147.52,90.61 148.13,91.22 148.13,94.1 147.62,94.61 v1(147.52,94.61)
  BOTTOM w0.18: v1(143.85,92.32) 143.85,90.85 UC1.BV2
  BOTTOM w0.2: v1(143.85,92.32) 143.85,93.15 CC80.1
  BOTTOM w0.254: CC80.1 CC69.1
+1.0V_APLL:
  vias: v1(141.74,82.84) v1(142.39,82.84) v1(142.39,82) v1(143.04,83.68) v1(143.69,83.68) v3(145.07,91.62)
+1.0V_CLK: length 16.1
  BOTTOM w0.2: 155.26,88.95 153.89,88.95 UC1.CP5
  BOTTOM w0.381: CC70.1 CC83.1 162.7,94.66 CC100.1 ; 155.26,88.95 155.45,88.95 156.06,89.56
  BOTTOM w0.4: CC70.1 161.4,93.5 v3(160.36,92.46) 157.45,89.56 156.06,89.56
  BOTTOM w0.508: CC100.1 CC103.1 LC2.2 RC175.2
+1.0V_MPHYGT:
  vias: v1(144.34,83.68) v1(144.34,82.84) v1(144.99,83.63) v1(144.99,82.84) v1(163.26,96.58) v1(163.9,96.58) v1(164.53,96.58) v3(169.54,91.59)
+1.0V_PRIM: length 101.5
  TOP w0.508: v1(63.71,100.2) 63.48,99.97 63.48,99.88 RC216.1
  IN3 w0.508: v1(150.82,105.28) 147.33,105.28 146.21,106.39 144.18,106.39 143.64,105.85 142.49,105.85 142.01,105.37 135.86,105.37 135.26,104.77 122.56,104.77 120.77,102.98 116.03,102.98 115.29,103.73 114.02,103.73 113.39,103.09 104.15,103.09 103.57,103.67 94.29,103.67 90.82,100.2 88.33,100.2 88.02,99.88 88.02,98.9 87.39,98.27 80.91,98.27 79.63,99.56 75.07,99.56 74.94,99.68 70.91,99.68 70.26,99.04 65.88,99.04 65.38,99.54 64.36,99.54 v1(63.71,100.2)
  BOTTOM w0.1: 141.19,79.29 UC1.BP20 ; UC1.BP20 141.64,78.84 ; UC1.BP20 141.19,78.84 ; UC1.BP20 141.64,79.29 ; 141.19,78.45 UC1.BP22 141.64,78.45
  BOTTOM w0.203: v1(147.59,84.52) UC1.CC12 ; UC1.BP14 v1(141.74,83.68) ; UC1.CA14 146.22,82.93 v1(146.29,82.84) ; v1(143.68,84.59) 143.69,84.52 UC1.BU12 ; UC1.BR12 v1(142.39,83.68)
  BOTTOM w0.508: LC2.1 165.36,95.94 v1(165.93,96.51) 166.03,96.51 RC175.1
  vias: v1(141.74,79.48) v1(142.39,80.32) v1(142.39,79.48) v1(142.94,78.64) v1(143.04,81.16) v1(143.04,80.32) v1(143.09,79.48) v1(144.99,81.16) v1(144.99,79.48) v1(163.01,98.8) v1(163.03,99.49) v1(163.52,100.45) v1(163.54,99.8) v1(163.54,99.17) v1(163.54,98.53) v1(164.03,100.77) v1(164.05,100.12) v1(164.05,99.49) v1(164.05,98.85) v1(164.53,100.51) v1(164.55,99.87) v1(164.55,99.23) v1(164.55,98.6) v3(168.2,107.28)
+1.0V_PRIM_CORE: length 85.3
  TOP w2.794: 231.34,26.54 231.34,29.02 230.26,30.1 230.26,35.93 228.36,37.83 226.38,37.83 225.48,38.73 222.64,38.73 208.35,53.02 204.29,53.02 203.33,53.97 187.46,53.97 184.35,57.08 184.35,68.96 181.55,71.76 177.54,71.76 176.85,72.45
  vias: v1(143.69,82) v1(143.69,77.8) v1(144.34,81.16) v1(144.34,79.48) v1(144.37,78.64) v1(144.34,77.8) v1(144.99,78.64) v1(144.99,77.8) v1(145.64,78.64) v1(146.29,81.16) v1(146.29,79.48) v1(146.94,83.73) v1(146.94,82) v1(191.97,26.28) v1(192.22,25.71) v1(192.54,26.28) v1(192.79,25.71) v1(192.92,26.85) v1(193.49,26.85) v1(229.88,23.68) v1(230.45,23.68) v1(231.02,23.68) v1(231.59,23.68) v1(232.16,23.68) v1(232.73,23.68) v3(231.3,24.58)
+1.0V_PRIM_COREP: length 8.9
  TOP w0.127: 191.32,29.12 v2(191.32,30.44)
  TOP w0.254: PC427.1 188.84,29.25 PR423.2 ; PU402.1 185.86,26.78 v1(185.97,26.66)
  IN2 w0.254: v1(189.17,25.46) 188.35,24.63 186.47,24.63 186.21,24.89 186.21,26.42 v1(185.97,26.66)
+1.0V_PRIM_XDP: length 81.8
  TOP w0.356: CC288.1 RC138.1
  TOP w0.381: v1(86.32,105.89) CC288.1 ; CC299.1 v1(61.28,95.78) ; v1(112.79,106.32) 111.93,105.47 109.19,105.47 105.67,101.95 RC125.2
  TOP w0.508: v1(63.45,104.23) 63.45,102.43 v3(62.23,101.21) RC216.2 62.16,99.55 61.54,98.93 v1(61.54,97.93)
  IN1 w0.508: v1(61.54,97.93) 61.54,96.96 61.28,96.7 v1(61.28,95.78)
  IN3 w0.508: v1(112.79,106.32) 111.88,106.32 111.54,105.98 93.04,105.98 92.32,105.26 90.37,105.26 89.86,105.77 89.86,106.23 89.35,106.74 86.65,106.74 86.32,106.4 v1(86.32,105.89) 86.32,105.33 86.92,104.72 86.92,103.24 86.32,102.64 82.36,102.64 79.83,105.16 65.72,105.16 64.79,104.23 v1(63.45,104.23)
  BOTTOM w0.305: v1(61.28,95.78) 61.28,95.78 JXDP1.43 ; v1(61.54,97.93) 61.54,98.48 60.98,99.04 JXDP1.44
+1.0V_VCCST: length 396.2
  TOP w0.356: RC218.1 136.54,101.6 v1(136.36,101.78)
  TOP w0.508: v1(55.88,63.18) 56.88,62.18 PR605.1 PR604.1 PR601.1 56.88,58.32 PC602.1 ; RC235.2 60.91,91.43 v1(62.12,91.43) ; RE59.1 281.7,93.53 v1(281.28,93.95) ; v1(116.15,107.44) 116.15,107.16 113.81,104.82 v3(113.81,104.77) 113.81,100.54 114.42,99.93 v1(114.42,99.12)
  IN1 w0.508: v1(265.7,91.52) 265.91,91.73 273.92,91.73 276.14,93.95 v1(281.28,93.95)
  IN2 w0.508: v1(116.85,107.48) 117.37,108.01 122.39,108.01 124.59,105.81 v1(145.8,105.81) ; v1(62.12,91.43) 59.63,88.94 57.49,88.94 54.52,85.98 54.52,83.09 53.87,82.44 52.56,82.44 51.8,81.68 51.8,80.73 52.4,80.12 53.18,80.12 54.3,79 54.3,76.14 56.58,73.85 56.58,72.9 58.74,70.75 58.74,67.52 55.84,64.61 55.84,63.23 v1(55.88,63.18)
  IN3 w0.508: v1(62.12,91.43) 62.52,91.43 63.2,92.12 67.58,92.12 71.75,96.29 82.46,96.29 82.78,96.61 88.15,96.61 88.96,97.41 91.73,97.41 93.78,99.46 97.95,99.46 99.18,100.69 103.93,100.69 105.21,99.41 111.93,99.41 112.78,100.26 113.86,100.26 114.42,99.7 v1(114.42,99.12) ; v1(265.7,91.52) 265.34,91.16 265.34,89.56 265.7,89.21 265.7,87.31 270.39,82.62 270.39,76.04 271.86,74.57 271.86,72.02 271.48,71.63 271.48,67.5 270.97,67 270.21,67 269.58,66.36 269.58,64.18 269.82,63.94 269.82,60.57 268.13,58.89 268.13,56.34 268.62,55.85 268.62,54.25 266.95,52.58 265.84,52.58 263.95,50.69 263.95,50.38 262.43,48.86 258.84,48.86 258.67,48.69 256.9,48.69 255.35,47.14 254.76,47.14 252.98,45.36 251.51,45.36 249.15,43 247.2,43 246.66,42.46 245.36,42.46 244.62,41.73 243.44,41.73 242.44,40.73 235.29,40.73 235.02,40.47 229.6,40.47 229.54,40.52 229.52,40.52 227.88,42.16 227.85,42.16 227.78,42.23 217.95,42.23 217,43.17 217,43.17 207.63,52.55 195.49,52.55 189.82,58.22 187.67,58.22 187.17,58.72 187.17,59.72 188.11,60.66 188.11,66.21 187.65,66.67 187.65,71.57 185.73,73.49 185.73,76.1 185.31,76.52 185.31,77.58 184.8,78.09 184.62,78.09 181,81.7 181,83.56 178.78,85.78 178.78,86.75 177.85,87.68 177.85,90.65 175.82,92.68 175.82,95.1 174.24,96.68 173.64,96.68 173.17,97.15 v1(173.17,97.85) 173.17,101.63 170.76,104.03 161.52,104.03 160.47,105.09 156.95,105.09 155.38,103.51 154.27,103.51 154.17,103.41 145.51,103.41 144.85,104.07 v1(144.09,104.07) 143.97,104.19 143.18,104.19 142.7,103.71 141.63,103.71 141.09,103.17 140.58,103.17 138.68,101.26 136.88,101.26 v1(136.36,101.78)
  BOTTOM w0.18: UC1.BP2 v1(141.39,91.69)
  BOTTOM w0.203: UC1.BT11 v1(142.33,85.45) UC1.BR11
  BOTTOM w0.3: UC1.BP11 v1(141.09,84.52)
  BOTTOM w0.508: v1(136.36,101.78) 136.36,101.36 135.76,100.76 RC71.2 ; RE90.1 172.87,98.15 v1(173.17,97.85)
+1.0V_VCCST_C: length 0.6
  TOP w0.127: 148.88,106.48 v3(149.46,106.48)
+1.0V_VCCSTG: length 98.1
  TOP w0.381: RC436.1 v1(89.19,65.81)
  TOP w0.508: 105.67,98.42 105.67,99.55 108.75,102.62 110.34,102.62 v3(111.48,103.76) v1(115.22,107.5)
  IN2 w0.508: v1(115.22,107.5) 116.36,108.64 122.75,108.64 124.97,106.42 v1(141.61,106.42)
  IN3 w0.254: v1(100.91,96.13) 100.91,95.22 99.59,93.9 98.5,93.57 98.23,93.52 97.62,93.26 96.07,91.71 94.2,91.71 93.14,90.65 90.93,90.65 90.54,91.03 87.1,91.03 86.76,90.68 86.76,89.61 85.29,88.13 85.29,68 86.96,66.33 88.78,66.33 89.19,65.92 v1(89.19,65.81)
  BOTTOM w0.254: v1(107.28,95.89) 107.28,95.74 RC130.2
  BOTTOM w0.381: RC558.1 v1(115.22,107.5)
  BOTTOM w0.508: v1(137.23,98.37) 137.55,98.05 RC153.1 138.06,97.64 138.33,97.37 138.33,95.79 137.99,95.45 CC29.1 137.99,94.4 137.32,93.72 137.32,92.74 137.61,92.45 137.61,92.09
  vias: v1(137.61,91.5) v1(137.61,90.93) v1(142.25,106.42)
+1.0V_VCCSTG_C: length 1.7
  TOP w0.127: v3(138.47,107.75) 138.74,107.49 140.09,107.49
+1.0V_VCCSTG_R: length 7.4
  BOTTOM w0.15: 136.99,91.62 136.99,91.44 136.88,91.33 136.88,90.15 UC1.BG3
  BOTTOM w0.254: 136.99,91.62 136.99,92.41 136.85,92.55 136.85,94.04 v2(136.59,94.29) 136.59,95.82 137.03,96.25 RC153.2
+1.0VS_VCCIO: length 102.9
  TOP w0.254: RC132.2 60.61,93.91 v1(60.9,93.62)
  TOP w0.381: RC163.1 v1(96.09,79.51)
  TOP w0.508: v1(129.44,96.15) RC8.1
  IN2 w0.254: v1(60.9,93.62) 61.49,93.03 64.13,93.03 65.09,92.07 67.05,92.07 68.32,90.8 68.32,71.26 67,69.93 v1(67,64.07)
  IN3 w0.2: 140.87,85.05 140.48,84.66 139.94,85.21 139.94,89.02 140.45,89.53 140.64,89.34 140.87,89.11 140.87,85.05
  IN3 w0.5: 140.48,84.66 140.48,81.77 v1(141.09,81.16) ; 141.08,92.45 140.45,91.81 140.45,89.53
  IN3 w0.508: v1(167.49,98.63) 166.27,98.63 165.24,97.61 157.09,97.61 155.38,99.31 154.5,99.31 153.22,98.02 153.22,96.83 152.41,96.02 146.61,96.02 143.03,92.45 v1(141.36,92.45) 141.08,92.45
  BOTTOM w0.1: UC1.BH25 137.79,75.93 ; UC1.BH25 138.23,75.93 ; UC1.BH25 137.79,75.48 ; UC1.BH25 138.23,75.48 ; 126.84,75.02 UC1.AK26 126.84,75.47 ; UC1.AL26 127.3,75.47 ; UC1.AL26 127.75,75.02 ; UC1.AL26 127.3,75.02 ; UC1.AL26 127.75,75.47 ; 138.24,76.4 UC1.BJ24 138.24,75.95 ; UC1.AL24 127.75,75.95 ; UC1.AL24 127.3,76.4 ; UC1.AL24 127.75,76.4 ; UC1.AL24 127.3,75.95 ; UC1.AL25 126.85,75.48 ; UC1.AL25 127.3,75.48 ; UC1.AL25 127.3,75.93 ; UC1.AL25 126.85,75.93 ; 137.78,75.02 UC1.BH26 137.78,75.47 ; 126.84,76.4 UC1.AK24 126.84,75.95 ; 127.76,75.48 UC1.AM25 127.76,75.93 ; 138.24,75.02 UC1.BJ26 138.24,75.47 ; 137.78,76.4 UC1.BH24 137.78,75.95
  BOTTOM w0.2: UC1.BP18 141.42,80.74 v1(141.09,81.16) UC1.BP16
  BOTTOM w0.508: QE11.1 170.5,100.45 170.15,100.8 168.62,100.8 167.49,99.67 v1(167.49,98.63)
  vias: v1(71.44,28.12) v1(71.44,27.55) v1(71.44,26.98) v1(72.02,28.06) v1(72.02,27.49) v1(72.02,26.92) v1(72.59,26.92) v1(126.61,77.06) v1(127.07,76.39) v1(127.52,77.06) v1(127.53,74.49) v1(127.98,76.39) v1(128.44,74.49) v1(137.55,74.49) v1(137.68,76.9) v1(138.18,76.61) v1(138.5,77.07) v1(138.47,74.49) v3(71.02,26.63)
+1.2V_DDRP: length 31.8
  TOP w0.254: v1(216.15,27.31) PC208.1 PR204.1
  IN3 w0.254: v1(216.15,27.31) 216.15,26.26 214.9,25.01 208.1,25.01 207.71,25.39 207.71,30.09 208.29,30.66 209.43,30.66 210,31.24 v1(210,31.49)
  IN3 w1.016: 211.42,31.96 212.39,32.93 217.6,32.93 219.84,30.69 222.47,30.69
  vias: v1(207.14,32.06) v1(207.14,31.49) v1(207.71,32.06) v1(207.71,31.49) v1(208.29,32.06) v1(208.29,31.49) v1(208.86,32.06) v1(208.86,31.49) v1(209.43,32.06) v1(209.43,31.49) v1(210,32.06) v1(223.34,30.98) v1(223.91,30.98) v3(209,30.68)
+1.2V_LDO:
  vias: v1(290.97,63.45) v1(293.45,63.49) v1(293.93,63.18) v3(292.66,64.24)
+1.2V_MEM: length 130
  TOP w0.254: v1(91.82,66.8) 91.82,63.94 91.83,63.94 91.83,60.89 92.02,60.7
  TOP w0.508: v1(175.33,40.65) 174.77,41.21 CD40.1 ; 172.92,29.58 172.92,29.33 172.21,28.62 RD28.1 ; v1(98.9,29.72) 98.9,27.86 99.45,27.31 RD15.1 ; CD48.1 173.3,40.56 v1(173.33,40.52) ; CD34.1 176.27,41.21 v1(176.86,40.61) ; CD47.1 CD41.1 170.43,41.21 v1(169.87,40.66)
  IN1 w0.381: v1(86.94,29.41) 87.31,29.78 v1(90.05,29.78)
  BOTTOM w0.09: v1(120.3,67.96) UC1.Y36 ; UC1.BH36 v1(137.92,67.96) ; UC1.AM36 v1(127.85,67.96) ; UC1.AH36 v1(125.34,67.96) ; UC1.AY36 v1(132.89,67.96) ; UC1.AD36 v1(122.82,67.96)
  BOTTOM w0.2: v1(135.73,71.95) UC1.BE32 ; v1(132.09,71.95) UC1.AW32 ; UC1.R32 v1(116.59,71.95) ; v1(128.44,71.95) UC1.AN32 ; UC1.AH32 v1(124.79,71.95)
  BOTTOM w0.203: JDIMM2.112 162.41,30.31 162.55,30.17 162.55,30.16 162.66,30.05 162.66,29.99 v1(162.82,29.83)
  BOTTOM w0.254: JDIMM1.112 85.21,30.15 v1(85.46,29.9)
  BOTTOM w0.305: v1(162.1,40.48) 162.16,40.42 JDIMM2.111 ; JDIMM2.141 169.65,40.4 169.87,40.61 v1(169.87,40.66) ; JDIMM1.118 86.7,29.64 v1(86.94,29.41) ; JDIMM2.96 158.41,31.93 158.08,32.25 v1(158.08,32.76) ; v1(190.95,32.38) 191.41,31.92 191.41,31.03 JDIMM2.220 ; JDIMM1.160 99.21,30.03 v1(98.9,29.72) ; JDIMM2.54 147.9,32.68 v1(147.88,32.71) ; JDIMM1.199 108.96,40.12 108.62,40.45 108.62,40.59 v1(108.61,40.6) ; JDIMM1.33 v1(65.46,40.47) ; JDIMM2.33 142.66,40.22 142.98,40.55 143.16,40.55 v1(143.17,40.54) ; JDIMM1.117 86.45,40.15 86.04,40.57 v1(85.48,40.57) 85.27,40.57 84.96,40.25 JDIMM1.111 ; JDIMM1.135 90.96,40.24 90.5,40.7 90.12,40.7 v1(90.11,40.7) 90.11,40.7 89.77,40.7 89.45,40.38 JDIMM1.129 ; JDIMM1.12 60.21,32.42 v1(60.1,32.52) ; v1(92.45,40.47) JDIMM1.141 ; JDIMM1.147 95.96,40.32 v1(95.82,40.45) ; JDIMM2.147 173.16,40.22 173.33,40.39 v1(173.33,40.52) ; v1(175.33,40.65) 174.96,40.65 174.65,40.34 JDIMM2.153 ; JDIMM2.135 168.16,40.24 167.87,40.52 167.44,40.52 167.39,40.57 v1(167.39,40.57) 166.96,40.57 166.65,40.27 JDIMM2.129 ; JDIMM2.136 168.41,29.98 168.58,29.8 v1(169.06,29.8) 169.55,29.8 169.91,30.16 JDIMM2.142 ; JDIMM1.136 91.21,29.86 v1(91.29,29.78) 91.4,29.66 92.43,29.66 92.71,29.94 JDIMM1.142 ; JDIMM2.148 173.41,31.03 173.41,30.04 173.6,29.84 174.05,29.84 v1(174.06,29.83) ; JDIMM2.118 163.9,30.14 v1(163.9,29.78) ; JDIMM1.178 103.71,32.26 v1(103.7,32.27) ; v1(185.99,36.99) 186.16,37.16 JDIMM2.199 ; v1(153.14,36.78) 153.16,36.79 JDIMM2.75 ; JDIMM1.54 v1(70.7,32.27) ; JDIMM2.123 165.16,40.26 164.95,40.46 v1(163.66,40.46) 163.66,40.24 163.65,40.24 JDIMM2.117 ; JDIMM2.12 137.41,32.89 v1(137.27,33.03) ; JDIMM1.123 87.96,40.92 87.6,41.27 85.94,41.27 v1(85.74,41.06) ; v1(98.45,40.55) 98.43,40.55 98.42,40.56 97.88,40.56 97.45,40.14 JDIMM1.153 ; JDIMM1.130 89.71,30.12 v1(90.05,29.78) 89.94,29.66 88.51,29.66 88.21,29.97 JDIMM1.124 ; JDIMM2.178 v1(180.91,32.49) ; JDIMM1.241 119.45,40.22 119.15,40.52 v1(118.6,40.52) ; v1(76.45,36.65) 76.45,37.89 75.96,38.39 JDIMM1.75 ; JDIMM2.241 196.66,39.23 v1(196.66,40.46) ; JDIMM1.163 99.96,40.55 v1(99.99,40.58) 99.82,40.74 99.39,40.74 98.96,40.31 JDIMM1.159 ; JDIMM1.148 96.21,30.03 96.51,29.72 v1(96.94,29.72) 97.4,29.72 97.71,30.03 JDIMM1.154 ; JDIMM2.154 174.91,29.87 174.92,29.85 v1(174.92,29.83) 176.2,29.83 176.41,30.03 176.41,31.03 JDIMM2.160 ; v1(113.67,29.7) 114.21,30.23 JDIMM1.220 ; JDIMM2.163 177.16,40.32 v1(176.86,40.61) 176.46,40.61 176.16,40.31 JDIMM2.159 ; v1(81.21,32.52) 81.21,32.51 JDIMM1.96 ; JDIMM2.124 165.41,29.97 165.59,29.78 166.59,29.78 v1(166.65,29.84) 166.91,30.1 JDIMM2.130
  BOTTOM w0.381: UD1.5 92.6,67.89 92.07,67.35 CD32.1 v1(91.82,66.8)
  vias: v3(67.24,44.34)
+1.05VALWP: length 22.3
  TOP w0.254: v1(196.09,111.91) PC307.1 195.57,110.8 195.57,109.93 PR306.1
  IN2 w0.254: v1(178.06,110.23) 180.83,113 195,113 v1(196.09,111.91)
  vias: v1(176.16,110.23) v1(176.79,110.23) v1(177.43,110.23) v3(179.13,109.66)
+1.8V_ANT: length 31.8
  TOP w0.127: v1(304.63,97.92) 305.44,97.11 v3(305.44,96.3)
  TOP w0.356: CZ230.1 304.67,98.63 CZ308.1 CZ234.1 303.79,97.83 303.45,97.49
  TOP w0.508: v1(302.65,106.74) 303.6,106.74 CZ228.1 304.06,106.98 304.53,107.45 v1(304.53,107.61) ; v1(304.63,97.92) 304.73,98.03 CZ230.1 ; v1(300.47,96.38) 299.55,95.46 299.55,94.3 RZ91.2 300.25,94.11 300.25,94.75 301.19,95.69 301.19,97.17 301.5,97.49 303.45,97.49
  IN1 w0.508: v1(302.65,106.74) 299.98,106.74 297.5,104.26 297.5,99.35 v1(300.47,96.38)
+1.8V_ANT_R: length 55.2
  TOP w0.102: v3(297.97,95.27) 298.6,94.65 RZ91.1
  IN1 w0.508: v1(272.57,63.11) 273.61,64.15 284.45,64.15 286.91,66.61 286.91,67.83 287.33,68.26 289.35,68.26 290.28,69.19 291.82,69.19 292.33,69.69 292.33,71.27 291.89,71.71 v1(291.89,72.19)
  IN3 w0.508: v1(291.89,72.19) 291.89,72 292.51,71.39 295.68,71.39 296.42,72.13 296.42,72.38 298.2,74.16 298.2,92.2 298.06,92.34
  BOTTOM w0.305: v1(272.57,63.11) 272.93,63.47 JNGFF2.24
  vias: v1(297.94,93.55) v1(297.94,92.97)
+1.8V_PRIM: length 374.6
  TOP w0.381: v1(148.24,80.32) 148.24,80.16 CC98.1
  TOP w0.508: RZ603.2 177.22,79.45 177.22,80.72 176.9,81.03 RC724.2 176.28,80.78 175.59,80.78 175.58,80.77 v1(175.21,80.77) ; RC733.2 v1(173.35,82.68) ; CC1464.1 157.08,79.38 155.4,77.71 v1(155.4,77.46) ; v1(173.78,83.94) 174.24,84.4 RC842.2 ; v1(160.72,57.14) 160.7,57.17 160.7,57.85 RC244.1
  IN2 w0.508: v1(151.26,71.3) 150.7,71.3 149.93,70.54 149.93,69.97 153.85,66.05 v1(153.85,64.94) ; v1(204.79,36.76) 202.71,36.76 202.38,37.09 200.19,37.09 198.21,39.07 192.62,39.07 191.08,37.52 v1(191.08,33.08)
  IN3 w0.508: v1(153.85,64.94) 156.72,62.07 156.72,58.22 158.5,56.45 159.65,56.45 160.34,57.14 v1(160.72,57.14) 160.72,57.04 161.86,55.9 170.78,55.9 174.95,51.73 v1(176.09,51.73) ; v1(154.34,80.92) 154.52,80.73 154.52,79.42 155.4,78.54 v1(155.4,77.46) 155.09,77.15 153.74,77.15 153.02,76.43 153.02,72.36 151.96,71.3 v1(151.26,71.3)
  IN3 w1.016: 30.68,30.85 31.82,30.85 31.82,30.86 31.95,30.86 32.96,31.87 32.96,36.34 35.64,39.01 44.81,39.01 47.79,41.99 68.6,41.99 69.18,42.57 94.96,42.57 95.99,43.59 133.57,43.59 134.05,43.11 136.53,43.11 138.31,41.33 138.31,40.19 138.88,39.62 170.43,39.62 170.83,39.22 172.85,39.22 173.12,39.49 200.07,39.49 202.5,37.07 203.84,37.07
  IN4 w0.508: v1(191.08,33.08) 190.57,33.58 190.57,38.37 189.16,39.78 189.16,40.96 187.98,42.15 186.84,42.15 177.25,51.73 v1(176.09,51.73)
  IN4 w1.016: 259.09,29.08 252.93,29.08 252.16,28.31 237.05,28.31 235.9,29.46 232.92,29.46 232.24,30.14 222.71,30.14 221.82,31.04 219.68,31.04 218.21,32.51 214.95,32.51 212.52,34.93 211.22,34.93 210.71,34.42 208.25,34.42 208.25,34.42 207.08,34.42 206.06,35.44 206.06,35.49 ; 278.26,28.57 280.23,28.57 281.02,27.78 284.89,27.78 285.63,27.04 287.09,27.04 288.55,25.58 288.55,22.28 291.09,19.74 291.85,19.74
  BOTTOM w0.18: v1(155.4,77.46) 155.27,77.33 UC1.CP23
  BOTTOM w0.203: v1(154.34,80.92) 154.14,81.11 UC1.CP17
  vias: v1(29.09,30.79) v1(29.09,30.22) v1(147.59,82) v1(147.59,80.32) v1(148.24,82) v1(171.58,94.61) v1(172.22,106.1) v1(172.15,94.61) v1(172.54,105.53) v1(172.73,94.61) v1(172.79,106.1) v1(173.11,105.53) v1(173.3,94.61) v1(205.43,36.76) v1(286.77,81.57) v1(286.77,80.96) v1(293.12,19.62) v1(293.76,19.62) v3(172.17,103.79)
+1.8V_PRIM_VTR3: length 13.5
  TOP w0.127: v2(282.66,75.6) RE549.1
  TOP w0.33: UE1.N5 284.25,80.96 284.28,80.98
  TOP w0.381: v1(283.45,73.84) 283.45,73.47 282.9,72.92 RE823.1
  TOP w0.508: v1(283.45,73.84) 283.45,74.38 RE549.1
  IN2 w0.508: v1(284.86,80.83) 284.49,80.45 284.49,77.3 283.7,76.51 283.7,75.6 283.45,75.34 v1(283.45,73.84)
+1.8V_RUN: length 11.8
  IN3 w1.016: 290.52,23.43 290.52,24.31 285.69,29.14 282.26,29.14 281.82,29.58
  vias: v1(280.87,30.85) v1(281.17,30.37) v1(290.39,22.35) v1(290.96,22.35) v3(289.53,23.82)
+1.8V_RUN_AUDIO: length 0.9
  TOP w0.203: UA1.20 281.92,36.53
  vias: v3(285.67,33.34)
+1.8V_RUN_CARD: length 30.8
  TOP w0.508: v1(310.84,66.92) 310.96,66.8 310.89,66.73 310.89,64.08 314.47,60.49 JSD1.15
  IN2 w0.762: 293.95,62.29 296.06,62.29 297.72,63.95 301.18,63.95 302.72,62.41 307.33,62.41 311.47,66.55
  BOTTOM w0.127: v3(293.29,61.84) 293.09,62.04 v1(293.09,62.62)
  vias: v1(292.94,63.18) v1(310.84,67.56)
+1.8V_RUN_UZ8: length 0.8
  TOP w0.127: 291.99,22.54 v3(291.99,21.76)
+1.8VALWP: length 8.5
  TOP w0.127: v1(175.96,103.63) v3(175.96,104.6)
  BOTTOM w0.254: PR501.1 180.16,102.24 PC503.1 180.14,102.21 179.2,101.28 174.69,101.28 174.5,101.47 174.5,102.04
  vias: v1(175.39,103.63)
+1VS_VCCIOP: length 21.4
  TOP w0.254: v1(82.43,28.9) 82.43,28.47 82.72,28.18 PU401.1 ; v1(81.92,24.19) 82.4,23.71 PR421.1
  IN4 w0.254: v1(82.43,28.9) 80.67,28.9 77.91,26.13 75.1,26.13 v1(74.24,25.27)
  BOTTOM w0.254: v1(74.24,25.27) 74.24,24 74.68,23.55 81.29,23.55 v1(81.92,24.19)
  vias: v2(73.36,25.94)
+2.5V_MEM: length 116.7
  TOP w0.127: v1(115.39,28.31) 115.39,27.27 v3(114.78,26.66)
  IN4 w1.016: 129.44,31.03 170.07,31.03 170.2,30.9 171.58,30.9 173.49,28.99 174.95,28.99 176.57,27.36 181.16,27.36 182.43,26.09 184.12,26.09 185.55,27.53 186.57,27.53 187.9,28.86 194.16,28.86 194.29,28.99 196.13,28.99 197.81,30.66 199.33,30.66 199.57,30.9 201.78,30.9 202.74,29.94 204.18,29.94 205.26,31.02 205.26,34.64 201.43,38.47 201.43,39.05 ; 129.44,31.03 127.91,32.57 127.91,38.16 126.89,39.18 125.64,39.18 ; 129.44,31.03 129.31,31.03 126.47,28.19 116.59,28.19
  vias: v1(116.08,28.31) v1(124.5,39.68) v1(124.5,39.05) v1(201.17,40.44) v1(201.68,40.06)
+2.7V_ANT: length 31
  TOP w0.356: 302.63,95.61 302.89,95.87 CZ233.1 CZ307.1 304.08,95.87 304.31,96.09 CZ229.1
  TOP w0.508: v1(304.16,97.38) 304.31,97.23 CZ229.1 ; v1(307.98,106.55) 307.98,106.97 307.46,107.49 v2(306.69,107.49) 306.36,107.49 305.95,107.08 305.48,107.08 305.44,107.04 CZ227.1 305.01,107.04 v1(304.72,106.75) ; 302.63,95.61 302.63,94.09 RZ90.2 301.8,94.47 v1(301.8,96.82)
  IN1 w0.508: v1(301.8,96.82) 298.71,99.91 298.71,103.6 300.61,105.5 305.73,105.5 306.42,106.19 307.63,106.19 v1(307.98,106.55)
+2.7V_ANT_R: length 56
  TOP w0.127: v3(290.33,72.49) 290.62,72.19 v1(291.23,72.19)
  IN1 w0.508: v1(291.23,72.19) 291.23,71.07 289.04,68.88 286.95,68.88 286.3,68.22 286.3,66.86 284.2,64.76 273.06,64.76 271.95,63.65 v1(271.95,63.13)
  IN3 w0.508: 298.98,92.51 299.22,92.27 299.22,74.23 297.06,72.07 297.06,71.81 296,70.76 292.11,70.76 291.24,71.63 291.24,72.16 291.23,72.17 v1(291.23,72.19)
  BOTTOM w0.305: v1(271.95,63.13) 271.93,63.15 JNGFF2.20
  vias: v1(299.29,92.97) v1(299.9,92.97)
+3.3V_5V_RUN_QV8:
  vias: v2(79.6,108.81)
+3.3V_ALS_PWR: length 3.6
  TOP w0.127: RZ1476.1 100.26,111.53 99.74,111.01 v1(99.52,111.01) 99.47,111.01 98.89,111.59 v3(98.89,111.79)
  BOTTOM w0.127: JIRTS1.15 v1(99.52,111.01)
+3.3V_ALW: length 562.1
  TOP w0.254: PC312.2 194.57,111.14 194.57,109.28 194.24,108.94 PU301.15 ; RT68.1 36.94,60.26 v1(37.98,60.26) ; PR307.1 v1(196.93,106.09) ; v1(152.05,107.2) 152.95,107.2 153.21,107.46 UZ35.5 ; v1(50.12,95.45) 50.12,94.69 50.06,94.63 50.06,93.82 50.31,93.56 50.31,91.89 PR4.2 ; PC206.1 219.04,30.11 219.13,30.11 v1(219.4,29.84) 219.64,29.84 219.8,30 PU200.13 ; PR107.1 v1(185.86,95.94)
  TOP w0.305: RZ377.1 267.18,56.27 267.18,53.37 266.4,52.6 266.4,52.07 266,51.67 262.77,51.67 262.34,52.1
  TOP w0.381: v1(179.01,53.28) 178.96,53.28 178.91,53.23 CZ82.1 178.4,53.83 178.46,53.89 UZ6.5 ; UZ54.5 29.46,34.21 28.71,33.46 ; v1(31.76,50.39) 30.52,50.39 29.22,49.08 29.22,47.17 27.72,45.68 CT360.1 26.18,45.18 25.64,45.18 UT34.5 ; PR417.1 183.98,31.88 PR418.1 181.59,31.88 180.11,30.41 179.58,30.41 179.2,30.03 v1(179.2,29.71) ; PR865.2 49.96,95.61 v1(50.12,95.45) 50.18,95.45 50.5,95.76 PR28.2 ; RE809.2 281.63,72.06 281.63,70.95 281.24,70.57 280.68,70.57 RE12.2 ; v1(247.59,31.43) 247.59,31.9 CZ91.1 ; v1(195.08,110.69) 195.15,110.76 195.15,111.16 PC314.2 PC312.2 ; UZ10.5 308.52,69.56 308.68,69.4 309.32,69.4 CZ93.1 309.4,68.91 v1(309.25,68.76) ; RE562.2 289.78,91.86 RE804.2 ; 42.95,102.43 43.75,102.43 v1(44.28,101.91) 44.49,101.7 44.49,100.9 44.18,100.58 43.01,100.58 PR821.2 ; 42.95,102.43 PR852.1 ; 42.95,102.43 43.56,103.05 PR851.1 ; PC226.1 PC206.1 ; UZ1.2 172.7,111.57 173.5,110.76 CZ94.1 174.31,110.76 174.69,111.14 v1(174.69,111.56) ; RE301.2 271.85,91.81 v1(271.28,92.39) ; v1(272.71,73.93) 272.63,73.86 RE362.1
  TOP w0.508: v1(243.97,38.35) 245.05,37.27 245.05,33.33 246.96,31.43 v1(247.59,31.43) ; PR824.1 PR838.1 35.54,106.59 v1(35.2,106.59) 34.89,106.59 PR825.1 ; RE809.2 281.44,72.24 281.06,71.86 v1(281.06,71.67) ; RE365.2 270.26,91.84 269.77,92.33 v1(269.25,92.33) ; v1(291.81,97.29) 291.91,97.39 RE74.1 RE73.1 ; v1(282.39,91.33) 282.17,91.33 281.96,91.12 RE38.2 ; v1(278.11,92.54) 278.09,92.56 RE83.2 ; PR410.1 178.43,23.79 177.92,24.3 v1(177.92,24.86) ; v1(285.44,95.75) RE821.2 RE300.1 ; RE343.1 273.69,72.07 v1(273.37,71.75) ; CE60.1 RE92.2 ; v1(228.92,28.65) 229.58,27.99 229.58,26.44 228.92,25.77 228.92,23.92 228.43,23.43 216.76,23.43 216.11,24.08 216.11,26.35 216.36,26.6 PR205.1 ; RE91.2 265.08,83.99 266.65,83.99 v1(269.43,86.76) ; v1(231.57,42.87) 231.57,40.15 232.73,38.98 232.73,33.66 233.46,32.93 v1(233.46,32.75) 233.46,32.3 PR1.1 ; PR413.1 89.27,25.25 v1(89.29,25.27) 89.3,25.25 PR414.1 ; v1(289.79,92.45) RE562.2 ; RE704.2 v1(289.01,97.29) ; RE63.2 v1(275.83,97.29) ; RC431.2 174.18,64.2 RC432.1 173,64.53 v1(173,64.82) ; PR404.1 80.02,28.91 80.26,28.67 80.26,27.83 v1(80.16,27.73) ; PR821.2 42.78,100.64 PQ807.2 41.55,100.46 v1(41.55,99.85) ; v1(43.82,47.7) 43.82,48.24 PR726.1 ; v1(295.22,32.06) 295.22,31.3 294.07,30.16 v3(291.95,30.16) 284.8,30.16 284.36,29.71 279.13,29.71 277.5,31.34 277.5,31.77 276.61,32.66 275.33,32.66 274.88,32.21 274.88,31.19 273.76,30.07 273.24,30.07 v1(272.75,30.56) 272.62,30.43 272.12,30.43 RZ8.1 RZ9.1 ; v1(277.68,91.94) 277.84,91.78 277.84,91.18 277.84,91.18 RE84.2 ; RE803.2 v1(290.66,92.44) ; v1(287.28,84.79) 287.82,84.25 RE525.2 RE524.2 ; v1(293.57,95.82) 293.57,95.6 293.34,95.38 RE75.1 ; v1(296.17,93.97) 296.5,93.64 RE71.1 RE813.1 RE816.1 RE814.1 RE815.1 ; v1(267.63,92.46) RE526.2 ; v1(283.6,91.61) 283.41,91.42 RE35.2 ; RE606.2 v1(277.08,95.37) ; RE72.1 293.99,93.66 v1(294.2,93.44) ; RE561.2 288.46,77.96 RE37.2 RE43.2 287.95,75.85 RE807.2 288.49,75.31 v1(288.49,75.24) 288.49,75.11 287.99,74.62 RE808.2 ; v1(289.12,94.57) 289.06,94.51 RE8.2 ; RE21.2 v1(266.6,92.46) ; RZ1482.2 v1(299.62,5.51) ; RE505.2 RE68.2 278.55,68.81 RE806.2 278.47,68.38 278.69,68.16 v1(278.69,68.15) ; RC68.2 159.61,55.55 v1(159.61,55.02) ; PR833.1 PR839.1 42.42,107.11 v1(42.42,107.5) ; RE79.1 v1(280.24,97.61) ; v1(290.63,83.36) 290.3,83.36 290.25,83.42 RE532.2 ; RE11.2 v1(272.71,73.93) ; v1(39.55,105.74) 38.88,105.07 PR828.1 PR830.1 ; RE302.2 RE303.2 264.94,73.26 264.52,72.84 264.52,72.01 265.73,70.8 265.73,68.59 266.5,67.82 269.65,67.82 269.67,67.8 v1(269.8,67.8) ; RE10.2 v1(275.2,96.58) ; RE25.1 288.98,91.83 RE804.2 ; RE605.2 v1(290.58,94.63) ; PR113.1 v1(46.78,31.73)
  IN1 w0.254: v1(185.86,95.94) 185.86,95.82 187.01,94.67 v1(187.01,91.81)
  IN1 w0.508: v1(247.59,31.43) 247.59,31.24 248.17,30.66 248.99,30.66 250.31,29.35 253.14,29.35 253.76,29.97 255.26,29.97 255.91,29.32 259.78,29.32 260.42,29.97 262.17,29.97 262.31,30.11 264.56,30.11 265.51,31.05 266.25,31.05 v1(266.71,31.5) ; v1(174.69,111.56) 174.69,109.72 178.89,105.53 178.89,103.75 180.54,102.1 181.49,102.1 ; v1(228.92,28.65) 229.77,28.65 231.94,30.82 231.94,31.2 233.46,32.73 v1(233.46,32.75) ; v1(42.42,107.5) 41.32,106.39 40.4,106.39 39.75,105.74 v1(39.55,105.74) 36.45,105.74 35.6,106.59 v1(35.2,106.59)
  IN1 w0.762: 28.47,92.13 29.41,92.13 31.36,94.09 31.36,98.25 31.26,98.36 31.26,105.67 33.53,107.94 36.8,107.94 37.92,109.06 40.86,109.06 v1(42.42,107.5)
  IN2 w0.508: v1(266.71,31.5) 266.71,30.89 267.52,30.08 269.36,30.08 269.84,30.56 v1(272.75,30.56) ; v1(309.25,68.76) 308.64,68.15 307.64,68.15 304.62,71.18 300.68,71.18 298.08,73.78 296.87,73.78 296.61,74.03 v1(296.61,74.61)
  IN2 w1.016: 124.78,28.51 124.64,28.37 118.36,28.37 114.03,24.04 94.06,24.04 90.48,27.63 87.9,27.63 86.23,25.95 82.14,25.95 80.36,27.73 v1(80.16,27.73)
  IN3 w0.508: v1(295.22,32.06) 295.22,31.93 295.73,31.43 297,31.43 297.25,31.68 v1(297.25,32.06) 298.27,31.05 298.27,28.06 301.3,25.03 301.3,22.04 303.7,19.64 303.7,13.81 302.57,12.68 302.57,5.12 302.04,4.59 301.12,4.59 300.21,5.51 v1(299.62,5.51) ; v1(228.92,28.65) 228.27,28.65 227.53,29.39 219.84,29.39 v1(219.4,29.84) ; v1(309.17,92.3) 308.02,93.45 308.02,95.61 306.98,96.65 303.85,96.65 302.77,97.73 299.79,97.73 296.17,94.11 v1(296.17,93.97) ; v1(28.96,32.7) 30.87,34.6 30.87,35.54 29.97,36.44 29.97,40.35 30.5,40.89 36.14,40.89 v1(37.28,42.03)
  IN4 w0.508: v1(37.98,60.26) 37.98,61.46 40.01,63.49 40.01,68.03 39.36,68.67 v1(39.36,69.35) ; v1(186.06,103.82) 185.74,104.13 185.74,105.94 188.09,108.29 191.2,108.29 192.86,106.64 192.86,106.15 193.82,105.19 194.96,105.19 195.87,106.09 v1(196.93,106.09) 196.93,107.88 v1(196.66,108.15) 196.22,108.59 196.22,109.54 v1(195.08,110.69) ; v1(174.31,26.28) 176.43,24.16 177.41,24.16 177.92,24.67 v1(177.92,24.86)
  BOTTOM w0.254: v1(297.25,32.06) 297.45,31.86 JAPS1.3 ; v1(295.22,32.06) 295.45,31.83 JAPS1.7 ; UE4.6 183.09,83.43 182.8,83.73 182.44,83.73 181.91,84.26 CE61.1
  BOTTOM w0.305: v1(247.59,31.43) 247.58,31.44 JKBTP1.6
  BOTTOM w0.381: UE3.5 179.85,81.12 CE53.1 179.88,81.39 179.54,81.72 v1(179.39,81.72) ; UE5.5 177.19,81.12 CE52.1 177.71,81.15 v1(177.79,81.06) ; v1(39.36,69.35) 39.36,68.84 40.05,68.15 CT237.1 40.27,67.68 40.04,67.46 UT32.5 ; RT483.1 34.17,51.31 33.24,50.39 v1(31.76,50.39)
  BOTTOM w0.508: QZ18.3 309.17,93.67 RZ1390.2 v1(309.17,92.3) ; v1(296.61,74.61) 295.98,74.61 295.48,75.1 293.6,75.1 292.49,76.21 292.49,76.77 291.79,77.46 291.22,77.46 290.33,78.35 288.61,78.35 ; 288.61,78.35 288.61,81.27 289.25,81.91 289.25,83.36 ; 288.61,78.35 287.98,77.72 287.98,75.75 v1(288.49,75.24) ; 181.68,96.07 178.19,96.07 178.06,96.2 177.98,96.2 RE69.1 ; RZ518.1 249.31,40.43 249.49,40.25 v1(249.67,40.25) ; PR313.2 195.51,107.69 196.02,108.2 196.61,108.2 v1(196.66,108.15) ; PR956.2 36.77,41.52 v1(37.28,42.03) ; 289.25,83.36 287.79,83.36 287.28,83.87 v1(287.28,84.79) ; 289.25,83.36 v1(290.63,83.36) ; v1(243.97,38.35) 243.97,40.05 244.89,40.96 246.04,40.96 246.83,40.18 246.83,37.93 247.91,36.85 249.28,36.85 249.9,37.47 RZ1483.1 ; CE61.1 181.91,85.06 v1(182.02,85.17) ; v1(80.16,27.73) 81.66,26.22 82.19,26.22 83.97,24.44 87.88,24.44 88.7,25.27 89.29,25.27 v1(89.29,25.27) ; v1(291.81,97.29) 294.95,97.29 296.17,96.07 v1(296.17,93.97) ; CV17.1 101.14,100.03 v1(101.14,99.55)
  BOTTOM w0.762: v1(42.42,107.5) 42.42,106.12 44.14,104.4 44.14,103.12
  vias: v1(27.18,91.94) v1(27.57,92.39) v1(27.76,32.7) v1(27.76,32.06) v1(28.33,32.7) v1(28.33,32.06) v1(28.96,32.06) v1(44.75,102.29) v1(100.72,99.12) v1(103,99.24) v1(125.55,29.08) v1(126.12,29.08) v1(170.5,66.16) v1(170.5,65.56) v1(171.01,65.91) v1(173.68,26.92) v1(174.25,26.92) v1(181.87,97.91) v1(181.87,97.28) v1(181.87,96.64) v1(182.51,97.91) v1(182.51,97.28) v1(182.51,96.64) v1(185.81,92.2) v1(185.81,91.56) v1(185.81,90.99) v1(185.81,90.35) v1(185.81,89.72) v1(186.06,103.22) v1(186.44,92.2) v1(186.44,91.56) v1(186.44,90.99) v1(186.44,90.35) v1(186.44,89.72) v1(186.66,103.82) v1(186.66,103.22) v1(187.01,91.18) v1(187.01,90.54) v1(187.01,89.91) v1(190.19,45.08) v1(190.82,45.02) v1(261.18,53.97) v1(261.18,53.38) v1(261.82,53.97) v1(261.82,53.38) v1(262.45,53.97) v1(264.61,47.86) v1(264.79,47.31) v1(264.98,48.3) v1(265.4,47.89) v1(265.4,47.31) v1(267.33,31.52) v1(274.26,69.85) v1(275.54,70.23) v3(262.3,52.58) v3(263.21,46.92)
