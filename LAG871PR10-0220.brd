# Allegro board LAG871PR10-0220.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RZ56  0_0201_5%  [R0201_0OHM]  260.89 43.43 0 top
RZ58  49.9_0402_1%  [R_0402]  187.14 75.99 90 top
RZ59  49.9_0402_1%  [R_0402]  186.12 75.99 90 top
RZ60  49.9_0402_1%  [R_0402]  184.03 74.78 90 top
RZ61  0_0201_5%  [R0201_0OHM]  185.43 74.28 90 top
RZ63  33_0402_5%  [R_0402]  182.52 78.23 180 bottom
RZ64  0_0201_5%  [R0201_0OHM]  184.93 93.78 180 top
RZ69  10K_0402_5%  [R_0402]  179.2 77.22 270 top
RZ70  0_0201_5%  [R_0201]  251.94 37.46 0 bottom
RZ71  0_0201_5%  [R_0201]  251.65 40.75 0 bottom
RZ76  0_0201_5%  [R_0201]  276.42 61.42 90 top
RZ77  0_0201_5%  [R_0201]  277.08 61.44 90 top
RZ78  0_0201_5%  [R_0201]  269.28 38.84 180 top
RZ79  0_0201_5%  [R_0201]  269.28 38.08 180 top
RZ80  0_0201_5%  [R_0201]  269.28 37.32 180 top
RZ89  0_0402_5%  [R_0402]  179.14 82.91 90 top
RZ90  0_0603_5%  [R_0603]  301.01 93.86 0 top
RZ91  0_0603_5%  [R_0603]  298.6 93.86 0 top
RZ112  0_0201_5%  [R0201_0OHM]  187.91 81.9 180 top
RZ114  0_0201_5%  [R0201_0OHM]  271.7 32.23 90 top
RZ116  10K_0402_5%  [R_0402]  252.36 34.87 0 bottom
RZ117  10K_0402_5%  [R_0402]  252.36 35.64 0 bottom
RZ119  0_0402_5%  [R_0402]  143.29 48.24 90 top
RZ120  0_0201_5%  [R0201_0OHM]  148.63 47.24 180 top
RZ128  0_0201_5%  [R_0201]  279.3 62.12 270 top
RZ129  0_0201_5%  [R_0201]  280.63 62.12 270 top
RZ130  0_0201_5%  [R_0201]  281.14 59.58 270 top
RZ151  0_0603_5%  [R_0603]  143.07 106.42 270 top
RZ320  0_0201_5%  [R_0201]  150.11 109.24 270 top
RZ326  0_0201_5%  [R_0201]  273.18 57.28 270 top
RZ334  51_0402_5%  [R_0402]  291.6 56.74 90 top
RZ335  15K_0402_5%  [R_0402]  290.95 56 0 top
RZ345  0_0201_5%  [R0201_0OHM]  295.78 18.19 90 top
RZ346  0_0201_5%  [R0201_0OHM]  254.7 29.5 270 top
RZ347  0_0201_5%  [R0201_0OHM]  249.31 28.58 90 top
RZ350  0_0201_5%  [R0201_0OHM]  313.29 94.63 270 bottom
RZ351  0_0201_5%  [R0201_0OHM]  313.9 94.63 270 bottom
RZ361  150_0402_5%  [R_0402]  310.11 6.71 180 top
RZ362  10K_0402_5%  [R_0402]  188.36 82.8 180 top
RZ372  0_0201_5%  [R_0201]  280 62.12 270 top
RZ373  0_0201_5%  [R_0201]  280.51 59.58 270 top
RZ374  0_0201_5%  [R_0201]  278.66 62.12 270 top
RZ377  100K_0402_5%  [R_0402]  267.37 56.46 0 top
RZ379  20K_0402_5%  [R_0402]  250.17 38.45 0 bottom
RZ380  0_0201_5%  [R0201_0OHM]  311.02 94.02 270 bottom
RZ388  0_0201_5%  [R0201_0OHM]  49.62 105.95 90 top
RZ400  10K_0402_5%  [R_0402]  179.16 58.6 270 top
RZ401  1K_0402_5%  [R_0402]  178.4 58.6 270 top
RZ518  100K_0402_5%  [R_0402]  248.83 40.43 180 bottom
RZ603  10K_0402_5%  [R_0402]  177.35 78.4 90 top
RZ752  10K_0402_5%  [R_0402]  268.36 35.79 0 top
RZ827  0_0201_5%  [R_0201]  268.62 55.61 0 top
RZ1381  22_0402_5%  [R_0402]  254.55 48.11 180 bottom
RZ1383  22_0402_5%  [R_0402]  254.55 47.22 180 bottom
RZ1385  0_0201_5%  [R0201_0OHM]  264.98 51.23 180 top
RZ1388  0_0201_5%  [R_0201]  313.21 96.69 90 top
RZ1389  0_0201_5%  [R_0201]  313.85 96.69 90 top
RZ1390  0_0402_5%  [R_0402]  308.26 93.02 0 bottom
RZ1391  0_0402_5%  [R_0402]  307.37 93.96 270 bottom
RZ1392  100K_0201_5%  [R_0201]  312.86 97.76 180 bottom
RZ1407  0_0201_5%  [R_0201]  188.32 81.27 180 top
RZ1408  0_0402_5%  [R0402_0OHM]  178.33 85.8 270 top
RZ1409  0_0402_5%  [R_0402]  178.31 83.22 90 top
RZ1410  0_0402_5%  [R_0402]  186.9 86.54 180 top
RZ1411  0_0201_5%  [R0201_0OHM]  257.97 30.98 0 top
RZ1413  330K_0402_5%  [R_0402]  299.62 8.21 90 top
RZ1414  0_0201_5%  [R_0201]  257.97 31.62 0 top
RZ1415  0_0201_5%  [R0201_0OHM]  301.63 7.19 270 top
RZ1416  0_0201_5%  [R_0201]  137.93 110.97 270 top
RZ1417  0_0201_5%  [R_0201]  138.94 110.97 270 top
RZ1418  0_0201_5%  [R_0201]  148.63 46.41 180 top
RZ1419  0_0201_5%  [R_0201]  148.63 48.06 180 top
RZ1420  0_0201_5%  [R0201_0OHM]  154.31 109.95 270 top
RZ1422  100K_0402_5%  [R_0402]  155.08 109.03 90 top
RZ1423  0_0201_5%  [R0201_0OHM]  139.64 110.97 270 top
RZ1450  470_0402_1%  [R_0402]  282.33 61.22 270 top
RZ1460  0_0201_5%  [R0201_0OHM]  304.87 105.43 90 top
RZ1461  0_0201_5%  [R0201_0OHM]  303.23 94.09 0 top
RZ1470  0_0201_5%  [R0201_0OHM]  62.35 111.31 0 top
RZ1471  0_0201_5%  [R_0201]  31.58 33.23 180 top
RZ1472  100K_0402_5%  [R_0402]  27.43 30.41 0 top
RZ1473  0_0201_5%  [R_0201]  277.6 31.87 180 bottom
RZ1474  100K_0402_5%  [R_0402]  28.34 31.24 180 top
RZ1475  0_0201_5%  [R0201_0OHM]  248.61 29.99 90 top
RZ1476  0_0603_5%  [R_0603]  100.26 112.01 0 top
RZ1477  0_0201_5%  [R_0201]  270.44 64.07 90 top
RZ1482  1M_0402_5%  [R_0402]  299.62 7.31 270 top
RZ1483  20K_0402_5%  [R_0402]  250.3 37.47 0 bottom
SHDCAN  -  [SION_C7521R_1P-T]  20.23 63.4 180 bottom
SW1  SSAJ120100_3P  [SW_SSAJ120100_3P]  302.82 28.17 270 bottom
SW3  SKRBACE010_4P  [SW_T4BJB26BQR_4P]  308.54 104.4 0 top
T1  PAD~D  [TPC12]  125.1 95.12 0 top
T2  PAD~D  [TPC12]  123.65 95.51 0 top
T12  PAD~D  [TPC12]  146.67 71.84 0 top
T16  PAD~D  [TPC12]  104.98 66.22 180 bottom
T17  PAD~D  [TPC12]  104.83 68.43 180 bottom
T18  PAD~D  [TPC12]  156.53 68.13 0 top
T19  PAD~D  [TPC12]  157.57 67.15 0 top
T20  PAD~D  [TPC12]  139.86 66.48 180 bottom
T21  PAD~D  [TPC12]  142.03 81.53 270 top
T50  PAD~D  [TPC12]  100.16 29.2 0 top
T51  PAD~D  [TPC12]  101.01 33.51 0 top
T54  PAD~D  [TPC12]  179.98 39.36 0 top
T55  PAD~D  [TPC12]  178.14 38.58 0 top
T219  PAD~D  [TPC12]  31.3 57.68 180 top
T220  PAD~D  [TPC12]  30.63 56.42 0 top
T341  PAD~D  [TPC12]  268.46 81.67 0 top
T348  PAD~D  [TPC12]  284.55 74.48 0 top
T350  PAD~D  [TPC12]  114.77 61.7 0 top
T351  PAD~D  [TPC12]  114.77 58.4 0 top
T353  PAD~D  [TPC12]  118.88 74.16 0 top
T354  PAD~D  [TPC12]  118.87 72.83 0 top
T355  PAD~D  [TPC12]  130.52 98.33 180 bottom
T360  PAD~D  [TPC12]  158.5 91.56 180 bottom
T361  PAD~D  [TPC12]  141.67 66.21 180 bottom
T363  PAD~D  [TPC12]  142.97 66.21 180 bottom
T364  PAD~D  [TPC12]  103.62 70.19 180 bottom
T365  PAD~D  [TPC12]  103.57 68.88 180 bottom
T366  PAD~D  [TPC12]  118.62 95.88 180 bottom
T367  PAD~D  [TPC12]  119.42 94.8 180 bottom
T368  PAD~D  [TPC12]  119.64 75.69 0 top
T369  PAD~D  [TPC12]  117.46 76.45 0 top
T371  PAD~D  [TPC12]  133.23 83.69 0 top
T372  PAD~D  [TPC12]  134.82 76.17 0 top
T373  PAD~D  [TPC12]  133.23 84.39 0 top
T374  PAD~D  [TPC12]  133.91 76.19 0 top
T375  PAD~D  [TPC12]  147.68 65.97 180 bottom
T376  PAD~D  [TPC12]  147.59 62.62 0 top
T377  PAD~D  [TPC12]  146.42 62.01 0 top
T380  PAD~D  [TPC12]  146.44 64.61 0 top
T381  PAD~D  [TPC12]  146.21 70.43 0 top
T383  PAD~D  [TPC12]  153.08 67.34 0 top
T388  PAD~D  [TPC12]  148.15 74.49 0 top
T389  PAD~D  [TPC12]  149.82 74.17 0 top
T390  PAD~D  [TPC12]  285.12 82.75 0 top
T391  PAD~D  [TPC12]  284.28 83.73 0 top
T395  PAD~D  [TPC12]  146.42 63.29 0 top
T396  PAD~D  [TPC12]  146.75 65.97 180 bottom
T397  PAD~D  [TPC12]  147.57 63.99 0 top
T399  PAD~D  [TPC12]  286.6 78.34 0 top
T404  PAD~D  [TPC12]  157.95 75.99 180 bottom
T405  PAD~D  [TPC12]  161.16 75.42 180 bottom
T408  PAD~D  [TPC12]  158.59 79.8 180 bottom
T409  PAD~D  [TPC12]  157.28 79.78 180 bottom
T410  PAD~D  [TPC12]  156 79.8 180 bottom
T411  PAD~D  [TPC12]  159.91 79.79 180 bottom
T412  PAD~D  [TPC12]  161.28 79.85 180 bottom
T415  PAD~D  [TPC12]  164.88 74.34 0 top
T416  PAD~D  [TPC12]  166.49 75.11 0 top
T417  PAD~D  [TPC12]  159.66 88.23 0 top
T418  PAD~D  [TPC12]  311.85 94.32 270 bottom
T419  PAD~D  [TPC12]  166.16 73.36 0 top
T420  PAD~D  [TPC12]  157.94 77.46 180 bottom
T421  PAD~D  [TPC12]  165.31 82.54 0 top
T422  PAD~D  [TPC12]  144.66 62.45 0 top
T423  PAD~D  [TPC12]  153.75 70.17 0 top
T452  PAD~D  [TPC12]  157.32 64.57 0 top
UA1  ALC3254-VA3-CG_MQFN48_6X6  [ALC3254-CG_MQFN48_6X6]  278.27 42.64 0 top
UC1  WHL-U42_BGA1528  [WHL-U42_BGA_1528P-T]  109.32 91.16 270 bottom
UC5  -  [GD25B256DYIG_WSON8_8X6]  198.18 59.97 90 top
UC6  GD25B127DSIGR_SO8  [W25Q128JVSIQ_SO8]  189.5 66.85 90 bottom
UC7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  197.15 73.97 180 top
UC9  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  177.04 82.92 0 bottom
UD1  74AUP1G07SE-7_TSSOP5  [74AUP1G07GW_TSSOP5]  94.98 67.89 270 bottom
UE1  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  272.62 77.76 90 top
UE3  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  179.85 78.16 180 bottom
UE4  -  [74AUP1G07FZ4-7_X2-DFN1410-6]  183.09 82.33 180 bottom
UE5  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  177.19 78.16 180 bottom
UI1  -  [SY6288D20AAC_SOT23-5]  26.8 41.96 90 bottom
UI3  -  [SLGC55544CVTR_TQFN16_3X3]  292.29 77.06 270 top
UR1  RTS5242-GR_QFN32_4X4  [RTS5242-GR_QFN32_4X4-S]  290.33 67.94 0 top
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  21.72 82.53 270 bottom
UT2  -  [W25Q80DVSSIG_SO8]  38.9 78.43 0 bottom
UT5  SN1804044ZBHR_NFBGA96  [TPS65982_BGA_96P]  33.77 55.99 90 bottom
UT6  GD25Q80CSIGR_SO8  [W25Q80DVSSIG_SO8]  38.28 46.71 270 bottom
UT7  AP2112K-3.3TRG1_SOT23-5  [AP2112K-3P3TRG1_SOT23-5]  23.86 90.79 180 bottom
UT8  AP2204R-5.0TRG1_SOT89-3  [AP2204R-5P0TRG1_SOT89-3]  24.68 29.29 90 bottom
UT32  -  [TS5A3159ADCKR_SC70-6]  40.69 65.18 180 bottom
UT34  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  23.25 45.67 270 top
UV2  -  [AP2330W-7_SC59-3]  24.57 46.22 90 bottom
UV24  -  [G527ATP1U_TSOT23-6]  105.07 99.18 270 bottom
UZ1  -  [APX8131AI-TRG_SOT23-3]  171.73 110.41 0 top
UZ3  EM5209VF_SON14_2X3  [TPS22966DPUR_SON14_2X3-S]  182.27 93.14 90 top
UZ5  EM5209VF_SON14_2X3  [TPS22966DPUR_SON14_2X3-S]  293.43 50.16 0 top
UZ6  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  178.46 56.29 180 top
UZ8  AOZ1336_DFN8_2X2  [AOZ1336_DFN8_2X2-S]  293.38 20.46 0 top
UZ10  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  308.52 71.61 180 top
UZ12  ST33HTPH2032AHC1_VQFN32_5X5  [ST33HTPH2E32AHB4_VQFN32_5X5]  184.91 83.43 270 top
UZ19  -  [EM5201V_DFN8_3X3]  142.93 111.07 180 top
UZ21  -  [EM5201V_DFN8_3X3]  147.75 111.07 180 top
UZ27  -  [EM5201V_DFN8_3X3]  144.6 46.46 0 top
UZ29  -  [HD3SS3212RKSR_VQFN20_2P5X4P5]  244.05 41.62 180 top
UZ35  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  153.21 109.97 180 top
UZ43  EM5209VF_SON14_2X3  [TPS22966DPUR_SON14_2X3-S]  258.19 53.24 0 top
UZ47  -  [EM5209VF_DFN14_3X2]  267.74 44.29 180 top
UZ53  AOZ1336_DFN8_2X2  [AOZ1336_DFN8_2X2-S]  26.85 32.41 90 top
UZ54  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  31.31 34.86 90 top
WC1  DEREN_40-42251-01001RHF  [DEREN_40-42251-01001RHF_10P-T]  46.83 39.69 195 bottom
YC1  24MHZ_12PF_8Y24000034  [Y_8Y24000034_4P]  159.9 94.63 180 bottom
YC2  32.768KHZ_12.5PF_9H03200042  [Y_9H03200042_2P]  152.86 57.77 0 top
YE1  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  267.87 76.58 90 top
YT1  25MHZ 20PF FL2500123Z  [Y_7V25000034_4P]  21.26 64.66 180 bottom

## Library data of the parts
CA1-CA4 CA9 CA10 CA12 CA13 CA19 CA22-CA25 CA27 CA28 CA33 CA41 CA43-CA48 CA51-CA61 CA69 CA73 CA74 CC1479 CZ125-CZ128 = CAP NP: room: CODEC
CA5 CA6 CA62 CA72 = CAP NP: room: CAMERA
CA7 CV1-CV6 CV11-CV14 CV17 CV632 CV633 CV651 CZ2 CZ202 CZ309 = CAP NP: room: LCD
CA8 CA29 CA31 CA35 CA49 CA76 CA77 CC24 CC25 CC28 CC29 CC31 CC65-CC70 CC72 CC73 CC75 CC76 CC78 CC80 CC83 CC85 CC86 CC96 CC98 CC100 CC102-CC104 CC195 CC269 CC279 CC280 CC303-CC307 CC326 CC334 CC430 CC1455-CC1471 CC1477 CC1478 CC1480 CD9-CD16 CD18 CD19 CD23-CD25 CD41-CD48 CD50 CD51 CD55-CD57 CD69-CD72 CE12 CE14 CE16 CE17 CE30-CE32 CE63 CN61 CN62 CN77 CN79-CN82 CN84 CN86 CR5 CR15 CR18 CR20 CR22 CT2-CT9 CT22 CT67-CT69 CT74-CT78 CT83 CT84 CT89 CT90 CT95-CT98 CT123-CT130 CT193 CT326-CT329 CT359 CV15 CV16 CV20 CV21 CV41 CV54 CV55 CV634 CV652 CV751 CV752 CV757 CV758 CZ3 CZ32 CZ94 CZ100 CZ102 CZ105 CZ154 CZ156 CZ206 CZ207 CZ218 CZ227-CZ230 CZ233 CZ234 CZ307 CZ308 CZ311 CZ312 PC756 PC759 = CAP NP
CA63-CA68 CE59 CE60 CI43-CI46 CR25-CR28 CT10-CT19 CT25-CT57 CT59-CT64 CT99-CT102 CT168-CT177 CT189 CT190 CT201-CT204 CV18 CV19 CV22-CV25 CZ41 CZ57 CZ58 CZ62 CZ63 CZ83-CZ89 = CAP NP: room: TBT
CC9 CC10 CC316 CC318-CC320 CC1452 CC1453 CC1476 CE57 CT1 CT70 CT237 CT360 = CAP NP: room: SPI ROM
CC21-CC23 CC26 CC27 CC32-CC42 CC45 CC46 CC51 CC52 CC71 CC234-CC237 CC266 CC300-CC302 CC331-CC333 CC1454 CE61 CV755 CZ113 = CAP NP: room: CPU
CC77 CC95 = CAP NP: room: SOC
CC84 CZ50-CZ56 CZ75 = CAP NP: room: TPM
CC93 = CAP NP: room: EDP
CC196 CN60 CZ64 CZ66-CZ69 CZ71-CZ73 = CAP NP: room: USH
CC288 CC299 = CAP NP: room: CPU XDP
CC340 CZ200 CZ220 = P_CAP NP: room: CAMERA
CD1-CD8 CD20-CD22 CD26-CD29 CD31-CD40 CD52-CD54 CD58-CD63 CD66 = CAP NP: room: MEMORY
CD17 CD49 CI1 CI14 = CAP WP
CE3 CE4 CE10 CE11 CE13 CE15 CE18-CE29 CE35-CE40 CE46 CE47 CE52-CE54 CE62 CE64-CE68 CZ80 CZ81 = CAP NP: room: KBC
CE8 = CAP NP: room: SIO
CI3-CI7 = CAP NP: room: USB2
CI13 CI16 CI17 CI19 CI31 CI33 CI34 = CAP NP: room: USB1
CI32 CI103 = CAP WP: room: USB1
CLIP1-CLIP17 SHDCAN = EMIST_SUL-12A2M_0
CMOS1 = OPEN: User Part Number: PART#; room: PCH
CN63-CN72 CN87 = CAP NP: room: SATA EXPRESS
CN78 CV756 CZ17-CZ21 CZ23-CZ25 CZ150-CZ153 CZ155 CZ198 CZ204 CZ205 CZ210 CZ211 = CAP NP: room: WWAN
CR1-CR4 CR6 CR7 CR11-CR14 CR17 CR19 CR21 = CAP NP: room: RTS5242
CT20 CT21 = CAP NP: room: LAN
CT71-CT73 CT80 CT81 CT85-CT88 CT91 CT92 = CAP NP: room: PD
CT82 CT94 = P_CAP NP: room: PD
CV31-CV40 = CAP NP: room: HDMI
CV635 = P_CAP NP: room: TOUCH
CV750 CV753 CV754 = CAP NP: room: GPU
CZ12 CZ13 CZ27-CZ31 CZ33-CZ36 = CAP NP: room: WLAN
CZ26 = CAP WP: room: WWAN
CZ37-CZ40 = CAP NP: room: SIM
CZ82 = CAP NP: room: RSMRST
CZ90-CZ92 = CAP NP: room: KBTP
CZ93 = CAP NP: room: LED
CZ101 = CAP NP: room: +1.0V_VCCST
CZ106 = CAP NP: room: +1.0V_VCCSTG
CZ109 CZ122 = CAP NP: room: UZ2
CZ112 CZ114 CZ115 = CAP NP: room: UZ3
CZ116-CZ119 CZ124 = CAP NP: room: UZ4
CZ120 CZ121 CZ197 CZ305 CZ306 = CAP NP: room: UZ8
CZ303 = CAP NP: room: +VCC_SFR_OC
DA1 DA3 = L03ESDL5V0CC3-2_SOT23-3: room: CODEC
DA2 = AZ5125-02S.R7G_SOT23-3
DA6 DA7 PD1 PD2 PD4 PD901 PD902 = L03ESDL5V0CG3-2_SOT-523-3
DA8 DC1 DC2 DE2 DV11 DV12 DZ1 DZ2 DZ5 DZ6 DZ8 DZ12 = RB751S-40_SOD523-2
DC4 = P_RB521CM-30T2R_SOD923-2
DD1 DI2 DI5 DV13 DV14 DZ10 DZ11 DZ21 = P_CEST523NC5VB_SOT-523-3
DE1 = P_BZV55-B5V1_SOD80C2
DI1 DI4 DZ13-DZ15 = AZ1045-04F_DFN2510P10E-10-9
DT1-DT3 = 1N4148WS-L_SOD323-2
DT4 = AZ4A24-01F.R7G_DFN0603P2Y2
DT5 DT6 DT9 DT10 DT13 DT14 DT17 DT18 = ESD8011MUT5G_X3DFN2-2
DT39 DT40 = L05ESDL5V0NA-4_SLP2510P8-10-9: room: JUSB2
DV1 DV2 DZ9 = BAT54CW_SOT323-3~D: room: LCD
DV3 = BAT54CT-7-F_SOT523-3
FD1-FD4 = FIDUCIAL MARK: room: LED
FV1 FZ2 = 1A_65V_T0603FF1000TM
FV2 FZ1 = 0.5A_65V_T0603FF0500TM
H1-H5 H8 H11-H18 H20 H21 H27-H31 = HOLE: room: LED
JANT1 JANT2 = I-PEX_20854-005E-00
JAPS1 = CVILU_CF4218FH0R0-05-NH_1
JASA1 = CVILU_CI1804M1HRG-NH
JDEG1 = JXT_FP241AH-010GAAM_1
JDIMM1 JDIMM2 = LOTES_ADDR0206-P001A_0
JEDP1 = I-PEX_20879-040E-01
JESPI = JXT_FP241AH-010GAAM_0
JFAN1 = ACES_50271-0040N-001: room: KBC
JFPBTN1 = FOX_QT510166-L010-7H
JHDMI1 = ACON_HMRBE-AK1L0D_0
JHP1 = SINGA_2SJ3095-085111F
JIRTS1 = ACES_50208-0180N-P01
JKBTP1 = HRS_TF31-20S-0P5SH-800_0
JLED1 = HRS_TF31-4S-0P5SH-800
JNGFF1 = LOTES_APCI0128-P005A_3
JNGFF2 = ACES_10
JNGFF3 = LOTES_APCI0170-P001A_1
JRTC1 = TYCO_0
JSD1 = T-SOL_2
JSIM1 = TAISO_0
JSPI1 = ACES_50506-02041-P01
JSPK1 = P_ACES_0
JTAG1 = OPEN: User Part Number: PART#; room: KBC
JUSB1 JUSB2 = ACON_TCRA2-9U1U93_1
JUSBC1 = JAE_DX07SD24JJ2R1300~D_1
JUSH1 = HRS_TF31C-26S-0P5SH-800
JXDP1 = JXT_FP270H-061G1AM
LA5-LA16 = L: room: CODEC
LC1-LC3 = L: room: SOC
LC4 LC5 = L
LED3 = LTW-C193DC-C_WHITE: room: LED
LI3 LI7 LZ1 = DLM0NSN900HY2D_4P
LI8 LI9 = MCM1012B900F06BP_4P
LI16 LI17 = HCM1012GH900BP_4P
LT1 LT2 = L: room: TBT
LV1 = L: room: LCD
LV3 LV6 LV9 LV12 = MCF12102G900-T_4P: room: HDMI
PBATT1 WC1 = P_DEREN_1
PC1 PC5 PC7 PC11 PC802 PC807 PC808 PC810 PC906 = P_CAP NP: room: P_DCIN
PC2 PC133-PC140 PC202-PC204 PC206-PC214 PC216-PC219 PC221-PC227 PC425-PC428 PC530 PC738 PC739 PC1096 PC1097 PC1146 PC1147 PC1166 PC1167 PC3008-PC3011 = P_CAP NP: room: P_1.2V
PC3 PC8 PC10 PC12 PC104-PC110 PC112 PC113 PC117 PC118 PC120-PC125 PC127 PC129-PC132 PC161-PC164 PC205 PC302 PC304-PC311 PC315 PC316 PC360 PC401-PC409 PC411-PC419 PC424 PC501 PC504 PC513 PC515 PC516 PC601 PC602 PC608 PC612-PC614 PC616 PC617 PC619 PC621 PC624 PC625 PC628-PC631 PC633 PC636 PC640 PC643 PC646 PC654 PC656-PC658 PC664 PC665 PC672-PC675 PC682-PC684 PC686-PC688 PC746 PC747 PC751 PC811 PC812 PC1000-PC1009 PC1011-PC1020 PC1031-PC1090 PC1101-PC1123 PC1131-PC1141 PC1151-PC1161 = P_CAP NP
PC4 PC6 PC13 PC350 PC603-PC605 PC611 PC618 PC620 PC622 PC626 PC627 PC632 PC635 PC637-PC639 PC641 PC642 PC644 PC645 PC647 PC649-PC653 PC655 PC659-PC663 PC668-PC671 PC676-PC678 PC685 PC697 PC754 PC803 PC814 PC865 PC3005 = P_CAP NP: room: CPU_CORE
PC100 PC102 PC103 PC114-PC116 PC303 = P_CAP NP: room: 3_5V
PC101 PC141 PC142 PC228 PC230 PC231 PC301 PC317 PC318 PC609 PC610 PC666 PC667 PC689-PC692 PC702-PC705 PC707-PC710 PC720-PC723 PC728-PC735 PC737 PC741 PC742 PC757 PC758 PC760 PC761 PC1098 PC1099 PC1148 PC1149 PC1168 PC1169 PC1180 PC1181 PC3001 PC3003 PC3004 = P_CAP NP: room: PWR_CHARGER
PC111 PC119 PC126 PC128 PC312-PC314 PC514 PC517 PC719 PC725-PC727 PC736 PC740 PC743-PC745 PC748-PC750 PC752 PC753 PC755 = P_CAP NP: room: CHARGER
PC200 PC201 PC700 PC701 PC800 PC801 PC804 PC805 PC813 PC3002 = P_CAP NP: room: Charger
PC503 PC505 PC506 = P_CAP NP: room: 1.8V
PC606 PC607 PC706 PC715 PC1091-PC1095 PC1142 PC1143 = P_CAP WP
PC806 PC809 = P_CAP NP: room: P_USBA
PD3 = P_BAS40-05W_SC70-3~D
PD5 PD801 = P_PDS5100H-13_POWERDI5-3~D: room: P_Selector
PD700 PD702 = P_SDMK0340L-7-F_SOD323-2~D
PD701 = P_DFLS160-7_POWERDI123-2
PD704 PD3001 PD3002 = RB520SM-30T2R_EMD2-2
PD705 PD800 PD803 PD3000 = BAT54CW_SOT323~D
PD802 = P_SDMK0340L-7-F_SOD323-2~D: room: P_selector
PH601-PH603 PH605 = P_SL2
PH604 = P_10KB_0603_5%_ERTJ1VR103J: room: CPU_CORE
PJP1 = PAD-OPEN: room: +1.0V_VCCST
PJP2 = PAD-OPEN: room: +1.0V_VCCSTG
PJP3 = PAD-OPEN: room: +1.0V_MPHYGT
PJP5 = P_JUMP_43X118: room: TBT
PJP6 = PAD-OPEN: room: TBT
PJP8 = PAD-OPEN: room: CARDREADER
PJP12 = PAD-OPEN: room: LCD
PJP14 = PAD-OPEN: room: RTS5242
PJP15 PJP16 PJP18 = PAD-OPEN: room: CODEC
PJP17 PJP40 PJP41 = PAD-OPEN: room: UZ4
PJP19 PJP36 = PAD-OPEN: room: UZ2
PJP20 PJP22 = PAD-OPEN: room: KBC
PJP31 = PAD-OPEN: room: SATA EXPRESS
PJP35 = PAD-OPEN: room: KBTP
PJP38 PJP39 = PAD-OPEN: room: UZ3
PJP42 = PAD-OPEN: room: UZ8
PJP100 PJP101 PJP202 PJP301 PJP602 = VCCPAD: room: DDR_VTT_0.75V
PJP102 PJP103 PJP401 PJP402 = P_JUMP_43X118: room: 1.5V
PJP200 = P_JUMP_43X118: room: P_1.2V
PJP201 = P_JUMP_43X39: room: P_1.2V
PJP302 = P_JUMP_43X118
PJP403 PJP404 PJP501 PJP502 PJP505 PJP506 PJP603 = PAD-OPEN: room: VGA_CORE
PJP601 PJP700 = PAD-OPEN: room: Charger
PJPDC1 = P_CVILU_CI0805M1HRC-NH_4
PL1-PL4 PL901 PL902 = P_L: room: P_DCIN
PL100 PL201 PL301 PL402 PL404-PL406 PL501 PL502 PL700 PL701 PL800 PL801 = P_L
PL101 = P_L: room: VDDCI
PL602 = P_L: room: CPU_CORE
PL610 PL612 PL613 = P_L_4P
PL614 = P_0.47UH_MMD05CZR47M_12A_20%
PQ1 PQ10 PQ802 PQ804 PQ806 PQ813 PQ3000 = P_DMN65D8LDW-7_SOT363-6
PQ2 = P_FDV301N_NL_SOT23-3~D: room: P_DCIN
PQ3 = MMST3904-7-F_SOT323~D: room: P_DCIN
PQ4 = P_AON7409_DFN8-5_2
PQ5 PQ11 PQ803 PQ805 = NTR4502PT1G_SOT23-3: room: P_Charger
PQ6-PQ8 PQ12 PQ13 PQ807 PQ812 PQ814 = DMN65D8LW-7_SOT323-3
PQ9 = P_AON7409_DFN8-5_3
PQ614 = P_AON7934_DFN3X3A-8-10_0
PQ700 PQ701 = P_AOE6930_DFN5X6E8-10_0
PQ702 = P_AON7409_DFN8-5_1
PQ703 = P_RHU002N06_SOT323-3~D
PQ800 = P_AON7409_DFN8-5_6
PQ801 = P_AON7409_DFN8-5_5
PQ808-PQ811 = P_DMN66D0LDW-7_SOT363-6: room: P_USBB
PR1-PR8 PR11 PR13 PR14 PR16 PR24 PR27 PR43 PR516 PR668 PR675 PR804 PR819 PR821 PR823 PR856 PR860 PR862 PR953-PR956 = P_R: room: P_DCIN
PR9 RC2 RC5 RC7 RC8 RC10-RC12 RC14 RC15 RC46-RC51 RC53 RC56 RC57 RC65-RC69 RC71-RC73 RC75 RC77 RC82 RC84 RC92 RC93 RC95 RC96 RC101 RC116 RC122 RC129 RC150 RC151 RC154-RC156 RC160 RC161 RC163 RC164 RC166 RC176 RC178 RC183 RC187 RC189 RC190 RC217 RC220 RC222 RC229-RC234 RC237 RC244 RC248 RC266 RC277-RC279 RC288 RC292 RC317-RC319 RC323 RC344 RC345 RC347 RC348 RC362 RC363 RC366-RC369 RC397 RC402 RC420 RC439 RC443 RC444 RC446 RC451 RC452 RC454 RC502-RC505 RC507 RC515 RC518 RC519 RC522 RC523 RC525 RC536 RC537 RC555 RC560-RC565 RC640 RC724 RC725 RC733 RC747-RC749 RC751 RC753 RC757-RC761 RC763-RC766 RC829-RC834 RC836-RC839 RC841 RC842 RC847 RC849 RC854 RC864 RC868 RE95 RE349 RE802 RE810-RE812 RE823 RV7 RV326 RV623-RV627 RV629-RV631 RZ20 RZ21 RZ603 RZ752 = R: room: CPU
PR10 PR15 PR17 PR28 PR33 PR45 PR705 PR706 PR801 PR802 PR806-PR808 PR810-PR813 PR822 PR824 PR825 PR828 PR830 PR833 PR838 PR839 PR846 PR851 PR852 PR855 PR865 = P_R: room: P_Selector
PR12 PR18 PR31 PR32 PR202 PR204 PR206 PR209 PR212 PR313 PR669 PR739 PR744 = P_R: room: P_1.2V
PR19 PR20 PR22 PR25 PR41 PR42 PR44 PR46 PR47 PR49 PR100 PR104 PR105 PR111 PR119 PR120 PR203 PR208 PR210 PR304 PR314 PR315 PR402 PR423 PR427 PR429 PR504 PR513 PR602 PR603 PR606 PR614 PR616 PR620 PR625 PR659 PR662 PR664 PR671 PR679 PR687 PR692 PR709 PR713 PR715 PR719 PR721 PR722 PR727 PR729 PR731 PR736 PR737 PR740 PR741 PR743 PR814 PR816 PR818 PR820 PR826 PR827 PR829 PR834 PR836 PR840 PR844 PR853 PR854 PR857-PR859 PR861 PR866 = P_R-SHORT
PR38-PR40 PR102 PR108 PR116 PR117 PR205 PR207 PR302 PR303 PR306 PR311 PR403 PR404 PR406-PR408 PR410 PR411 PR421 PR425 PR428 PR430 PR514 PR515 PR601 PR604 PR605 PR608 PR610 PR611 PR613 PR617 PR618 PR621 PR622 PR626 PR629-PR631 PR635 PR639 PR640 PR644 PR651 PR678 PR680 PR688 PR691 PR693 PR701-PR703 PR712 PR717 PR718 PR720 PR725 PR726 PR728 PR733-PR735 PR800 PR809 PR815 PR817 PR831 PR832 PR835 PR842 PR843 PR870 PR3002-PR3005 PR3007-PR3013 RE79 RZ335 RZ1413 RZ1482 = P_R
PR103 = P_R: room: 3_5V
PR106 PR112 = P_R: room: 1.5V
PR107 PR113 PR307 PR310 = P_R: room: 1P5V
PR114 PR308 PR312 PR412 PR422 PR745 PR746 PR892 PR893 PR3001 PR3006 RC25-RC27 RC29 RC30 RC33 RC35 RC78 RC86 RC87 RC104 RC106-RC109 RC120 RC123-RC126 RC130 RC131 RC133-RC139 RC218 RC219 RC236 RC241 RC405-RC407 RC409-RC419 RC432 RC433 RC435 RC436 RC448 RC512 RC513 RC520 RC521 RC558 RC567-RC576 RC624 RC723 RC728-RC730 RC734 RC752 RC866 RE300 RE362 RE543 RE546 RE551 RN130 RN131 RT1-RT8 RT12 RT13 RT16-RT24 RT26-RT29 RT31-RT39 RT41 RT42 RT50-RT53 RT66-RT68 RT71 RT76 RT81 RT82 RT86 RT95 RT96 RT100 RT101 RT106 RT107 RT128 RT129 RT190-RT197 RT219-RT222 RT338 RT371 RT372 RT398 RT440 RT447 RT488-RT491 RT494 RT497 RV26 RV29 RV32 RV35 RV56-RV63 RV98 RV99 RV102 RV311 RV319 RV732 RV740-RV744 RZ58-RZ60 RZ89-RZ91 RZ128-RZ130 RZ326 RZ334 RZ372-RZ374 RZ1392 RZ1409 RZ1410 RZ1476 = R
PR405 PR409 PR501 PR502 PR505 PR506 = P_R: room: 1.8V
PR413-PR420 PR424 PR708 PR710 PR716 PR724 PR805 = P_R: room: Charger
PR612 PR619 PR623 PR624 PR627 PR628 PR632 PR633 PR636 PR638 PR641-PR643 PR645-PR650 PR652 PR653 PR656-PR658 PR660 PR661 PR663 PR665-PR667 PR670 PR672-PR674 PR676 PR677 = P_R: room: CPU_CORE
PR615 PR634 = P_R: room: GPU_CORE
PR700 PR711 = P_R~D: room: CHARGER
PR704 PR707 PR714 PR723 PR738 = P_R: room: CHARGER
PR803 = P_R: room: P_selector
PR841 PR845 = P_R: room: P_USBB
PU2 = AP2204R-5.0TRG1_SOT89-3
PU3 PU801 = TC7SH08FU_SSOP5~D: room: PCH
PU100 = P_SY8288BRAC_QFN20_0
PU102 = P_SY8288CRAC_QFN20_1
PU200 = P_SY8210AQVC_QFN19_4X3: room: P_1.2V
PU301 = P_SY8288RAC_QFN20_1
PU401 PU402 = P_TLV62130ARGTR_QFN16_0
PU501 = P_RT8097ALGE_SOT23-6
PU503 = P_AP7361C-FGE-7_U-DFN3030-8_2
PU602 = P_ISL62883CHRTZ-T_TQFN40_1: room: GPU_CORE
PU610 = P_FDMF3035_PQFN31_5
PU612 = P_FDMF3035_PQFN31_7
PU613 = P_FDMF3035_PQFN31_6
PU614 = P_ISL95808HRZ-TS2378_DFN8_2X2
PU700 = P_ISL88738HRTZ-T_TQFN32_4X4
PU701 = SN74AHC1G08DCKR_SC70-5
PU800 = P_LM393DGKR_VSSOP8
PU3000 = P_AZV3002RL-7_U-FLGA8_1P65X1P65
QC2 QC4 QE2 = DMN63D8LV-7_SOT563-6
QC6 QE11 QE12 QE17 QR1 = L2N7002WT1G_SC-70-3
QC7 QV8 QZ1 QZ18 = NTK3139PT1G_SOT723-3
QE3-QE7 QV19 QV21 QZ21 = LMBT3904WT1G_SC70-3
QE15 = LP2301ALT1G_SOT23-3: room: CAMERA
QV1 = P_AO6405_TSOP6_0: room: LCD
QV2 QV4 QV5 QV7 = 2N7002KTB_SOT523-3
QV3 QZ7 = DMN66D0LDW-7_SOT363-6~D: room: CPU
QV18 QV20 = MMBT3906H_SOT23-3
QZ3 = LMUN5111T1G_SC70-3
QZ15 QZ17 QZ22 = PJE138K_SOT523-3
RA3 RA35-RA37 RA48 RA53 RC28 RC32 RC121 RC128 RC153 RC157 RC159 RC165 RC215 RC216 RC221 RC239 RC240 RC243 RC297 RC328 RC337 RC425 RC426 RC429 RC430 RC440 RC442 RC445 RC526 RC528 RC529 RC532 RC548 RC549 RC559 RC566 RC631 RC632 RC660 RC727 RC735-RC738 RC845 RC848 RC850-RC853 RD5 RD7 RD9 RD10 RD12 RD21 RD22 RD25 RD26 RE30 RE32 RE59 RE90 RE275 RE290 RE318 RE361 RE548 RE552 RE565 RE600-RE603 RE608 RE703 RN99 RN129 RR5-RR10 RR274 RT9 RT48 RT58-RT60 RT63 RT83 RT99 RT104 RT105 RT120-RT123 RT399-RT401 RT441 RT448 RT456 RT483 RT492 RT493 RT495 RV323 RV400 RV628 RV733 RZ26 RZ29 RZ56 RZ61 RZ64 RZ112 RZ114 RZ120 RZ345-RZ347 RZ350 RZ351 RZ380 RZ388 RZ1385 RZ1408 RZ1411 RZ1415 RZ1420 RZ1423 RZ1460 RZ1461 RZ1470 RZ1475 = R-SHORT
RA5-RA9 RA12-RA14 RA17 RA18 RA44 RA45 RA51 RA52 RA59-RA61 RA66 RA67 RC59 = R: room: CODEC
RA50 RC24 RC31 RC60 RC214 RC298 RC302 RC441 RC530 RC867 RD4 RD6 RD8 RD20 RD23 RD24 RE274 RE280 RE292 RE304 RE306 RE536 RE817-RE819 RN100 RT40 RT49 RT64 RT65 RT89 RT90 RT97 RT98 RT103 RT110 RT394 RT402 RT403 RT445 RT482 RT496 RV324 RZ22 RZ23 RZ70 RZ71 RZ76-RZ80 RZ320 RZ1388 RZ1389 RZ1407 RZ1414 RZ1416-RZ1419 RZ1471 RZ1473 RZ1477 = R: room: AR
RA54 = R: room: UZ8
RC19 RC289 RC299 RC710 RC711 RE350 RE539 = R: room: SPI ROM
RC61 RC62 RC94 = R: room: PD_1
RC63 RC158 RC400 RC401 RC557 RC743-RC745 RC754 RC843 RC844 RE31 RE33 RE37 RE43 RE48 RE51 RE55-RE58 RE60 RE63-RE65 RE67-RE75 RE77 RE86 RE301-RE303 RE312-RE314 RE342 RE343 RE526 RE562 RE706-RE708 RE813-RE816 RZ32 RZ827 = R: room: KBC
RC132 RC235 = R: room: CPU XDP
RC173 RC175 RC422 = R: room: Other
RC431 RE8 RE10-RE12 RE20 RE21 RE25 RE26 RE35 RE38 RE83-RE85 RE91-RE94 RE288 RE365 RE505 RE507 RE508 RE524 RE525 RE532 RE541 RE547 RE549 RE550 RE561 RE605 RE606 RE704 RE709 RE803-RE809 RE820-RE822 = R: room: SIO
RD11 RD14-RD19 RD27-RD31 RZ1450 = R: room: MEMORY
RI13 RI14 = R: room: USB1
RN37 = R: room: SATA EXPRESS
RR3 RR4 RR19 = R: room: RTS5242
RT25 RT391 RT455 = R: room: TBT
RT111 RT377 RT393 = R: room: PD
RV1-RV5 RV101 = R: room: LCD
RV6 RV8 RV325 RV734 = R: room: TOUCH
RV10-RV23 = R: room: HDMI
RZ8-RZ10 = R: room: USH
RZ18 RZ19 RZ116 RZ117 = R: room: KBTP
RZ25 RZ28 RZ361 = R: room: LED
RZ38 RZ1422 = R: room: UZ2
RZ40 RZ1472 RZ1474 = R: room: UZ4
RZ43 RZ63 RZ69 RZ362 RZ377 RZ379 RZ400 RZ518 RZ1483 = R: room: TPM
RZ119 = R: room: +VCC_SFR_OC
RZ151 = R: room: +1.0V_VCCSTG
RZ401 = R: room: GPU
RZ1381 RZ1383 = R: room: WLAN
RZ1390 RZ1391 = R: room: CAMERA
SW1 = SSAJ120100_0
SW3 = SKRBACE010_4P
T1 T2 T219 T220 = PAD_5: room: CPU
T12 T341 T348 T375-T377 T383 T388-T391 T395-T397 T399 T404 T405 T408-T412 T415-T421 T452 = PAD_0: room: CPU
T16-T21 T355 T360 T361 T363-T369 T371-T374 T380 T381 T422 T423 = PAD_8: room: CPU
T50 T51 T54 T55 = PAD_9: room: MEMORY
T350 T351 T353 T354 = PAD_6: room: CPU
UA1 = ALC3254-CG_MQFN48_6X6
UC1 = WHL-U42_BGA1528
UC5 = GD25B256DYIG_WSON8_8X6
UC6 = W25Q128JVSIQ_SO8
UC7 UE3 UE5 = TC7SH08FU_SSOP5~D: room: CPU
UC9 UZ54 = MC74VHC1G32DFT2G_SC70-5~D
UD1 = 74AUP1G07GW_TSSOP5: room: MEMORY
UE1 = MEC5105_WFBGA169_0
UE4 = 74AUP1G07FZ4-7_X2-DFN1410-6
UI1 = SY6288D20AAC_SOT23-5: room: USB2
UI3 = SLGC55544CVTR_TQFN16_3X3: room: USB1
UR1 = RTS5242-GR_QFN32_4X4: room: RTS5242
UT1 = ALPINE-RIDGE_BGA337_1: room: TBT
UT2 = W25Q80DVSSIG_SO8: room: TBT
UT5 = TPS65982_BGA96_0: room: PD
UT6 = W25Q80DVSSIG_SO8: room: PD
UT7 = AP2112K-3.3TRG1_SOT23-5: room: PD
UT8 = AP2204R-5.0TRG1_SOT89-3: room: PD
UT32 = TS5A3159ADCKR_SC70-6
UT34 UZ35 = TC7SH08FU_SSOP5~D: room: +1.0V_VCCSTG
UV2 = AP2330W-7_SC59-3: room: HDMI
UV24 = G527ATP1U_TSOT23-6
UZ1 = APX8131AI-TRG_SOT23-3
UZ3 = TPS22966DPUR_SON14_1: room: UZ3
UZ5 = TPS22966DPUR_SON14_0: room: CODEC
UZ6 = TC7SH08FU_SSOP5~D: room: RSMRST
UZ8 UZ53 = AOZ1336_DFN8_1: room: UZ8
UZ10 = TC7SH08FU_SSOP5~D: room: LED
UZ12 = ST33HTPH2E32AHB4_VQFN32_5X5
UZ19 UZ21 UZ27 = EM5201V_DFN8_3X3
UZ29 = HD3SS3212RKSR_VQFN20_0
UZ43 = TPS22966DPUR_SON14_1: room: UZ2
UZ47 = TPS22966DPUR_SON14_1: room: UZ4
YC1 = 24MHZ_12PF_8Y24000034
YC2 = 32.768KHZ_12.5PF_9H03220008: room: CPU
YE1 = 32.768KHZ_9PF_X1A000141000200
YT1 = 25MHZ_18PF_1: room: TBT

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1N4148WS-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
2N7002KTB_SOT523-3
  oval 0.406x0.457 smd: 1(0,0) 2(-0.5,-1.35) 3(0.5,-1.35)
3A_Z120_0603_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
9A_Z80_1812_2P-NPM
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
74AUP1G07FZ4-7_X2-DFN1410-6
  oval 0.254x0.533 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,0.725) 5(0.5,0.725) 6(0,0.725)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_40-42313-06711RHFAN_75P-T
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(19.6,-0.775) 77(-1.1,-0.775)
ACES_50208-0180N-P01_18P-T-S
  oval 0.508x1.295 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0) 5(-3.2,0) 6(-4,0) 7(-4.8,0) 8(-5.6,0) 9(-6.4,0) 10(-7.2,0) 11(-8,0) 12(-8.8,0) 13(-9.6,0) 14(-10.4,0) 15(-11.2,0) 16(-12,0) 17(-12.8,0) 18(-13.6,0)
  rect 1.194x1.702 smd: 19(1.3,-1.95) 20(-14.9,-1.95)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50271-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,-2.9) 6(-6.3,-2.9)
ACES_50278-00801-001_8P
  oval 0.787x1.905 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0) 5(-5,0) 6(-6.25,0) 7(-7.5,0) 8(-8.75,0)
  rect 1.295x3.353 smd: 9(2.85,-4.923) 10(-11.6,-4.923)
ACES_50506-02041-P01_20P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 0.991x2.007 smd: 21(-2.1,-3.05) 22(11.6,-3.05)
ACON_HMRBL-A41L0F_19P-T
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.397x2.21 hole 0.787x1.6: 20(11.75,0.2) 22(-2.75,0.2)
  oval 1.702x2.997 hole 1.092x2.388: 21(13.25,-8.15) 23(-4.25,-8.15)
ACON_TCRA2-9U1U93_9P-T
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.295x2.311 hole 0.711x1.702: 10(2.9,0.3) 12(-9.9,0.3)
  oval 1.295x2.007 hole 0.711x1.397: 11(4.2,-8.95) 13(-11.2,-8.95)
ALC3254-CG_MQFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
AO3409_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AO6405_TSOP6
  oval 0.508x1.473 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
AOE6930_DFN5X6E8-10
  rect 0.61x0.61 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.5) 6(2.54,5.5) 7(1.27,5.5)
  rect 0.61x1.676 smd: 8(0,4.96)
  rect 4.191x1.041 smd: 9(1.905,1.215)
  custom 0.617x0.617 smd: 10(1.905,3.465)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AOZ1336_DFN8_2X2-S
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AP2112K-3P3TRG1_SOT23-5
  oval 0.508x0.965 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.375) 5(0,2.375)
AP2204R-5P0TRG1_SOT89-3
  oval 0.889x1.295 smd: 1(0,0) 3(3,0)
  custom 0.433x0.433 smd: 2(1.5,1.775)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AP7361C-FGE-7_U-DFN3030-8_3X3
  oval 0.457x0.94 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,3.05) 6(1.3,3.05) 7(0.65,3.05) 8(0,3.05)
  rect 2.261x1.499 smd: 9(0.975,1.525)
APX8131AI-TRG_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZ4A24-01FPR7G_DFN0603P2Y2
  rect 0.305x0.356 smd: 1(0,0) 2(0.4,0)
AZ1045-04F_DFN2510P10E-10-9
  oval 0.254x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.381x1.549 smd: 3(1,0.437)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZV3002RL-7_U-FLGA8_1P65X1P65
  oval 0.406x0.508 smd: 1(0,0)
  oval 0.305x0.508 smd: 2(0.55,0) 3(1.05,0) 5(1.05,1.22) 6(0.55,1.22) 7(0.05,1.22)
  oval 0.508x0.305 smd: 4(1.15,0.61) 8(-0.05,0.61)
BAT54CT-7-F_SOT523-3
  oval 0.406x0.508 smd: 1(0,0) 2(-0.5,-1.3) 3(0.5,-1.3)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BZV55-B5V1_SOD80C2
  rect 0.889x1.6 smd: 1(0,0) 2(3.3,0)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0603-S3
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_A
  rect 1.626x1.829 smd: 1(0.389,0) 2(2.989,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_B2-NPM
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_B3
  rect 1.346x2.692 smd: 1(0,0) 2(2.75,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D3
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D7
  rect 1.803x2.794 smd: 1(0,0) 2(6.5,0)
CEST523NC5VB_SOT-523-3
  oval 0.508x0.61 smd: 1(0,0)
  oval 0.406x0.61 smd: 2(-0.5,-1.24) 3(0.5,-1.24)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CLIP_0P8X7P0
  rect 0.787x7.01 smd: 1(0,0)
CLIP_14P1X2P6
  rect 14.097x2.591 smd: 1(0,0)
CVILU_CF4218FH0R0-05-NH_18P-T
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.406x0.787 smd: 19(-1,-2.5) 20(9.5,-2.5)
CVILU_CI0805M1HRC-NH_5P-T
  round 1.803 hole 1.803 unplated: (-0.2,5.2) (8.2,5.2)
  oval 0.889x2.388 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0)
  rect 1.6x2.489 smd: 6(11.15,9.05) 7(-3.15,9.05)
CVILU_CI1804M1HRG-NH_4P
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(1.3,-1.95) 6(-3.7,-1.95)
CYNTE_PCMB051H-1R0MS_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
CYNTE_PCMB063T-1R0MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCMB103T-2R2MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
DB3J315E0L_SMINI3-F2-B3
  oval 0.889x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DEREN_40-42251-01001RHF_10P-T
  oval 0.838x2.21 smd: 1(0,0.1) 2(1.5,0.1) 3(3,0.1) 4(4.5,0.1) 5(6,0.1) 6(7.5,0.1) 7(9,0.1) 8(10.5,0.1) 9(12,0.1) 10(13.5,0.1)
  custom 0.75x0.75 smd: 11(-3.4,-3.15) 12(16.9,-3.15)
DMN63D8LV-7_SOT563-6
  oval 0.254x0.711 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.425) 5(0.5,1.425) 6(0,1.425)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
EM5201V_DFN8_3X3
  oval 0.305x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.8)
  rect 1.6x0.61 smd: 6(0.65,2.8)
  rect 2.388x1.6 smd: 7(0.975,1.4)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
EMIST_SUL-15A3M_1P
  rect 5.994x1.194 smd: 1(0,0)
ESD8011MUT5G_X3DFN2-2
  rect 0.33x0.356 smd: 1(0,0) 2(0.43,0)
F_T0603FF0500TM
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
F_T0603FF1000TM
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
FDMC6679AZ_MLP8-5
  oval 0.432x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.537x0.537 smd: 5(0.975,2.075)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
FOX_ASAA821-H4RB5-7H_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(-67.175,7.9) 262(0.425,7.9)
FOX_QT510166-L010-7H_16P
  oval 0.305x1.295 smd: 1(0,0) 2(0,-5.7) 3(-0.5,0) 4(-0.5,-5.7) 5(-1,0) 6(-1,-5.7) 7(-1.5,0) 8(-1.5,-5.7) 9(-2,0) 10(-2,-5.7) 11(-2.5,0) 12(-2.5,-5.7) 13(-3,0) 14(-3,-5.7) 15(-3.5,0) 16(-3.5,-5.7)
G527ATP1U_TSOT23-6
  oval 0.508x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0.95,3) 6(0,3)
GD25B256DYIG_WSON8_8X6
  oval 0.635x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.9) 6(2.54,7.9) 7(1.27,7.9) 8(0,7.9)
  rect 4.293x3.429 smd: 9(1.905,3.95)
H_0P6X2P8
  oval 1.118x3.302 hole 0.61x2.794: 1(0,0)
H_2P3-G
  round 2.819 hole 2.311: 1(0,0)
H_2P5X0P7
  oval 2.997x1.219 hole 2.489x0.711: 1(0,0)
H_2P6-G
  round 3.099 hole 2.591: 1(0,0)
H_3P1-G
  round 3.607 hole 3.099: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P6X2P6-G
  oval 4.115x3.099 hole 3.607x2.591: 1(0,0)
H_3P7
  round 4.216 hole 3.708: 1(0,0)
H_4P0-G
  round 4.496 hole 3.988: 1(0,0)
HD3SS3212RKSR_VQFN20_2P5X4P5
  oval 0.254x0.889 smd: 1(0,0) 10(0,-4.6) 11(0.5,-4.6) 20(0.5,0)
  oval 0.889x0.254 smd: 2(-1.05,-0.55) 3(-1.05,-1.05) 4(-1.05,-1.55) 5(-1.05,-2.05) 6(-1.05,-2.55) 7(-1.05,-3.05) 8(-1.05,-3.55) 9(-1.05,-4.05) 12(1.55,-4.05) 13(1.55,-3.55) 14(1.55,-3.05) 15(1.55,-2.55) 16(1.55,-2.05) 17(1.55,-1.55) 18(1.55,-1.05) 19(1.55,-0.55)
  rect 0.991x2.997 smd: 21(0.25,-2.3)
HRS_TF31-4S-0P5SH-800_4P-T
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0)
  rect 1.905x2.21 smd: 5(-1.95,3.25) 6(3.45,3.25)
HRS_TF31-20S-0P5SH-800_20P-T
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.905x2.21 smd: 21(11.45,3.25) 22(-1.95,3.25)
HRS_TF31C-26S-0P5SH-800_26P-T
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  rect 1.905x2.21 smd: 27(14.45,3.25) 28(-1.95,3.25)
I-PEX_20854-005E-00_5P-T
  oval 0.152x0.457 smd: 1(0,0) 2(0.35,0) 3(0.7,0) 4(1.05,0) 5(1.4,0)
  custom 0.076x0.076 smd: 6(-0.635,0.025) 7(-1.095,0.465) 8(-1.095,1.135) 11(2.495,1.135) 12(2.495,0.465) 13(2.035,0.025)
  custom 0.14x0.14 smd: 9(-0.71,1.75) 10(2.11,1.75)
I-PEX_20879-040E-01_40P-T
  oval 0.203x0.635 smd: 1(0,0) 2(-0.4,0) 3(-0.8,0) 4(-1.2,0) 5(-1.6,0) 6(-2,0) 7(-2.4,0) 8(-2.8,0) 9(-3.2,0) 10(-3.6,0) 11(-4,0) 12(-4.4,0) 13(-4.8,0) 14(-5.2,0) 15(-5.6,0) 16(-6,0) 17(-6.4,0) 18(-6.8,0) 19(-7.2,0) 20(-7.6,0) 21(-8,0) 22(-8.4,0) 23(-8.8,0) 24(-9.2,0) 25(-9.6,0) 26(-10,0) 27(-10.4,0) 28(-10.8,0) 29(-11.2,0) 30(-11.6,0) 31(-12,0) 32(-12.4,0) 33(-12.8,0) 34(-13.2,0) 35(-13.6,0) 36(-14,0) 37(-14.4,0) 38(-14.8,0) 39(-15.2,0) 40(-15.6,0)
  rect 0.305x0.813 smd: 41(-17.385,0.085) 57(1.785,0.085)
  rect 1.448x0.356 smd: 42(-16.305,0.75) 56(0.705,0.75)
  rect 0.457x0.356 smd: 43(-15,0.75) 44(-13.8,0.75) 45(-12.6,0.75) 46(-11.4,0.75) 47(-10.2,0.75) 48(-9,0.75) 49(-7.8,0.75) 50(-6.6,0.75) 51(-5.4,0.75) 52(-4.2,0.75) 53(-3,0.75) 54(-1.8,0.75) 55(-0.6,0.75)
  rect 0.406x0.889 smd: 58(1.735,-2.28) 74(-17.335,-2.28)
  rect 1.397x0.508 smd: 59(0.64,-2.915) 73(-16.24,-2.915)
  rect 0.457x0.508 smd: 60(-0.6,-2.915) 61(-1.8,-2.915) 62(-3,-2.915) 63(-4.2,-2.915) 64(-5.4,-2.915) 65(-6.6,-2.915) 66(-7.8,-2.915) 67(-9,-2.915) 68(-10.2,-2.915) 69(-11.4,-2.915) 70(-12.6,-2.915) 71(-13.8,-2.915) 72(-15,-2.915)
INPAQ_HCM1012GH900BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
ISL62883CHRTZ-T_TQFN40_5X5-S
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.95) 22(3.2,4.95) 23(2.8,4.95) 24(2.4,4.95) 25(2,4.95) 26(1.6,4.95) 27(1.2,4.95) 28(0.8,4.95) 29(0.4,4.95) 30(0,4.95)
  oval 0.991x0.203 smd: 11(4.275,0.675) 12(4.275,1.075) 13(4.275,1.475) 14(4.275,1.875) 15(4.275,2.275) 16(4.275,2.675) 17(4.275,3.075) 18(4.275,3.475) 19(4.275,3.875) 20(4.275,4.275) 31(-0.675,4.275) 32(-0.675,3.875) 33(-0.675,3.475) 34(-0.675,3.075) 35(-0.675,2.675) 36(-0.675,2.275) 37(-0.675,1.875) 38(-0.675,1.475) 39(-0.675,1.075) 40(-0.675,0.675)
  rect 3.505x3.505 smd: 41(1.8,2.475)
