# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_C_DRX_P13: length 3.8
  BOTTOM w0.104: JNGFF3.13 30.88,23.44 31.03,23.59 31.03,24.08 v4(31.43,24.47) 31.69,24.73 31.69,25.64 CN66.1
PCIE_PTX_C_DRX_P14: length 3.8
  BOTTOM w0.104: JNGFF3.25 27.88,23.42 28.07,23.62 28.07,24.47 v4(28.39,24.79) 28.63,25.03 28.63,25.59 CN68.1
PCIE_PTX_C_DRX_P15: length 2.7
  BOTTOM w0.104: CN70.1 25.1,24.81 25.1,23.56 24.88,23.34 JNGFF3.37
PCIE_PTX_C_DRX_P16: length 2.9
  BOTTOM w0.104: JNGFF3.49 21.88,23.37 22.02,23.5 22.02,24.29 21.69,24.61 21.69,24.78 CN72.1
PCIE_PTX_DRX_N5: length 167.4
  IN1 w0.094: v1(35.02,69.4) 35.22,69.2 35.68,69.2 36.35,69.87 36.35,70.23 35.77,70.81 35.77,77.53 36.4,78.16 36.4,84.21 37.66,85.46 37.66,92.09 38.31,92.74 38.31,95.24 40.27,97.19 41.06,97.19 42.17,98.3 42.17,98.91 43.07,99.82 43.76,99.82 45.88,101.94 47.85,101.94 50.93,105.02 50.93,105.07 52.11,106.25 52.11,106.77 54.76,109.43 60.06,109.43 60.33,109.15 60.69,109.15 60.96,109.43 64.77,109.43 65.37,108.83 77.87,108.83 78.3,108.4 80.07,108.4 80.43,108.05 82.13,108.05 82.48,108.4 87.48,108.4 88.76,109.68 90.9,109.68 91.26,110.04 103.4,110.04 103.66,110.3 105.17,110.3 105.82,109.66 110.93,109.66 111.68,110.4 136.12,110.4 136.34,110.18 137.5,110.18 138.06,109.61 141.09,109.61 146.04,104.66 146.04,103.03 145.43,102.42 145.43,99.85 145.61,99.66 145.75,99.66 v1(145.97,99.89)
  BOTTOM w0.076: UC1.BW4 144.21,89.49 144.21,90.04 144.06,90.38 144.06,90.63 144.1,90.73 144.1,90.95 144.06,91.05 144.06,91.07 144.06,91.07 144.06,91.39 144.26,91.58 144.26,92.59 144.7,93.03 144.7,94.37 144.87,94.55 144.87,96.38 144.96,96.47 144.96,98.32 144.95,98.33 144.95,98.35
  BOTTOM w0.104: v1(35.02,69.4) 34.78,69.4 34.68,69.3 34.68,69.1 34.59,69.01 34.33,69.01 34.08,68.76 33.71,68.76 33.61,68.87 33.61,69.01 CT3.1 ; v1(145.97,99.89) 145.84,99.75 145.27,99.75 144.95,99.44 144.95,98.35
PCIE_PTX_DRX_N6: length 172.1
  IN1 w0.094: v1(145.97,101.16) 146.13,101.31 146.42,101.31 146.62,101.52 146.62,105.8 146.05,106.37 145.61,106.37 141.75,110.23 138.27,110.23 137.73,110.77 136.63,110.77 136.41,110.98 111.44,110.98 110.69,110.24 106.06,110.24 105.41,110.88 103.42,110.88 103.16,110.62 89.21,110.62 89.21,110.62 88.87,110.62 87.24,108.98 78.54,108.98 78.09,109.43 65.64,109.43 65.07,110.01 61,110.01 60.91,110.1 59.46,110.1 59.41,110.04 59.09,110.04 59.09,110.04 58.54,110.04 58.48,110.1 58.18,110.4 57.13,110.4 56.74,110.01 54.52,110.01 52.58,108.07 52.5,108.07 50.36,105.94 50.36,105.85 48.43,103.92 46.95,103.92 43.45,100.42 42.74,100.42 41.54,99.22 41.54,98.51 40.82,97.79 39.03,97.79 38.25,97.01 38.25,96 37.73,95.48 37.73,92.98 37.08,92.33 37.08,90.37 36.35,89.65 36.35,85.97 35.77,85.39 35.77,78.36 34.46,77.04 34.46,76.87 34.02,76.43 34.02,71.68 33.67,71.32 33.67,68.46 33.36,68.15 30.96,68.15 30.81,68.31 v1(30.81,68.64)
  BOTTOM w0.076: UC1.BU4 143.46,89.8 143.46,90.04 143.6,90.38 143.6,90.63 143.57,90.73 143.57,90.95 143.64,91.13 143.64,92.01 143.44,92.21 143.44,96.46 144.53,97.55 144.53,98.32 144.54,98.33 144.54,98.35
  BOTTOM w0.104: v1(30.81,68.64) 30.62,68.83 30.62,69.02 CT5.1 ; 144.54,98.35 144.54,100.97 144.73,101.16 v1(145.97,101.16)
PCIE_PTX_DRX_N7: length 170.7
  IN1 w0.094: v1(28.01,68.59) 28.22,68.38 28.22,68.2 29.03,67.39 34.95,67.39 37.12,69.55 37.12,70.54 36.54,71.13 36.54,77.22 37.17,77.85 37.17,83.83 38.42,85.08 38.42,91.77 39.43,92.78 39.43,94.36 43.55,98.48 43.55,98.83 43.78,99.05 44.08,99.05 46.2,101.18 48.17,101.18 51.69,104.7 51.69,104.75 53.1,106.16 53.1,106.68 55.01,108.59 59.81,108.59 60.01,108.39 61,108.39 61.2,108.59 64.33,108.59 64.89,108.03 76.45,108.03 76.86,107.63 79.7,107.63 80.04,107.28 82.45,107.28 82.8,107.64 89.94,107.64 91.57,109.27 103.72,109.27 103.98,109.54 104.85,109.54 105.5,108.89 111.25,108.89 112,109.64 124,109.64 124.5,109.14 125.8,109.14 126,109.34 127.83,109.34 128.03,109.15 129.24,109.15 129.43,109.34 137.22,109.34 138.01,108.55 138.9,108.55 140.47,106.97 142.64,106.97 145.05,104.57 145.05,103.12 144.67,102.74 144.67,97.84 144.29,97.47 143.86,97.47 143.71,97.62 143.71,97.73 v1(143.51,97.92)
  BOTTOM w0.076: v1(143.51,97.92) 143.41,97.82 143.05,97.82 142.86,97.62 142.86,91.21 UC1.BU2
  BOTTOM w0.104: v1(28.01,68.59) 28.21,68.78 28.21,69 CT124.1
PCIE_PTX_DRX_N8: length 171.4
  IN1 w0.094: v1(26.88,68.59) 26.88,67.8 27.07,67.61 28.22,67.61 28.85,66.99 35.12,66.99 37.6,69.46 37.6,70.63 36.93,71.29 36.93,77.05 37.57,77.68 37.57,83.59 38.82,84.85 38.82,91.6 39.83,92.61 39.83,93.81 41.98,95.96 42.83,95.96 43.97,97.1 43.97,97.71 45.76,99.49 46.28,99.49 47.44,100.65 48.21,100.65 52.09,104.54 52.09,104.58 53.5,105.99 53.5,106.52 55.17,108.19 59.64,108.19 59.84,107.99 61.17,107.99 61.37,108.19 63.99,108.19 64.85,107.33 65.58,107.33 65.8,107.11 67.09,107.11 67.61,107.63 76.22,107.63 76.75,107.11 79.65,107.11 79.87,106.88 82.61,106.88 82.97,107.24 90.1,107.24 91.74,108.88 103.09,108.88 103.47,108.49 111.42,108.49 112.16,109.24 123.6,109.24 124.3,108.55 136.33,108.55 136.73,108.15 138.73,108.15 142,104.88 144.18,104.88 144.65,104.41 144.65,103.28 144.27,102.9 144.27,99.49 144.05,99.27 143.67,99.27 v1(143.53,99.12)
  BOTTOM w0.076: 143.07,98.35 143.07,98.06 142.7,97.69 142.7,90.53 142.88,90.34 142.88,90.11 UC1.BT4
  BOTTOM w0.104: v1(143.53,99.12) 143.07,98.67 143.07,98.35 ; CT126.1 26.68,69.04 26.68,68.79 v1(26.88,68.59)
PCIE_PTX_DRX_N9: length 216
  TOP w0.104: CR12.1 284.9,64.37 284.7,64.37 284.49,64.59 284.49,66.13 284.31,66.3 284.15,66.3 v1(283.91,66.06)
  IN4 w0.094: v1(283.91,66.06) 283.71,66.26 283.39,66.26 283.27,66.15 283.27,65.28 283.48,65.07 284.5,65.07 285.75,63.82 285.75,63.04 285.3,62.59 285.3,61.6 285.49,61.41 285.49,60.31 284.34,59.15 281.99,59.15 281.58,58.74 281.58,57.6 281.17,57.19 278.72,57.19 278.33,57.58 278.33,58.66 277.9,59.09 275.64,59.09 275.42,58.87 272.96,58.87 272.32,58.23 270.35,58.23 269.66,58.92 266.19,58.92 265.69,58.42 264.99,58.42 262.55,55.98 261.97,55.98 257.01,51.01 257.01,50.24 256.03,49.27 254.7,49.27 253.17,47.73 253.17,45.89 252.55,45.27 244.22,45.27 241.89,42.94 240.12,42.94 238.79,41.6 230.49,41.6 229.59,42.51 222.96,42.51 222.54,42.93 219.27,42.93 216.4,45.8 214.64,45.8 196.03,64.4 196.03,70.89 194.22,72.71 194.22,73.45 193.22,74.44 193.22,76.17 189.94,79.45 187.59,79.45 185.11,81.93 185.11,82.61 184.29,83.43 184.29,83.65 183.92,84.01 183.92,84.97 180.09,88.81 180.09,92.64 178.65,94.08 178.65,95.06 175.29,98.42 173.23,98.42 172.6,99.05 169.55,99.05 168.6,100 168.32,100 162.27,106.04 156.86,106.04 155.29,104.47 151.73,104.47 151.39,104.13 147.14,104.13 145.1,102.09 145.1,101.97 144.09,100.96 143.66,100.96 v1(143.51,100.81)
  BOTTOM w0.076: 142.47,98.35 142.47,98.01 142.32,97.86 142.32,94.4 142.32,91.02 UC1.BR2
  BOTTOM w0.104: v1(143.51,100.81) 142.57,100.81 142.47,100.71 142.47,98.35
PCIE_PTX_DRX_N10: length 168.4
  IN4 w0.094: v1(143.51,103.04) 143.89,102.66 144.59,102.66 146.83,104.9 150.97,104.9 151.31,105.23 154.97,105.23 156.54,106.81 162.59,106.81 163.62,105.78 166.69,105.78 169.3,103.17 169.3,102.24 170.96,100.58 171.09,100.58 171.14,100.63 174.9,100.63 178.12,97.41 178.12,96.71 179.83,95.01 179.83,93.99 180.85,92.96 180.85,89.22 184.7,85.37 185.23,85.37 185.43,85.17 185.43,83.38 185.88,82.93 185.88,82.25 186.53,81.6 188.22,81.6 189.57,80.25 190.23,80.25 195.1,75.38 195.1,73.84 196.87,72.07 197.05,72.07 197.54,71.57 197.54,63.97 214.96,46.56 216.72,46.56 219.58,43.69 222.85,43.69 223.27,43.27 229.91,43.27 230.82,42.37 238.47,42.37 239.81,43.7 241.57,43.7 243.9,46.03 252.1,46.03 252.19,46.13 252.19,46.27 v1(251.91,46.56)
  BOTTOM w0.076: 141.67,98.35 141.69,98.34 141.69,97.92 141.75,97.86 141.75,91.54 141.62,91.42 141.62,91.05 141.66,90.95 141.66,90.73 141.62,90.63 141.62,90.38 141.64,90.34 141.74,90.1 141.77,90.04 141.77,89.83 142.04,89.22 UC1.BR4
  BOTTOM w0.104: v1(251.91,46.56) 252.04,46.43 252.04,45.25 252.57,44.72 253.47,44.72 CZ13.1 ; 141.67,98.35 141.67,101.87 142.85,103.04 v1(143.51,103.04)
PCIE_PTX_DRX_N11: length 155.5
  TOP w0.104: v1(237.08,44.64) 237.2,44.75 237.2,45.44 237.81,46.05 239.61,46.05 239.76,46.05 CZ153.1
  IN4 w0.094: v1(141.05,96.24) 140.37,96.24 140.17,96.44 140.17,102.31 144.23,106.37 145.44,106.37 145.53,106.47 148.93,106.47 149.27,106.8 150.06,106.8 150.31,107.05 151.39,107.05 151.64,106.8 153.89,106.8 155.4,108.31 155.59,108.31 155.82,108.54 157.13,108.54 158.55,109.96 160.7,109.96 161.29,109.37 165.32,109.37 171.08,103.61 173.51,103.61 174.45,102.66 175.09,102.66 180.54,97.22 180.54,96.58 181.81,95.31 181.81,94.22 182.42,93.61 182.42,89.87 185.35,86.94 186.11,86.94 188.91,84.14 189.38,84.14 189.97,83.55 189.97,82.99 199.36,73.6 199.36,64.95 203.87,60.44 203.87,59.87 215.61,48.13 217.37,48.13 220.24,45.26 223.51,45.26 223.93,44.84 231.9,44.84 232.62,44.12 237.17,44.12 237.31,44.26 237.31,44.41 v1(237.08,44.64)
  BOTTOM w0.076: v1(141.05,96.24) 140.64,95.83 140.64,93.72 141,93.36 141,91.55 141.16,91.39 141.16,91.05 141.13,90.95 141.13,90.73 141.16,90.63 141.16,90.38 141.02,90.04 141.02,89.73 UC1.BN4
PCIE_PTX_DRX_N12: length 206.6
  TOP w0.104: CZ210.1 278.54,53.37 279,52.92 279,52.77 278.84,52.61 277.84,52.61 277.5,52.95 277.5,57.33 276.71,58.12 276.5,58.12 v1(276.13,58.49)
  IN4 w0.094: v1(141.05,98.78) 141.28,98.55 141.66,98.55 141.87,98.35 141.87,97 142.91,95.95 144.47,95.95 145.09,96.56 145.82,96.56 146.63,97.37 146.63,102.23 148.09,103.69 151.51,103.69 151.9,104.07 155.45,104.07 157.03,105.65 162.1,105.65 166.95,100.8 166.95,100.2 169.08,98.06 171.82,98.06 172.86,97.01 176.13,97.01 178.25,94.89 178.25,92.71 179.69,91.27 179.69,88.65 183.53,84.81 183.53,83.85 183.89,83.48 183.89,82.59 187.43,79.05 189.73,79.05 192.79,75.99 192.79,74.31 193.74,73.35 193.74,71.56 195.63,69.67 195.63,64.24 214.47,45.4 216.23,45.4 219.1,42.53 222.37,42.53 222.79,42.11 229.42,42.11 230.33,41.2 238.95,41.2 240.26,42.51 242.22,42.51 243.23,43.52 243.93,43.52 245.28,44.87 252.71,44.87 253.75,45.91 253.75,47.73 254.67,48.65 256.13,48.65 258.15,50.67 258.46,50.67 260.45,52.65 262.23,52.65 263.28,53.71 263.28,54.27 266.57,57.55 274.8,57.55 275.47,58.23 275.87,58.23 v1(276.13,58.49)
  BOTTOM w0.076: UC1.BN2 140.46,91.02 140.46,93.05 140.33,93.19 140.33,93.19 140.1,93.42 140.1,96.45 140.28,96.64 140.28,98.46 140.33,98.51
  BOTTOM w0.104: 140.33,98.51 140.55,98.72 141,98.72 v1(141.05,98.78)
PCIE_PTX_DRX_N13: length 190.4
  IN1 w0.094: v1(140.99,99.9) 140.54,100.35 140.21,100.35 139.7,100.85 139.7,102.68 137.32,105.06 120.7,105.06 120.05,105.71 114.3,105.71 113.58,104.99 110.9,104.99 110.49,105.4 94.5,105.4 93.69,104.6 93.03,104.6 91.91,103.48 88.59,103.48 88.19,103.08 80.75,103.08 80.03,103.79 78.51,103.79 78.29,104.02 67.33,104.02 66.87,103.56 61.44,103.56 61.07,103.92 56.38,103.92 54.33,101.88 53.8,101.88 52.96,101.03 52.96,100.74 47.66,95.44 47.66,93.91 46.43,92.68 46.43,84.45 41.4,79.42 41.4,78.41 40.66,77.66 40.66,73.68 41.05,73.29 41.05,71.03 41.1,70.98 41.1,68.62 40.73,68.25 40.73,67.52 40.53,67.32 40.53,67.32 39.46,66.25 39.46,63.32 38.66,62.52 36.52,60.38 36.52,54.98 35.87,54.33 35.87,50.88 33.31,48.32 33.31,32.6 31.75,31.03 31.75,29.09 v1(32.07,28.76)
  BOTTOM w0.076: 139.92,98.35 139.92,93.25 140.25,92.91 140.25,90.68 140.25,90.61 140.25,90.53 140.44,90.34 140.44,90.04 140.17,89.77 UC1.BM4
  BOTTOM w0.104: CN65.2 31.98,27.16 31.98,27.31 32.1,27.43 32.1,28.06 31.88,28.28 31.88,28.57 v1(32.07,28.76) ; v1(140.99,99.9) 140.84,100.04 140.35,100.04 139.92,99.61 139.92,98.35
PCIE_PTX_DRX_N14: length 192.3
  IN1 w0.094: v1(29.66,28.63) 29.34,28.96 29.34,29.57 32.73,32.97 32.73,50.46 33.78,51.52 33.78,53.17 35.94,55.32 35.94,63.55 37.85,65.46 39.95,67.56 39.95,67.56 40.15,67.76 40.15,68.49 40.51,68.86 40.51,70.74 40.47,70.78 40.47,73.05 40.07,73.44 40.07,77.91 40.82,78.65 40.82,79.66 45.1,83.94 45.1,85.45 45.85,86.2 45.85,92.39 45.74,92.49 45.74,94.34 52.38,100.98 52.38,101.27 53.56,102.46 54.09,102.46 56.14,104.51 61.66,104.51 61.76,104.61 63.73,104.61 64.2,104.14 66.37,104.14 66.83,104.6 78.6,104.6 78.82,104.37 80.27,104.37 80.57,104.08 91.69,104.08 92.79,105.18 93.45,105.18 94.28,106.01 99.29,106.01 99.31,105.98 110.81,105.98 111.21,105.58 113.34,105.58 114.06,106.29 117.28,106.29 117.71,106.73 122.06,106.73 123.15,105.64 137.59,105.64 140.29,102.95 140.29,102.38 140.49,102.18 140.56,102.18 v1(141.02,101.73)
  BOTTOM w0.076: UC1.BL2 139.87,91.01 139.87,92.73 139.52,93.08 139.52,98.04 139.25,98.32 139.25,98.35
  BOTTOM w0.104: v1(29.66,28.63) 29.38,28.35 29.38,28.14 28.82,27.59 28.82,27.2 CN67.2 ; v1(141.02,101.73) 140.17,101.73 139.25,100.81 139.25,98.35
PCIE_PTX_DRX_N15: length 194.9
  IN1 w0.094: v1(138.95,92.33) 138.5,92.78 138.35,92.78 138.12,92.55 137.64,92.55 136.7,93.49 136.7,94.91 137.24,95.45 137.24,96.78 137.61,97.15 137.61,98.92 133.79,102.73 121.16,102.73 120.81,102.38 114.06,102.38 113.77,102.67 109.93,102.67 109.53,103.07 95.46,103.07 93.14,100.75 81.71,100.75 80.5,99.53 76.46,99.53 74.81,101.18 70.78,101.18 70.73,101.23 60.13,101.23 59.64,100.74 56.52,100.74 54.04,98.26 54.04,97.26 51.62,94.84 51.62,94.16 49.28,91.81 49.28,87.17 48.9,86.79 48.9,82.56 44.27,77.93 44.27,76.54 43.91,76.19 43.91,74.92 43.43,74.43 43.43,67.66 43.06,67.29 43.06,66.45 41.79,65.18 41.79,61.53 41.58,61.32 41.58,59.18 40.64,58.23 40.64,54.04 41.15,53.54 41.15,51.04 39.76,49.65 37.94,49.65 36.21,47.93 36.21,28.66 33.84,26.29 29.52,26.29 27.44,28.37 25.75,28.37 25.62,28.24 25.62,28.11 v1(25.86,27.87)
  BOTTOM w0.076: v1(138.95,92.33) 139.2,92.33 139.35,92.18 139.35,91.56 139.18,91.39 139.18,91.05 139.22,90.95 139.22,90.73 139.18,90.63 139.18,90.38 139.33,90.04 139.33,89.81 UC1.BL4
  BOTTOM w0.104: CN69.2 25.35,26.42 25.35,27.03 25.66,27.34 25.66,27.67 v1(25.86,27.87)
PCIE_PTX_DRX_N16: length 198.4
  IN1 w0.094: v1(22.05,26.87) 21.73,27.19 21.73,28.06 22.61,28.95 27.69,28.95 29.77,26.87 33.6,26.87 35.63,28.9 35.63,34.22 35.06,34.79 35.06,47.59 37.85,50.39 37.85,50.98 39.18,52.31 39.18,53.01 40,53.83 40,58.47 40.96,59.43 40.96,61.59 41.21,61.83 41.21,65.46 42.47,66.73 42.47,67.53 42.84,67.9 42.84,71.86 42.82,71.89 42.82,74.81 43.28,75.27 43.28,77.45 43.15,77.59 43.15,78.69 44.87,80.42 45.64,80.42 48.32,83.1 48.32,87.04 48.7,87.42 48.7,92.44 49.42,93.17 49.42,93.7 50.68,94.96 50.68,95.17 52.86,97.35 52.86,97.9 56.28,101.32 59.4,101.32 59.89,101.81 70.72,101.81 71.17,102.27 72.53,102.27 73.04,101.77 75.05,101.77 76.7,100.12 80.26,100.12 81.29,101.15 81.47,101.33 92.24,101.33 93.76,102.85 94.41,102.85 95.22,103.66 109.77,103.66 110.18,103.25 114.37,103.25 114.64,103.52 115.81,103.52 116.37,102.96 119.83,102.96 120.18,103.31 134.04,103.31 138.19,99.16 138.19,96.77 138.01,96.59 138.01,94.88 138.21,94.68 138.5,94.68 v1(138.95,94.23)
  BOTTOM w0.076: UC1.BJ4 138.29,89.45 138.57,89.73 138.57,90.04 138.72,90.38 138.72,90.65 138.69,90.74 138.69,90.96 138.72,91.05 138.72,91.39 138.71,91.4 138.57,91.54 138.57,93.85 v1(138.95,94.23)
  BOTTOM w0.104: CN71.2 21.88,26.4 21.88,26.69 v1(22.05,26.87)
PCIE_PTX_DRX_P5: length 167.4
  IN1 w0.094: v1(35.02,68.82) 35.22,69.02 35.76,69.02 36.54,69.8 36.54,70.3 35.95,70.88 35.95,77.46 36.58,78.09 36.58,84.13 37.84,85.39 37.84,92.01 38.49,92.66 38.49,95.16 40.34,97.01 41.13,97.01 42.35,98.22 42.35,98.84 43.15,99.64 43.83,99.64 45.95,101.76 47.92,101.76 51.11,104.94 51.11,104.99 52.29,106.17 52.29,106.7 54.84,109.24 59.98,109.24 60.25,108.97 60.76,108.97 61.03,109.24 64.7,109.24 65.3,108.64 77.8,108.64 78.22,108.22 79.99,108.22 80.35,107.86 82.2,107.86 82.56,108.22 87.55,108.22 88.84,109.5 90.98,109.5 91.33,109.86 103.48,109.86 103.74,110.12 105.09,110.12 105.74,109.47 111.01,109.47 111.76,110.22 136.04,110.22 136.27,110 137.42,110 137.99,109.43 141.01,109.43 145.86,104.59 145.86,103.1 145.25,102.5 145.25,99.77 145.54,99.48 145.75,99.48 v1(145.97,99.25)
  BOTTOM w0.076: 145.14,98.35 145.14,98.33 145.13,98.32 145.13,96.4 145.04,96.31 145.04,94.48 144.86,94.3 144.86,92.96 144.42,92.52 144.42,91.51 144.23,91.32 144.23,91.07 144.26,90.98 144.26,90.7 144.23,90.61 144.23,90.42 144.28,90.3 144.39,90.18 144.6,90.18 144.77,90.01 144.77,89.67 144.69,89.59 144.57,89.59 144.49,89.67 UC1.BW3
  BOTTOM w0.104: CT2.1 33.42,69.04 33.42,68.79 33.63,68.57 34.16,68.57 34.41,68.82 v1(35.02,68.82) ; v1(145.97,99.25) 145.67,99.56 145.35,99.56 145.14,99.36 145.14,98.35
PCIE_PTX_DRX_P6: length 172
  IN1 w0.094: v1(145.97,101.79) 145.97,101.67 146.14,101.5 146.34,101.5 146.44,101.59 146.44,105.72 145.97,106.19 145.53,106.19 141.68,110.04 138.2,110.04 137.66,110.59 136.55,110.59 136.34,110.8 111.51,110.8 110.77,110.05 105.98,110.05 105.34,110.7 103.5,110.7 103.23,110.44 89.29,110.44 89.28,110.43 88.95,110.43 87.31,108.8 78.46,108.8 78.01,109.25 65.56,109.25 64.99,109.82 60.92,109.82 60.83,109.91 59.54,109.91 59.48,109.86 59.02,109.86 59.01,109.86 58.46,109.86 58.41,109.91 58.1,110.22 57.21,110.22 56.81,109.82 54.59,109.82 52.66,107.89 52.57,107.89 50.54,105.86 50.54,105.77 48.51,103.74 47.02,103.74 43.52,100.24 42.82,100.24 41.73,99.14 41.73,98.43 40.9,97.6 39.11,97.6 38.43,96.93 38.43,95.93 37.91,95.4 37.91,92.9 37.26,92.25 37.26,90.3 36.54,89.57 36.54,85.9 35.95,85.32 35.95,78.28 34.64,76.97 34.64,76.79 34.2,76.36 34.2,71.6 33.85,71.25 33.85,68.38 33.44,67.97 30.89,67.97 v1(30.22,68.64)
  BOTTOM w0.076: 144.35,98.35 144.35,98.33 144.36,98.32 144.36,97.61 143.28,96.53 143.28,92.14 143.47,91.94 143.47,91.16 143.4,90.98 143.4,90.84 143.41,90.84 143.41,90.7 143.44,90.61 143.44,90.42 143.22,89.91 UC1.BU3
  BOTTOM w0.104: CT4.1 30.42,69.02 30.42,68.84 v1(30.22,68.64) ; 144.35,98.35 144.35,101.05 144.65,101.35 145.53,101.35 145.66,101.48 145.66,101.71 145.75,101.79 v1(145.97,101.79)
PCIE_PTX_DRX_P7: length 170.7
  IN1 w0.094: v1(143.51,97.28) 144.37,97.28 144.85,97.76 144.85,102.66 145.23,103.04 145.23,104.65 142.72,107.16 140.55,107.16 138.97,108.73 138.08,108.73 137.3,109.52 129.36,109.52 129.17,109.33 128.1,109.33 127.91,109.52 125.93,109.52 125.72,109.32 124.58,109.32 124.08,109.82 111.92,109.82 111.17,109.07 105.58,109.07 104.93,109.72 103.9,109.72 103.64,109.46 91.5,109.46 89.86,107.82 82.73,107.82 82.37,107.46 80.12,107.46 79.77,107.81 76.93,107.81 76.53,108.22 64.97,108.22 64.41,108.77 61.13,108.77 60.93,108.57 60.09,108.57 59.89,108.77 54.93,108.77 52.92,106.76 52.92,106.23 51.51,104.82 51.51,104.78 48.09,101.36 46.12,101.36 44,99.24 43.71,99.24 43.37,98.9 43.37,98.56 39.25,94.43 39.25,92.85 38.24,91.85 38.24,85.16 36.98,83.9 36.98,77.92 36.35,77.29 36.35,71.05 36.93,70.47 36.93,69.63 34.88,67.57 29.11,67.57 28.4,68.27 28.4,68.39 v1(28.6,68.59)
  BOTTOM w0.076: v1(143.51,97.28) 143.51,97.42 143.28,97.65 143.15,97.65 143.02,97.53 143.02,97.09 143.1,97.01 143.19,97.01 143.26,96.93 143.26,96.78 143.19,96.71 143.1,96.71 143.02,96.63 143.02,91.95 143.1,91.88 143.25,91.88 143.31,91.82 143.31,91.64 143.23,91.56 143.1,91.56 143.02,91.48 143.02,91.32 UC1.BU1
  BOTTOM w0.104: v1(28.6,68.59) 28.4,68.78 28.4,69 CT123.1
PCIE_PTX_DRX_P8: length 171.3
  IN1 w0.094: v1(26.3,68.59) 26.7,68.18 26.7,67.73 26.99,67.43 28.14,67.43 28.77,66.81 35.2,66.81 37.78,69.39 37.78,70.7 37.12,71.37 37.12,76.97 37.75,77.6 37.75,83.51 39,84.77 39,91.53 40.01,92.53 40.01,93.73 42.05,95.77 42.9,95.77 44.16,97.03 44.16,97.63 45.83,99.31 46.35,99.31 47.52,100.47 48.28,100.47 52.27,104.46 52.27,104.51 53.68,105.92 53.68,106.44 55.25,108.01 59.57,108.01 59.77,107.81 61.24,107.81 61.44,108.01 63.91,108.01 64.78,107.14 65.5,107.14 65.72,106.92 67.16,106.92 67.68,107.45 76.15,107.45 76.67,106.92 79.58,106.92 79.8,106.7 82.69,106.7 83.04,107.06 90.18,107.06 91.81,108.69 103.01,108.69 103.39,108.31 111.49,108.31 112.24,109.06 123.53,109.06 124.22,108.36 136.25,108.36 136.65,107.97 138.65,107.97 141.93,104.69 144.1,104.69 144.46,104.33 144.46,103.36 144.09,102.98 144.09,99.57 143.96,99.45 143.71,99.45 143.53,99.64 v1(143.53,99.76)
  BOTTOM w0.076: 142.88,98.35 142.88,98.1 142.53,97.76 142.53,90.27 UC1.BT3
  BOTTOM w0.104: v1(26.3,68.59) 26.49,68.78 26.49,68.97 CT125.1 ; 142.88,98.35 142.88,98.75 143.14,99.02 143.14,99.38 v1(143.53,99.76)
PCIE_PTX_DRX_P9: length 216
  TOP w0.104: v1(283.91,66.65) 284.07,66.49 284.39,66.49 284.68,66.21 284.68,64.67 284.78,64.56 284.93,64.56 CR11.1
  IN4 w0.094: v1(283.91,66.65) 283.71,66.45 283.31,66.45 283.09,66.22 283.09,65.21 283.41,64.89 284.42,64.89 285.57,63.75 285.57,63.11 285.12,62.67 285.12,61.53 285.31,61.33 285.31,60.38 284.26,59.33 281.91,59.33 281.39,58.81 281.39,57.67 281.09,57.38 278.79,57.38 278.51,57.66 278.51,58.74 277.97,59.28 275.56,59.28 275.34,59.05 272.88,59.05 272.24,58.41 270.43,58.41 269.74,59.1 266.11,59.1 265.62,58.61 264.92,58.61 262.47,56.16 261.9,56.16 256.83,51.09 256.83,50.32 255.96,49.45 254.63,49.45 252.99,47.81 252.99,45.96 252.47,45.45 244.14,45.45 241.81,43.12 240.05,43.12 238.71,41.78 230.57,41.78 229.66,42.69 223.03,42.69 222.61,43.11 219.34,43.11 216.47,45.98 214.72,45.98 196.22,64.48 196.22,70.97 194.4,72.78 194.4,73.52 193.4,74.52 193.4,76.24 190.01,79.63 187.67,79.63 185.29,82.01 185.29,82.69 184.47,83.51 184.47,83.73 184.11,84.09 184.11,85.05 180.27,88.89 180.27,92.72 178.83,94.16 178.83,95.13 175.36,98.6 173.31,98.6 172.68,99.24 169.62,99.24 168.68,100.18 168.39,100.18 162.34,106.23 156.79,106.23 155.21,104.65 151.66,104.65 151.32,104.32 147.07,104.32 144.92,102.17 144.92,102.05 144.02,101.14 143.8,101.14 v1(143.52,101.43)
  BOTTOM w0.076: UC1.BR1 142.16,91.27 142.16,92.04 142.16,94.33 142.16,97.93 142.28,98.05 142.28,98.35
  BOTTOM w0.104: 142.28,98.35 142.28,100.82 142.46,101.01 143.03,101.01 143.14,101.11 143.14,101.32 143.24,101.43 v1(143.52,101.43)
PCIE_PTX_DRX_P10: length 168.4
  IN4 w0.094: v1(252.49,46.56) 252.38,46.44 252.38,46.05 252.17,45.85 243.97,45.85 241.65,43.52 239.88,43.52 238.55,42.18 230.74,42.18 229.84,43.09 223.2,43.09 222.78,43.51 219.51,43.51 216.64,46.38 214.88,46.38 197.36,63.9 197.36,71.49 196.97,71.88 196.8,71.88 194.92,73.76 194.92,75.31 190.16,80.07 189.49,80.07 188.15,81.41 186.45,81.41 185.69,82.17 185.69,82.85 185.24,83.3 185.24,85.1 185.15,85.19 184.62,85.19 180.67,89.14 180.67,92.89 179.64,93.91 179.64,94.93 177.94,96.63 177.94,97.33 174.83,100.45 171.22,100.45 171.17,100.39 170.88,100.39 169.11,102.16 169.11,103.1 166.62,105.59 163.54,105.59 162.51,106.63 156.62,106.63 155.05,105.05 151.39,105.05 151.05,104.72 146.9,104.72 144.67,102.48 143.52,102.48 v1(143.52,102.48)
  BOTTOM w0.076: UC1.BR3 142.14,89.78 142.29,89.78 142.37,89.85 142.37,90.08 142.23,90.22 141.93,90.22 141.86,90.29 141.82,90.33 141.79,90.42 141.79,90.61 141.82,90.7 141.82,90.98 141.79,91.07 141.79,91.32 141.91,91.45 141.91,97.93 141.85,97.99 141.85,98.34 141.87,98.35
  BOTTOM w0.104: CZ12.1 252.97,44.91 252.65,44.91 252.23,45.33 252.23,46.3 v1(252.49,46.56) ; 141.87,98.35 141.87,101.79 142.93,102.85 143.13,102.85 143.2,102.77 143.2,102.61 143.33,102.48 v1(143.52,102.48)
PCIE_PTX_DRX_P11: length 155.6
  TOP w0.104: v1(237.76,44.64) 237.39,45.01 237.39,45.36 237.89,45.86 239.25,45.86 CZ152.1
  IN4 w0.094: v1(141.05,96.88) 140.8,96.88 140.71,96.78 140.71,96.53 140.6,96.43 140.45,96.43 140.35,96.52 140.35,102.23 144.31,106.19 145.51,106.19 145.61,106.29 149,106.29 149.34,106.62 150.14,106.62 150.39,106.87 151.31,106.87 151.56,106.62 153.97,106.62 155.47,108.13 155.66,108.13 155.89,108.36 157.2,108.36 158.63,109.78 160.62,109.78 161.22,109.19 165.24,109.19 171,103.43 173.43,103.43 174.38,102.48 175.01,102.48 180.35,97.14 180.35,96.5 181.63,95.23 181.63,94.15 182.24,93.54 182.24,89.79 185.27,86.76 186.03,86.76 188.83,83.96 189.3,83.96 189.79,83.47 189.79,82.91 199.18,73.53 199.18,64.88 203.69,60.36 203.69,59.79 215.53,47.95 217.29,47.95 220.16,45.08 223.43,45.08 223.85,44.66 231.83,44.66 232.55,43.94 237.24,43.94 237.49,44.18 237.49,44.36 v1(237.76,44.64)
  BOTTOM w0.076: UC1.BN3 140.78,89.91 141,90.42 141,90.61 140.97,90.7 140.97,90.98 141,91.07 141,91.32 140.84,91.48 140.84,93.29 140.48,93.65 140.48,95.43 140.48,95.9 140.7,96.12 140.7,96.45 141.05,96.81 v1(141.05,96.88)
PCIE_PTX_DRX_P12: length 206.5
  TOP w0.104: v1(276.14,57.93) 276.63,57.93 277.31,57.25 277.31,52.87 277.76,52.42 278.92,52.42 279.19,52.69 279.19,53.07 CZ211.1
  IN4 w0.094: v1(141.05,98.15) 141.28,98.37 141.59,98.37 141.68,98.28 141.68,96.92 142.84,95.76 144.55,95.76 145.16,96.38 145.9,96.38 146.81,97.29 146.81,102.15 148.16,103.51 151.59,103.51 151.97,103.89 155.53,103.89 157.1,105.46 162.03,105.46 166.76,100.72 166.76,100.12 169.01,97.88 171.74,97.88 172.79,96.83 176.05,96.83 178.07,94.82 178.07,92.63 179.5,91.19 179.5,88.57 183.34,84.73 183.34,83.77 183.71,83.41 183.71,82.51 187.35,78.87 189.65,78.87 192.61,75.91 192.61,74.23 193.56,73.28 193.56,71.48 195.45,69.59 195.45,64.16 214.4,45.21 216.16,45.21 219.03,42.34 222.3,42.34 222.72,41.92 229.34,41.92 230.25,41.02 239.03,41.02 240.33,42.33 242.3,42.33 243.31,43.33 244,43.33 245.36,44.69 252.79,44.69 253.93,45.83 253.93,47.66 254.74,48.46 256.21,48.46 258.23,50.48 258.53,50.48 260.52,52.47 262.3,52.47 263.47,53.63 263.47,54.19 266.64,57.37 274.87,57.37 275.55,58.05 276.03,58.05 v1(276.14,57.93)
  BOTTOM w0.076: v1(141.05,98.15) 140.86,98.15 140.78,98.22 140.78,98.45 140.71,98.53 140.6,98.53 140.44,98.37 140.44,97.98 140.52,97.9 140.65,97.9 140.72,97.83 140.72,97.67 140.65,97.6 140.52,97.6 140.44,97.52 140.44,97.34 140.52,97.27 140.58,97.27 140.66,97.19 140.66,97.04 140.58,96.96 140.52,96.96 140.44,96.89 140.44,96.57 140.26,96.39 140.26,93.49 140.63,93.12 140.63,91.27 UC1.BN1
PCIE_PTX_DRX_P13: length 190.4
  IN1 w0.094: v1(31.49,28.76) 31.56,28.83 31.56,31.11 33.13,32.67 33.13,48.39 35.69,50.95 35.69,54.41 36.33,55.05 36.33,60.45 38.48,62.6 39.28,63.4 39.28,66.33 40.35,67.39 40.35,67.4 40.55,67.6 40.55,68.33 40.91,68.69 40.91,70.9 40.86,70.95 40.86,73.21 40.47,73.6 40.47,77.74 41.22,78.48 41.22,79.49 46.25,84.52 46.25,92.75 47.47,93.98 47.47,95.51 52.78,100.82 52.78,101.11 53.73,102.06 54.26,102.06 56.3,104.11 61.15,104.11 61.52,103.74 66.79,103.74 67.25,104.2 78.36,104.2 78.59,103.97 80.11,103.97 80.82,103.26 88.11,103.26 88.51,103.66 91.84,103.66 92.96,104.78 93.61,104.78 94.42,105.58 110.57,105.58 110.98,105.18 113.51,105.18 114.22,105.9 120.13,105.9 120.78,105.24 137.4,105.24 139.89,102.75 139.89,100.93 140.28,100.53 v1(140.99,100.53)
  BOTTOM w0.076: 139.73,98.35 139.73,98.34 139.74,98.33 139.74,98.28 139.75,98.26 139.75,93.18 140.09,92.85 140.09,90.68 140.09,90.57 140.09,90.54 139.92,90.37 139.92,90.19 139.99,90.12 140.1,90.12 UC1.BM3
  BOTTOM w0.104: 139.73,98.35 139.73,99.69 140.27,100.24 140.69,100.24 v1(140.99,100.53) ; CN66.2 31.76,27.22 31.76,27.36 31.91,27.51 31.91,27.98 31.69,28.2 31.69,28.56 v1(31.49,28.76)
PCIE_PTX_DRX_P14: length 192.2
  IN1 w0.094: v1(29.08,28.63) 29.15,28.71 29.15,29.65 32.55,33.04 32.55,50.54 33.6,51.59 33.6,53.24 35.75,55.4 35.75,63.62 37.67,65.54 39.76,67.63 39.76,67.64 39.97,67.84 39.97,68.57 40.33,68.93 40.33,70.66 40.28,70.71 40.28,72.97 39.89,73.36 39.89,77.98 40.64,78.73 40.64,79.73 44.92,84.02 44.92,85.53 45.66,86.27 45.66,92.31 45.56,92.42 45.56,94.42 52.19,101.06 52.19,101.35 53.49,102.64 54.01,102.64 56.06,104.69 61.58,104.69 61.69,104.79 63.8,104.79 64.27,104.32 66.29,104.32 66.75,104.78 78.68,104.78 78.9,104.56 80.35,104.56 80.64,104.26 91.62,104.26 92.72,105.36 93.37,105.36 94.21,106.19 99.36,106.19 99.39,106.17 110.88,106.17 111.29,105.76 113.26,105.76 113.98,106.48 117.2,106.48 117.64,106.91 122.13,106.91 123.22,105.82 137.67,105.82 140.47,103.02 140.47,102.45 140.56,102.36 v1(141.02,102.36)
  BOTTOM w0.076: 139.05,98.35 139.05,98.29 139.07,98.28 139.07,98.26 139.36,97.97 139.36,93.01 139.71,92.66 139.71,91.26 139.67,91.22 UC1.BL1
  BOTTOM w0.104: v1(29.08,28.63) 29.18,28.53 29.18,28.22 28.63,27.67 28.63,27.2 CN68.2 ; 139.05,98.35 139.05,100.89 140.09,101.92 140.54,101.92 140.64,102.02 140.64,102.26 140.75,102.36 v1(141.02,102.36)
PCIE_PTX_DRX_P15: length 194.9
  IN1 w0.094: v1(25.28,27.87) 25.44,28.03 25.44,28.32 25.67,28.55 27.52,28.55 29.6,26.47 33.77,26.47 36.03,28.73 36.03,48 37.86,49.83 39.68,49.83 40.96,51.12 40.96,53.46 40.46,53.97 40.46,58.31 41.4,59.25 41.4,61.39 41.61,61.6 41.61,65.26 42.87,66.53 42.87,67.36 43.25,67.74 43.25,74.51 43.73,74.99 43.73,76.27 44.08,76.62 44.08,78 48.72,82.64 48.72,86.87 49.1,87.25 49.1,91.89 51.44,94.23 51.44,94.92 53.86,97.34 53.86,98.34 56.44,100.92 59.56,100.92 60.06,101.41 70.8,101.41 70.85,101.37 74.88,101.37 76.53,99.72 80.42,99.72 81.64,100.93 93.06,100.93 95.39,103.26 109.6,103.26 110.01,102.85 113.84,102.85 114.13,102.56 120.73,102.56 121.09,102.91 133.87,102.91 137.79,99 137.79,97.07 137.42,96.7 137.42,95.37 136.88,94.83 136.88,93.56 137.71,92.74 138.05,92.74 138.27,92.96 v1(138.95,92.96)
  BOTTOM w0.076: v1(138.95,92.96) 139.26,92.65 139.26,92.5 139.52,92.25 139.52,91.49 139.35,91.32 139.35,91.07 139.38,90.98 139.38,90.7 139.35,90.61 139.35,90.42 139.41,90.27 139.61,90.07 UC1.BL3
  BOTTOM w0.104: CN70.2 25.15,26.39 25.15,27.11 25.47,27.42 25.47,27.68 v1(25.28,27.87)
PCIE_PTX_DRX_P16: length 198.4
  IN1 w0.094: v1(138.95,94.87) 138.28,94.87 138.19,94.96 138.19,96.51 138.37,96.7 138.37,99.24 134.11,103.5 120.11,103.5 119.75,103.14 116.44,103.14 115.88,103.7 114.57,103.7 114.3,103.43 110.25,103.43 109.84,103.84 95.14,103.84 94.34,103.03 93.68,103.03 92.16,101.51 81.4,101.51 81.22,101.33 80.18,100.3 76.77,100.3 75.13,101.95 73.12,101.95 72.61,102.45 71.1,102.45 70.64,102 59.82,102 59.32,101.5 56.2,101.5 52.68,97.98 52.68,97.43 50.5,95.24 50.5,95.04 49.24,93.78 49.24,93.24 48.52,92.52 48.52,87.49 48.14,87.11 48.14,83.18 45.56,80.6 44.79,80.6 42.96,78.77 42.96,77.51 43.1,77.38 43.1,75.35 42.63,74.88 42.63,71.82 42.66,71.79 42.66,67.97 42.29,67.6 42.29,66.81 41.02,65.54 41.02,61.91 40.78,61.67 40.78,59.51 39.82,58.55 39.82,53.91 39,53.08 39,52.39 37.67,51.06 37.67,50.47 34.87,47.67 34.87,34.72 35.45,34.14 35.45,28.98 33.53,27.05 29.84,27.05 27.76,29.13 22.54,29.13 21.55,28.14 21.55,26.94 v1(21.47,26.87)
  BOTTOM w0.076: v1(138.95,94.87) 138.95,94.73 138.6,94.38 138.6,94.11 138.41,93.92 138.41,91.47 138.55,91.33 138.56,91.32 138.56,91.07 138.52,90.98 138.52,90.7 138.56,90.61 138.56,90.42 138.34,89.91 138.29,89.86 UC1.BJ3
  BOTTOM w0.104: CN72.2 21.68,26.38 21.68,26.65 v1(21.47,26.87)
PCIE_PTX_L_DRX_N11: length 2.8
  TOP w0.104: v1(275.8,55.22) 275.95,55.07 275.95,54.64 275.87,54.56 LI17.2
  BOTTOM w0.104: v1(275.8,55.22) 275.99,55.4 275.99,55.81 275.68,56.12 JNGFF2.35
PCIE_PTX_L_DRX_P11: length 2.8
  TOP w0.104: v1(276.42,55.22) 276.14,54.94 276.14,54.82 276.37,54.59 LI17.3
  BOTTOM w0.104: v1(276.42,55.22) 276.18,55.45 JNGFF2.37
PCIE_PTX_SW_DRX_N11: length 40.7
  TOP w0.104: v1(249.5,41.72) 249.5,44 249.32,44.18 249.32,44.19 248.95,44.56 248.94,44.56 248.1,45.4 246.31,45.4 246.08,45.17 UZ29.8 ; LI17.1 275.87,52.85 275.72,52.7 275.16,52.7 274.93,52.48 274.93,52.13 v1(275.32,51.75)
  IN1 w0.094: v1(249.5,41.72) 249.5,42.04 249.56,42.11 250.99,42.11 251.87,42.99 263.15,42.99 264.39,44.23 267.95,44.23 268.51,44.79 268.97,44.79 270.97,46.79 271.27,46.79 273.1,48.62 273.1,50.01 274.45,51.36 274.45,51.65 274.54,51.75 v1(275.32,51.75)
PCIE_PTX_SW_DRX_P11: length 40.6
  TOP w0.104: v1(248.91,41.72) 249.31,42.11 249.31,43.92 v4(248.99,44.23) 248.02,45.21 246.39,45.21 246.16,44.98 245.98,44.98 245.67,44.67 UZ29.7 ; LI17.4 276.37,52.82 275.87,52.32 v1(275.32,52.32)
  IN1 w0.094: v1(275.32,52.32) 274.93,51.93 274.46,51.93 274.26,51.73 274.26,51.43 272.92,50.09 272.92,48.7 271.19,46.97 270.89,46.97 268.89,44.97 268.43,44.97 267.87,44.41 264.32,44.41 263.08,43.17 251.79,43.17 250.91,42.29 249.49,42.29 v1(248.91,41.72)
PCIE_RCOMPN: length 8.6
  TOP w0.381: v1(150,94.19) 150,95.2 RC50.1
  IN4 w0.2: v1(150,94.19) 150,91.55 148.3,89.85 148.3,88.46 v1(148.72,88.04)
  BOTTOM w0.2: v1(148.72,88.04) UC1.CE6
PCIE_RCOMPP: length 8.8
  TOP w0.127: v2(151.33,93.58) 150.85,94.06 v1(150.84,94.06)
  TOP w0.381: v1(150.84,94.06) 150.74,94.15 150.74,94.79 150.96,95 RC50.2
  IN4 w0.2: v1(148.72,88.67) 150.56,90.52 150.56,93.78 v1(150.84,94.06)
  BOTTOM w0.2: v1(148.72,88.67) UC1.CE5
PCIE_WAKE#: length 383.9
  TOP w0.127: v2(39.45,43.99) 39.91,43.53 v1(39.91,43.36) ; v1(282.07,55.73) 282.21,55.59 282.64,55.59 RE275.2 RE274.1
  IN1 w0.076: JNGFF3.54 20.63,20.89
  IN1 w0.084: 20.63,20.89 20.63,21.05 18.28,23.4 18.28,26.1 v1(17.75,26.63) ; v1(255.39,40.44) 254.84,40.99 253.68,40.99 253.2,40.51 253.2,40.02 252.94,39.76 247.24,39.76 246.43,38.95 244.58,38.95 244.43,39.09 243.48,39.09 243.32,38.93 229.43,38.93 228.8,38.31 221.45,38.31 219.07,40.69 215.79,40.69 197.84,58.64 195.57,58.64 195.14,59.08 193.09,59.08 v1(193.02,59.01)
  IN2 w0.122: v1(39.91,43.36) 39.91,43.02 40.71,42.22 41.68,42.22 42.49,41.41 42.49,40.27 42.83,39.93 43.1,39.93 44.35,38.67 54.79,38.67 55.96,39.84 64.54,39.84 64.78,40.07 67.44,40.07 68.27,40.9 79.18,40.9 80,40.07 81.58,40.07 82.67,41.17 82.67,41.17 85.76,44.25 113.24,44.25 115.08,42.41 122.44,42.41 122.82,42.03 125.39,42.03 125.51,42.15 125.51,42.18 125.99,42.66 126.67,42.66 127.15,42.18 127.15,42.15 127.27,42.03 133.07,42.03 135.43,39.66 157.41,39.66 160.66,42.91 184.75,42.91 189.4,47.56 191.74,47.56 196.39,42.91 197.48,42.91 197.74,43.16 197.74,45.02 195.84,46.91 195.84,56.79 193.62,59.01 v1(193.02,59.01) ; v1(277.92,55.78) 279.47,57.33 279.47,59.24 279.26,59.45 v1(279.26,59.75)
  IN4 w0.084: v1(255.39,40.44) 255.76,40.06 257.69,40.06 258.6,39.15 260.36,39.15 260.81,39.6 260.81,40.66 258.58,42.89 258.58,46.93 261.18,49.53 262.57,49.53 265.93,52.89 266.35,52.89 267.51,54.05 271.36,54.05 271.9,54.6 276.78,54.6 277.92,55.74 v1(277.92,55.78) ; v1(17.75,26.63) 17.23,27.15 17.23,30.38 19.28,32.43 22.17,32.43 22.98,33.24 22.98,35.74 24.27,37.02 25.72,37.02 26.16,37.46 28.14,37.46 28.57,37.02 35.59,37.02 38.8,40.24 38.8,42.26 v1(39.91,43.36)
  BOTTOM w0.127: v1(277.92,55.78) 277.92,54.89 278.4,54.41 280.93,54.41 282.07,55.55 282.07,55.73 v1(282.07,55.73) ; v1(279.26,59.75) 279.26,61.02 280.43,62.19 JNGFF2.54 ; JNGFF1.55 255.83,40.88 255.39,40.44 v1(255.39,40.44) ; v1(39.91,43.36) 39.57,43.71 39.57,46.92 40.01,47.36 40.01,49.14 39.06,50.1 39.06,54.22 38.04,55.24 38.04,58.99 38.42,59.37 38.42,61.96 38.83,62.36 38.83,62.78 RT448.1
PCIE_WAKE#_AR: length 64.6
  TOP w0.127: v1(27.18,63.87) 27.25,63.87 27.44,63.68 28.01,63.68 28.64,64.32 28.64,65.53 30.17,67.05 37.03,67.05 v3(37.78,66.29) v1(38.5,65.57) ; v1(29.15,89.4) 29.15,89.26 RT455.1
  IN2 w0.122: v1(30.59,84.19) 30.59,84.68 31.07,85.16 31.07,86.6 30.81,86.85 30.37,86.85 30.22,87 30.22,87.63 29.15,88.7 v1(29.15,89.4)
  IN3 w0.122: v1(30.59,84.19) 30.59,84.36 31.18,84.96 35.49,84.96 35.86,84.58 36.51,84.58 37.17,83.93 37.17,78.97 38.08,78.06 38.08,76.21 37.23,75.36 37.23,69.54 35.67,67.98 34.44,67.98 33.4,69.03 26.19,69.03 25.9,68.75 25.9,65.15 v1(27.18,63.87)
  BOTTOM w0.076: UT1.W1 30,82.82 30.17,82.99 30.17,83.01 30.21,83.05 30.21,83.66 30.36,83.81
  BOTTOM w0.127: v1(30.59,84.19) 30.59,84.04 30.36,83.81 ; v1(38.5,65.57) 38.42,65.65 RT441.2
PCIE_WAKE#_AR_R: length 3.5
  BOTTOM w0.127: RT441.1 RT440.2 38.6,67.39 38.78,67.57 38.78,67.9 39.16,68.28 v2(39.26,68.28) 39.39,68.15 UT32.4
PCIE_WAKE#_R: length 49.2
  TOP w0.127: v1(284.23,54.22) 284.13,54.12 v2(283.15,54.12) 282.9,54.12 282.64,54.38 RE275.1 ; RE35.1 283.41,89.42 v1(283.41,89.41) 283.41,89.41 283.41,88.33 282.44,87.36 UE1.N13
  IN2 w0.122: v1(283.41,89.41) 283.8,89.81 284.2,89.81 284.42,89.59 285.8,89.59 286.93,88.46 286.93,87.46 285.57,86.1 285.57,84.26 285.38,84.07 285.38,80.74 286.25,79.86 286.25,79.54 285.12,78.41 285.12,75.98 283.86,74.73 283.86,73.58 283.5,73.21 282.77,73.21 282.22,72.66 282.22,68.68 282.67,68.24 282.67,67.52 281.79,66.64 281.79,61.8 283.67,59.92 283.67,59.26 284.08,58.86 284.08,58.02 283.67,57.61 283.67,54.79 v1(284.23,54.22)
PD1_GPIO2: length 3.9
  TOP w0.127: v2(32.4,63.09) v1(32.4,62.42) 32.4,61.92 32.07,61.59 RT71.2
  BOTTOM w0.076: UT5.D10 32.02,60.74 32.02,61.27 32.25,61.5
  BOTTOM w0.127: v1(32.4,62.42) 32.4,61.65 32.25,61.5
PD1_GPIO8: length 4.7
  TOP w0.089: RT76.1 29.25,55.63 v2(29.58,55.63)
  TOP w0.127: RT76.1 28.74,56.69 28.52,56.92 28.52,57.6 29.04,58.12 RT377.1 29.77,58.12 v1(29.8,58.14)
  BOTTOM w0.076: v1(29.8,58.14) 29.93,58.14 UT5.H6
PD#: length 9.2
  TOP w0.203: UA1.2 277.8,42.24 277.03,43.01 CA31.1 277.03,43.26 276.74,43.55 v2(275.68,43.55) 275.47,43.55 275.09,43.94 274.45,43.94 273.96,44.43 RA18.1 273.79,44.74 273.79,45.64 RA48.2 272.61,46.06 DA8.2 272.36,45.8 RA50.2
PECI_EC: length 243.9
  TOP w0.127: v1(133.64,99.24) 133.36,99.24 v2(133.13,99.02) ; RE60.2 v1(280.12,91.7)
  IN1 w0.084: v1(266.11,89.78) 266.24,89.65 270.14,89.65 270.56,89.23 271.12,89.23 271.26,89.38 273.16,89.38 275.02,91.24 278.14,91.24 278.59,91.7 v1(280.12,91.7)
  IN4 w0.084: v1(133.64,99.24) 133.71,99.32 133.71,100.87 133.32,101.27 133.32,105.57 135.15,107.41 135.15,111.22 137.03,113.09 145.78,113.09 147.46,111.41 148.55,111.41 149.25,112.1 152.57,112.1 153.16,112.7 156.95,112.7 157.35,113.09 166.44,113.09 170.37,109.17 174.72,109.17 179.47,104.41 179.86,104.41 180.24,104.03 180.24,103.87 184.77,99.34 184.77,97.28 185.47,96.59 185.47,95.47 188.58,92.36 188.58,90.54 190.61,88.51 190.61,87.83 195.02,83.43 195.35,83.43 195.78,83 195.78,82.29 198.41,79.65 198.41,79.08 202.31,75.19 202.31,66.53 206.93,61.91 206.93,60.98 216.83,51.08 218.78,51.08 219.32,50.54 219.66,50.54 219.98,50.21 220.23,50.21 220.61,49.83 221.56,49.83 223.18,48.21 224.73,48.21 225.15,47.79 240.78,47.79 242.38,49.39 244.22,49.39 245.49,50.66 246.2,50.66 246.63,50.23 247.69,50.23 250.27,52.81 251.76,52.81 256.99,58.03 258.64,58.03 260.92,60.32 260.92,68.5 262.12,69.71 262.12,76.25 262.14,76.5 262.14,82.93 266.11,86.9 v1(266.11,89.78)
  BOTTOM w0.114: 129.8,98.35 128.85,97.4 128.85,93.46 129.82,92.48 129.82,91.19 UC1.AR1
  BOTTOM w0.127: v1(133.64,99.24) 133.62,99.24 133.11,99.75 131.2,99.75 129.8,98.35
PECI_EC_R: length 3
  TOP w0.127: RE60.1 279.97,90.04 v2(279.97,89.25) 279.97,87.5 UE1.K13
PGOOD_3V: length 4.2
  TOP w0.127: v2(187.53,94.65) 187.09,95.09 187.09,95.57 PR107.2
  TOP w0.254: PR107.2 187.47,95.95 PR119.1 188.44,96.74 188.67,96.97 PU100.9
PGOOD_5V: length 212.5
  TOP w0.254: PU102.9 46.45,28.66 47.07,29.28 v2(47.07,30.05) 47.39,30.37 47.39,32.94 PR113.2 46.18,34.14 43.12,34.14 v1(42.86,33.88)
  IN2 w0.122: v1(171,98.54) 171.51,99.05 173.53,99.05 175.12,97.47 177.49,97.47 181.01,93.94 183.95,93.94 184.36,94.35 v1(184.36,95.41)
  IN3 w0.122: v1(58.59,49.76) 58.59,49.2 58.71,49.07 60.56,49.07 61.16,49.68 70.9,49.68 72.21,50.99 73.19,50.99 73.21,51.02 87.17,51.02 90.8,54.66 133.69,54.66 138.82,59.78 138.82,62.84 139.34,63.35 140.55,63.35 141.41,62.48 141.41,60.96 144.38,58 146,58 149.54,61.53 149.54,63.44 149.87,63.77 149.87,63.78 149.87,66.23 150.13,66.49 150.13,68.12 150.36,68.35 152.29,68.35 155.99,72.05 159.57,72.05 160.09,72.57 160.83,72.57 161.44,73.18 161.44,75.19 161.63,75.39 161.63,77.17 161.89,77.43 161.89,81.13 164.24,83.47 166.06,83.47 166.83,84.24 170.13,84.24 172.49,86.61 172.49,87.91 172.08,88.32 172.08,89.15 172.22,89.29 172.22,91.21 170.4,93.03 170.4,96.89 171,97.48 v1(171,98.54)
  IN4 w0.084: v1(42.86,33.88) 42.86,34.3 41.98,35.17 41.98,37.65 43.38,39.05 44.4,39.05 52.27,46.92 54.21,46.92 56.24,48.95 58.3,48.95 58.59,49.25 v1(58.59,49.76)
  BOTTOM w0.254: v1(184.36,95.41) 184.75,95.8 PR120.1
PLTRST_TPM#: length 24.3
  TOP w0.127: v1(196.41,73.06) 197.6,73.06 RC738.2 198.77,73 v2(198.77,73.17) 198.77,73.35 RC60.2 ; UZ12.17 181.41,78.08 181.16,77.83 180.75,77.83 v1(180.74,77.82)
  IN2 w0.122: v1(196.41,73.06) 194.15,73.06 192.22,74.99 192.22,76.33 189.64,78.91 182.35,78.91 181.26,77.82 v1(180.74,77.82)
PM_LANPHY_ENABLE: length 9.2
  TOP w0.127: T422.1 144.66,63.16 v1(144.09,63.73)
  BOTTOM w0.076: v1(144.09,63.73) 144.57,64.21 144.57,66.06 143.31,67.32 143.31,68.16 143.22,68.26 143.15,68.41 143.15,68.66 143.22,68.81 143.31,68.91 143.31,69.98 143.56,70.23 UC1.BU34
PME#: length 1
  TOP w0.127: T12.1 v1(146.67,71.31)
  BOTTOM w0.089: UC1.CA32 146.29,71.49 v1(146.67,71.31)
POWER_SW#_MB: length 193.5
  TOP w0.127: v1(290.71,26.66) v3(289.21,26.66) 288.17,26.66 286.76,28.07 276.03,28.07 274.6,29.5 v1(274.6,29.94) ; v1(268.09,71.02) 267.93,70.86 266.74,70.86 266.45,71.15 266.45,72.52 266.26,72.71 CE10.1 265.8,72.94 RE33.2 ; RZ1414.1 257.97,31.9 v1(258.25,32.18) ; SW3.3 v1(309.47,100.5) SW3.4
  IN1 w0.084: v1(258.25,32.18) 258.38,32.05 260.41,32.05 261.17,32.81 264.64,32.81 265.17,33.33 268.25,33.33 270.15,35.23 271.33,35.23 274.71,38.6 274.71,43.86 275.65,44.81 276.14,44.81 277.38,46.04 277.38,46.49 278.39,47.5 279.04,47.5 279.92,48.38 279.92,49.95 279.92,49.95 279.92,50.16 281.89,52.13 294.55,52.13 295.92,53.51 295.92,57.02 295.02,57.93 295.02,61.9 295.69,62.58 295.69,67.22 295.12,67.8 295.12,68.92 296.03,69.83 296.03,71.39 296.24,71.61 296.24,72.72 v1(295.79,73.17) 295.79,76.82 295.67,76.94 295.67,82.8 295.15,83.32 295.15,84.5 295.67,85.02 295.67,89.35 298.37,92.05 298.37,93.38 298.91,93.92 305.25,93.92 307.78,96.45 307.78,98.53 309.47,100.22 v1(309.47,100.5) ; v1(288.81,73.1) 288.48,73.1 288.36,72.98 288.36,72.12 288.08,71.85 287.77,71.85 287.56,72.06 287.56,72.23 287.19,72.6 286.18,72.6 285.97,72.39 284.7,72.39 283.6,71.29 283.6,71.16 283.22,70.78 282.8,70.78 281.38,72.19 280.69,72.19 280.38,71.88 277.95,71.88 277.32,71.25 275.5,71.25 274.98,70.72 272.06,70.72 271.76,71.02 v1(268.09,71.02)
  IN4 w0.084: v1(258.25,32.18) 258.25,30.68 259.18,29.74 264.32,29.74 264.81,30.23 265.72,30.23 266.21,29.74 273.21,29.74 273.41,29.94 v1(274.6,29.94)
  BOTTOM w0.127: v1(290.71,26.66) 291.34,26.66 293.44,28.76 293.44,29.52 293.45,29.53 JAPS1.11 ; v1(288.81,73.1) 290.73,73.1 290.98,73.35 291.5,73.35 291.74,73.12 291.74,73.12 292.46,72.39 294.34,72.39 295.1,73.15 295.77,73.15 v1(295.79,73.17)
POWER_SW#_MB_USH: length 19.6
  TOP w0.127: v1(273.37,30.93) 273.9,30.93 v2(274.06,31.09) ; v1(259.66,31.49) 259.54,31.62 RZ1414.2
  IN4 w0.084: v1(259.66,31.49) 259.66,30.6 260.15,30.11 264.16,30.11 264.65,30.6 265.88,30.6 266.37,30.11 272.96,30.11 273.37,30.52 v1(273.37,30.93)
  BOTTOM w0.127: JUSH1.26 273.93,31.38 273.48,30.93 v1(273.37,30.93)
POWER_SW_IN#: length 143.2
  TOP w0.127: v1(306.06,14.1) 305.42,13.46 301.84,13.46 v2(301.75,13.37) 301.2,13.37 299.64,11.81 QZ21.3 ; v1(274.62,80.56) UE1.D5 ; v1(268.09,71.6) 267.7,71.6 267.52,71.77 267.52,72.69 268.08,73.25 268.08,74.7 267.84,74.94 CE12.1 267.25,74.64 RE31.2 RE33.1
  IN1 w0.084: v1(268.09,71.6) 268.49,71.99 269.81,71.99 270.43,71.37 271.54,71.37 271.91,71.75 272.85,71.75 273.47,71.12 274.72,71.12 275.22,71.62 277.13,71.62 277.76,72.26 280.23,72.26 280.55,72.58 285.9,72.58 286.1,72.78 287.36,72.78 v1(287.93,72.22)
  IN2 w0.122: v1(287.93,72.22) 287.74,72.03 287.74,71.41 287.74,70.35 288.74,69.36 288.74,68.22 289.26,67.7 289.26,65.88 288.23,64.85 288.23,61.69 287.66,61.12 287.66,56.34 286.96,55.64 286.96,53.91 285.57,52.51 285.31,52.51 285.28,52.48 281.59,52.48 279.82,50.7 277.37,50.7 276.26,49.59 275.92,49.59 275.12,48.78 275.12,46.07 275.41,45.78 275.41,44.9 274.64,44.14 274.64,42.41 275.61,41.45 275.61,40.26 275.28,39.94 275.28,37.27 275.6,36.95 275.6,35.66 274.6,34.66 274.6,32.87 275.81,31.66 276.36,31.66 277.18,30.83 277.18,30.28 279.95,27.52 284.65,27.52 286.99,25.18 286.99,23.45 292.51,17.93 293.51,17.93 294.61,16.82 303.94,16.82 306.06,14.7 v1(306.06,14.1)
  BOTTOM w0.127: v1(268.09,71.6) 268.52,71.6 269.68,72.75 269.68,75.23 270.44,75.99 270.44,78.92 271.41,79.88 271.96,79.88 273.05,80.97 274.3,80.97 274.62,80.64 v1(274.62,80.56)
PRIM_CORE_OPT_DIS: length 38.7
  TOP w0.127: v2(164.08,81.2) 163.99,81.11 v1(163.99,80.23)
  IN1 w0.084: v1(156.22,75.68) 155.48,75.68 154.27,76.89 148.72,76.89 148.22,76.38 148.22,75.11 147.59,74.49 v1(147.58,74.49)
  IN2 w0.122: v1(163.99,80.23) 162.37,78.61 159.46,78.61 156.52,75.68 v1(156.22,75.68)
  BOTTOM w0.089: UC1.CC27 v1(147.58,74.49)
  BOTTOM w0.127: v1(163.99,80.23) 163.99,80.52 164.39,80.92 165.59,80.92 167.35,79.15 167.74,79.15 168.88,80.29 168.88,81.32 171.5,83.94 173.17,83.94 173.69,83.42 RC854.1 175.27,83.42 RC867.1 175.7,83.85 UC9.1
PRIM_PWRGD: length 15.7
  TOP w0.127: UE1.L7 280.95,82.23 v1(281.01,82.23) ; v2(286.5,72.62) 285.69,71.81 RE361.1 285.55,71.94 285.55,72.08 285.44,72.19 CE68.1 285.44,72.7 285.97,73.23 285.97,73.76 285.77,73.96 v1(284.71,73.96)
  BOTTOM w0.127: v1(284.71,73.96) 283.74,74.92 283.22,74.92 282.17,75.98 282.17,81.56 281.5,82.23 v1(281.01,82.23)
PRIVACY_ENABLE: length 298.6
  TOP w0.127: v1(272.11,70.09) 272.1,70.1 272.1,70.1 272.23,70.22 272.6,70.22 RE820.1 RE802.1 ; UE1.F5 276.62,80.94 v1(276.24,80.57) ; v1(266.83,69.06) 267.63,69.87 v3(267.99,69.87)
  IN1 w0.084: v1(266.83,69.06) 271.04,69.06 272.07,70.09 v1(272.11,70.09)
  IN3 w0.122: v1(266.83,69.06) 266.83,68.25 265.05,66.47 265.05,63.27 264.52,62.74 264.52,57.7 264.16,57.34 264.16,57.22 263.39,56.45 261.5,56.45 260.01,54.95 260.01,54.33 259.55,53.88 258.66,53.88 257.9,53.12 255.97,53.12 253.55,50.7 253.55,50.01 252.36,48.82 250.19,48.82 247.15,45.78 245.01,45.78 244.21,44.98 242.8,44.98 242.08,44.26 242.08,44.03 241.51,43.47 234.36,43.47 234.22,43.33 232.35,43.33 230.75,44.93 218.92,44.93 208.7,55.14 196.62,55.14 196.19,55.57 196.19,58.03 191.55,62.67 191.55,74.58 188.64,77.49 188.64,80.9 187.61,81.93 187.61,82.7 186.77,83.54 186.43,83.54 186.3,83.66 186.3,85.69 182.77,89.22 182.77,93.77 180.41,96.14 180.41,97.49 179.79,98.11 179.79,100.52 177.83,102.48 177.83,103.99 173.39,108.42 167.61,108.42 167,107.81 163.08,107.81 161.75,109.14 161.11,109.14 159.99,110.26 157.33,110.26 156.53,111.06 153.87,111.06 152.65,109.84 151.23,109.84 151.09,109.98 146.69,109.98 145.84,110.83 138.81,110.83 138.72,110.92 136.86,110.92 136.41,111.37 113.81,111.37 111.43,108.99 105.72,108.99 105.16,109.55 103.35,109.55 102.54,108.74 92.56,108.74 92.52,108.77 90.3,108.77 89.67,109.4 82.81,109.4 82.49,109.72 81.48,109.72 81.33,109.87 79.23,109.87 77.77,111.33 67.42,111.33 66.96,110.86 58.76,110.86 58.69,110.8 v1(58.69,110.42)
  BOTTOM w0.127: JEDP1.3 58.23,110.88 v1(58.69,110.42) ; v1(272.11,70.09) 272.28,70.09 275.44,73.24 275.44,76.35 275.24,76.55 275.24,77.31 275.85,77.91 275.85,80.17 v1(276.24,80.57)
PROCHOT#: length 521.9
  TOP w0.127: PR678.1 58.69,56.11 PC605.2 57.45,55.62 v1(57.45,55.49) ; v1(282.12,98.86) 282.12,97.28 280.38,95.54 RE288.2 ; PR745.1 43.08,48.12 v1(41.95,46.98) 41.34,46.38 v2(41.34,45.29) 41.34,44 42.04,43.3 v1(42.04,41.01) ; PR719.1 40.4,51.77 v1(40.29,51.87) ; v1(114.93,103.14) 114.93,101.14 v1(116.45,99.63)
  IN1 w0.084: v1(294.74,93.14) 294.74,97.73 294.56,97.91 292.17,97.91 291.79,98.29 283.47,98.29 282.9,98.86 v1(282.12,98.86) ; v1(41.95,46.98) 41.95,47.22 44.39,49.66 v1(44.39,49.98)
  IN2 w0.122: v1(44.39,49.98) 43.76,50.61 43.76,51.37 41.98,53.15 41.98,54.73 41.66,55.05 41.66,56.51 42.17,57.01 42.17,66.69 42.79,67.31 42.79,73.39 45.82,76.43 45.82,78.17 48.82,81.17 48.82,86.53 49.52,87.23 49.52,93.27 49.19,93.6 49.19,95.59 50.83,97.23 50.83,98.26 55.18,102.61 55.52,102.61 56.81,103.9 59.71,103.9 60.05,103.56 60.68,103.56 61.75,102.5 65.65,102.5 67.96,104.81 80.66,104.81 80.92,104.55 83.42,104.55 83.58,104.71 83.83,104.96 87.26,104.96 87.54,104.68 91.75,104.68 92.34,105.27 102.15,105.27 103.04,104.38 109.61,104.38 114.37,99.63 v1(116.45,99.63) ; v1(294.74,93.14) 294.36,92.76 293.75,92.76 292.1,91.11 292.1,89.72 291.66,89.27 291.66,88.32 291.09,87.75 290.54,87.75 288.79,86 288.79,84.59 288.89,84.48 288.89,84.16 288.41,83.68 288.41,82.42 287.35,81.36 287.35,75.91 287.2,75.76 287.2,75.07 285.6,73.47 285.6,72.54 285.4,72.34 284.51,72.34 283.97,71.79 283.97,70.3 284.42,69.85 284.42,67.53 284.9,67.05 284.9,65.3 283.97,64.38 283.97,63.68 283.59,63.29 283.59,61.93 285.76,59.77 285.76,54.67 284.8,53.71 279.74,53.71 278.41,52.39 277.51,52.39 275.8,50.68 275.47,50.68 273.49,48.7 273.49,46.24 273.73,46 273.73,41.3 272.75,40.33 272.75,37.91 272.17,37.33 272.17,36.25 270.88,34.95 270.88,34.12 269.48,32.73 265.63,32.73 264.82,31.92 264.82,30.22 264.13,29.53 262.58,29.53 262.33,29.78 259.44,29.78 259.35,29.69 254.35,29.69 253.55,30.48 251.62,30.48 250.08,28.94 241.93,28.94 239.3,31.57 233.62,31.57 233,30.95 231.06,30.95 230.43,31.57 224.48,31.57 223.94,32.11 217.52,32.11 212.69,36.94 208.42,36.94 206.58,38.77 204.07,38.77 203.55,39.29 201.09,39.29 200.68,39.69 200.68,40.96 199.21,42.44 196.25,42.44 191.56,47.13 189.58,47.13 184.93,42.48 160.83,42.48 157.59,39.24 135.26,39.24 132.99,41.51 126.89,41.51 126.72,41.68 126.72,42 126.49,42.23 126.17,42.23 125.94,42 125.94,41.84 125.63,41.53 117.49,41.53 117.33,41.7 115.19,41.7 113.18,43.71 97.21,43.71 93.15,39.65 64.95,39.65 64.72,39.42 56.14,39.42 54.96,38.25 44.18,38.25 42.92,39.5 42.66,39.5 42.04,40.11 v1(42.04,41.01)
  IN4 w0.084: v1(41.95,46.98) 41.88,47.05 40.96,47.05 40.35,47.66 40.35,49.16 39.57,49.95 39.57,51.24 40.2,51.87 v1(40.29,51.87) ; v1(44.39,49.98) 45.12,49.98 45.32,49.78 49.41,49.78 52.71,53.08 52.9,53.08 55.31,55.49 v1(57.45,55.49)
  BOTTOM w0.127: RC558.2 115.22,104.4 115.79,103.83 RC84.1 115.42,103.14 v1(114.93,103.14)
PROCHOT#_CHG: length 120.4
  TOP w0.127: PU700.23 44.36,52.85 43.27,51.77 PR719.2 41.82,51.51 41.63,51.32 39.87,51.32 v2(39.73,51.18) 39.58,51.04 39.58,50.11 38.8,49.32 38.79,49.32 38.76,49.3 38.7,49.3 38.17,48.76 38.17,47.68 v1(38.42,47.43) ; PQ812.1 55.18,105.43 v1(54.64,105.98)
  IN2 w0.122: v1(20.45,50.22) 20.1,50.22 17.53,52.79 17.53,60.89 16.52,61.91 16.52,64.07 15.66,64.92 15.66,68.93 17.15,70.42 17.15,77.78 17.3,77.93 17.3,82.62 21.36,86.68 26.17,86.68 v1(26.52,87.04)
  IN4 w0.084: v1(38.42,47.43) 38.42,47.24 37.7,46.51 36.96,46.51 36.55,46.1 36.55,46.1 35.87,45.43 35.87,45.42 35.66,45.2 35.65,45.2 35.34,44.9 33.02,44.9 32.52,45.4 29.03,45.4 28.39,46.03 28.39,46.67 27.25,47.81 26.8,47.81 24.83,49.78 20.9,49.78 v1(20.45,50.22)
  BOTTOM w0.127: v1(26.52,87.04) 26.63,87.04 28.49,88.91 31.41,88.91 32.22,89.71 33.62,89.71 35.74,91.83 35.74,99.23 36.61,100.1 36.96,100.1 37.65,100.79 41.82,100.79 42.24,100.37 45.22,100.37 46.82,101.97 50.18,101.97 53.89,105.68 54.35,105.68 v1(54.64,105.98)
PROCHOT#_R: length 15.9
  BOTTOM w0.076: 120.48,93.19 120.59,93.07 120.59,90.66 120.91,90.34 120.91,90.04 120.65,89.77 UC1.Y4
  BOTTOM w0.114: 118.56,98.04 118.56,97.78 118.37,97.59 118.37,96.45 118.56,96.26 119.26,96.26 120.15,95.37 120.15,93.52 120.48,93.19
  BOTTOM w0.127: 118.56,98.04 118.56,98.25 117.82,98.98 117.82,100.12 v2(116.67,101.27) 115.79,102.15 RC84.2
PROCHOT#_R1: length 7.1
  TOP w0.127: UE1.H13 278.18,87.4 278.18,88.19 278.71,88.72 278.71,91.54 v2(278.86,91.68) 279.39,92.21 279.39,92.81 279.67,93.08 RE288.1
