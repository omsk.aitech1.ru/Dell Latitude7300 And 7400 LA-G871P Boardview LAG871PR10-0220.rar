# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PROG1_CPU_CORE: length 6.1
  TOP w0.203: PU602.32 63.17,60.41 61.92,61.67 61.92,62.99 v2(61.49,63.42) 60.79,64.12 PR608.1
PROG2_CPU_CORE: length 6.5
  TOP w0.203: PU602.31 63.21,60.81 62.29,61.73 62.29,63.46 v2(61.07,64.68) 60.74,65 PR611.1
PROG_CHG: length 3.4
  TOP w0.203: PU700.27 46.33,51.22 45.48,50.37 v2(45.1,50.37) 44.93,50.2 44.93,49.77 44.7,49.54 PR725.1
PROM_BIOS: length 3.4
  TOP w0.127: UZ6.1 178.46,57.26 178.4,57.32 RZ401.2 RZ400.2 179.9,57.69 v2(180.22,57.37)
PROM_BIOS_R: length 17.2
  TOP w0.127: v2(178.8,59.6) 178.25,59.6 v1(178.06,59.41) 178.06,58.94 RZ401.1
  IN1 w0.084: v1(175.31,71.22) 175.43,71.1 175.43,68.42 174.76,67.75 174.76,66.46 175.44,65.77 175.44,65.7 176.2,64.95 176.2,63.32 176.47,63.05 176.47,63.04 176.84,62.67 176.84,61.83 177.35,61.32 177.35,60.13 v1(178.06,59.41)
  BOTTOM w0.127: JSPI1.17 176.6,71.5 176.32,71.22 v1(175.31,71.22)
PS_ID: length 335.3
  TOP w0.127: v1(279.42,83.76) UE1.J8
  TOP w0.254: v1(51.89,86.81) 51.89,87.23 52.28,87.62 PR5.2 52.84,87.83 52.84,89.74 51.95,90.63 v2(51.12,90.63) 50.4,90.63 PR4.1
  IN1 w0.084: v1(284.43,83.19) 284.41,83.21 282.59,83.21 282.41,83.38 279.79,83.38 v1(279.42,83.76)
  IN3 w0.122: v1(284.43,83.19) 283.95,83.19 283.5,82.74 283.5,81.24 282.28,80.02 282.28,77.2 281.69,76.61 281.69,75.5 281.22,75.02 281.22,72.96 280.4,72.14 280.4,69.54 279.3,68.44 279.3,65.8 279.49,65.61 279.49,65.29 278.58,64.37 278.58,62.04 278.83,61.78 278.83,59.49 278.47,59.13 278.47,57.75 277.07,56.35 277.07,54.88 276.44,54.25 274.79,54.25 274.48,53.93 274.25,53.93 272.43,52.11 272.43,51.19 271.52,50.27 271,50.27 270.28,49.55 270.28,45.47 269.11,44.3 268.42,44.3 266.79,42.67 264.94,42.67 262.06,39.79 260.85,39.79 259.27,38.21 256.73,38.21 256.53,38 251.7,38 250.27,36.58 247.37,36.58 246.97,36.18 245.71,36.18 244.79,35.26 237.89,35.26 237.41,35.73 226.14,35.73 224.25,37.63 215.61,37.63 208,45.24 204.02,45.24 202.9,46.36 153.7,46.36 152.48,45.14 142.33,45.14 138.33,49.14 94.94,49.14 92.94,47.14 83.65,47.14 83.23,46.73 64.23,46.73 64.03,46.53 60.93,46.53 60.62,46.84 55.2,46.84 54.89,46.53 53.46,46.53 51.53,48.46 51.53,53.51 52.2,54.18 52.2,57.65 51.14,58.72 51.14,60.71 50.79,61.06 49.26,61.06 48.63,61.68 48.63,62.22 45.41,65.45 45.41,74.14 47.36,76.1 47.85,76.1 49.28,77.52 49.28,82.84 51.89,85.44 v1(51.89,86.81)
PSYS_CHG: length 3.8
  TOP w0.203: PR731.1 49.69,49.64 v2(49.01,50.32) 48.36,50.32 47.53,51.15 PU700.30
PSYS_CPU_CORE: length 6.4
  TOP w0.203: PR620.2 59.86,54.74 60.25,55.14 60.7,55.14 v2(61.16,55.6) 61.55,55.99 64.31,55.99 64.52,56.19 PU602.1
  TOP w0.254: PR620.2 59.86,53.96 PR693.2
PTP_DISABLE#: length 109.7
  TOP w0.127: v1(289.76,93.04) 289.86,93.14 RE605.1 ; v2(248.37,28.71) 248.18,28.9 v1(248.18,29.33) 248.18,29.56 RZ1475.1 ; UE1.N12 282.85,86.56 v1(283.26,86.14)
  IN3 w0.122: v1(288.61,89.08) 288.91,89.08 290.31,87.69 290.31,86.23 291.66,84.88 291.66,82.73 292.64,81.75 292.64,78 291.85,77.21 291.85,74.67 290.37,73.19 290.37,69.13 290.88,68.62 290.88,66.26 290.13,65.52 290.13,63.1 290.24,62.99 290.24,59.2 289,57.96 289,57.48 288.77,57.25 287.96,57.25 286.84,56.13 286.84,54.64 284.29,52.1 282.88,52.1 281.57,50.79 280.77,50.79 279.61,49.62 279.61,48.51 279.4,48.31 277.25,46.16 277.25,38.48 275.73,36.96 274.86,36.96 274.55,36.64 273.4,36.64 272.69,35.93 270.87,35.93 270.14,35.2 268.95,35.2 268.57,34.82 267.88,34.82 267.08,34.02 265.01,34.02 263.74,32.76 261.88,32.76 259.31,30.19 253.91,30.19 253.43,29.7 250.14,29.7 249.87,29.97 248.82,29.97 v1(248.18,29.33)
  IN4 w0.084: v1(289.76,93.04) 289.58,93.04 289.41,92.87 289.41,89.38 289.12,89.08 v1(288.61,89.08) 288.31,89.08 287.9,88.67 287.9,87.86 286.18,86.14 v1(283.26,86.14)
PTP_DISABLE#_R: length 5.8
  TOP w0.127: v1(249.48,31.26) 249.29,31.26 RZ1475.2 248.53,30.58 247.71,29.75 247.71,29.29 246.91,28.49 v3(246.67,28.49)
  BOTTOM w0.127: v1(249.48,31.26) 249.48,31.35 250.08,31.95 JKBTP1.11
PWM1_B_IA: length 40.4
  TOP w0.127: v1(80.08,85.72) v2(80.74,85.72)
  TOP w0.203: v1(70.17,57.4) 69.96,57.61 PU602.12
  IN2 w0.254: v1(80.08,85.72) 80.08,86.29 79.44,86.93 77.35,86.93 74.29,83.87 74.29,78.92 71.63,76.26 71.63,69.53 72.52,68.64 72.52,67.73 71.13,66.33 71.13,61.13 70.17,60.17 v1(70.17,57.4)
  BOTTOM w0.254: v1(80.08,85.72) 80.46,85.72 80.99,86.25 PR687.1
PWM1_IA: length 2.4
  BOTTOM w0.254: PR687.2 80.58,87.47 80.22,87.12 79.38,87.12 79.14,87.36 PU610.1
PWM2_B_IA: length 27.2
  TOP w0.203: PU602.13 70.38,58.01 v2(70.66,57.73) 70.86,57.52 v1(71.44,57.52)
  IN2 w0.203: v1(75.7,75.24) 74.75,76.19 73.11,76.19 72.22,75.3 72.22,71.1 73.6,69.72 73.6,68.32 73.91,68.01 73.91,59.99 v1(71.44,57.52)
  BOTTOM w0.254: PR692.1 v1(75.7,75.24)
PWM2_IA: length 3.8
  BOTTOM w0.127: v2(78.25,75.61) 77.88,75.24 PR692.2
  BOTTOM w0.254: PR692.2 77.23,76.36 76.78,76.82 76.78,77.11 77.04,77.37 PU613.1
PWM_A_GT: length 12.7
  TOP w0.127: v2(68.61,63.33) 68.35,63.07 v1(68.35,62.69)
  TOP w0.203: PU602.22 67.72,62.06 v1(68.35,62.69)
  BOTTOM w0.203: v1(68.35,62.69) 69.57,61.47 73,61.47 73.64,62.11 73.64,65.13 PR664.1
PWM_C_SA: length 61.6
  TOP w0.127: v1(63.7,62.67) v2(62.79,62.67)
  TOP w0.203: PU602.30 64.52,62.28 64.13,62.67 v1(63.7,62.67)
  TOP w0.254: v1(89.11,93.07) 89.52,93.48 89.52,95.7 89.69,95.88 PR606.2
  IN3 w0.254: v1(63.7,62.67) 63.95,62.92 63.95,63.87 65.28,65.21 66.55,65.21 68.4,67.05 68.4,70.67 68.97,71.25 68.97,92.32 72.07,95.42 82.87,95.42 85.22,93.07 v1(89.11,93.07)
PWM_FAN1: length 148.6
  TOP w0.127: UE1.L10 281,85.34 v1(281.09,85.34) ; RE48.2 194.88,82.29 v1(194.62,82.55) 194.62,82.56 v3(194.06,83.12)
  IN2 w0.122: v1(194.62,82.55) 195,82.55 195.87,81.68 197.17,81.68 197.52,81.33 197.52,80.03 202.45,75.11 202.45,72.15 203.03,71.57 203.03,70.44 204.78,65.84 204.78,65.84 204.87,65.57 204.87,62.69 215.2,52.37 215.82,52.37 221.89,46.29 236.01,46.29 236.18,46.46 241.38,46.46 242.67,47.75 247.37,47.75 251.05,51.43 254.01,51.43 262.33,59.75 262.33,63.46 261.89,63.9 261.89,66.6 261.49,66.99 v1(261.49,67.56)
  IN4 w0.084: v1(281.09,85.34) 281.09,85.3 280.68,84.89 280.68,84.32 280.49,84.13 276.49,84.13 276.42,84.19 275.22,84.19 275.09,84.07 275.09,83.57 274.9,83.38 273.43,83.38 271.43,85.38 268.27,85.38 267.28,84.4 267.28,84.33 265.62,82.67 265.62,75.66 267.06,74.23 267.72,74.23 267.98,73.97 267.98,73.1 267.48,72.6 267.48,70.74 265.58,68.84 264.21,68.84 262.93,67.56 v1(261.49,67.56)
  BOTTOM w0.127: v1(194.62,82.55) 192.72,80.65 JFAN1.2
PWM_GT: length 1.7
  BOTTOM w0.254: PR664.2 72.64,67.16 73.59,68.11 PU612.1
PWM_SA: length 3
  TOP w0.127: PR606.1 v2(89.54,96.79)
  TOP w0.254: PU614.3 91.97,96.74 91.74,96.97 90.75,96.97 PR606.1
REFCLK_CNV: length 8.4
  TOP w0.104: v1(154.5,93.38) v2(153.85,94.03) 153.41,94.47 CC1477.1 RC751.2 153.41,97.05 LC5.1
  BOTTOM w0.089: UC1.CM3 152.01,90.55 152.5,91.04 152.5,91.31 154.5,93.31
  BOTTOM w0.114: 154.5,93.31 v1(154.5,93.38)
REFCLK_CNV_L: length 165.4
  TOP w0.127: LC5.2 154.88,97.67 156.27,97.67 156.66,97.28 160.79,97.28 v2(161.21,97.7) v1(162.06,98.55) ; v1(268.92,34.53) 268.36,35.08 RZ752.1 267.78,36.38 v1(267.78,36.56)
  IN2 w0.122: v1(262.44,44.43) 262.36,44.43 261.94,44.02 260.53,44.02 259.94,44.61 254.43,44.61 253.61,43.78 246.89,43.78 246.54,44.13 245.63,44.13 244.37,42.87 243.48,42.87 241.59,40.98 230.48,40.98 228.78,42.68 219.78,42.68 201.06,61.39 201.06,65.43 199.37,69.9 199.37,70.11 198.83,70.66 198.83,73.08 195.86,76.05 194.38,76.05 188.38,82.06 188.38,84.14 187.64,84.88 186.36,84.88 185,83.52 182.1,83.52 180.99,84.63 180.99,86.47 180.41,87.05 179.27,87.05 177.62,88.7 177.62,88.86 176.38,90.1 175.08,90.1 174.55,89.57 173.01,89.57 171.28,91.29 167.82,91.29 163.89,95.22 163.61,95.22 162.52,96.31 162.52,97.83 162.06,98.29 v1(162.06,98.55)
  IN4 w0.084: v1(268.92,34.53) 268.72,34.73 268.25,34.73 266.27,36.71 265.65,36.71 264.5,37.86 264.5,43.01 263.07,44.43 v1(262.44,44.43)
  BOTTOM w0.127: JNGFF1.64 265.71,38.63 v1(267.78,36.56)
REM_DIODE1_N: length 236
  TOP w0.127: v1(121.29,76.64) 120.7,77.23 QE3.3 120.68,77.23 120.64,77.27 120.64,77.89 CE35.1 ; v1(269.56,82.35) 269.69,82.23 270.05,82.23 270.37,82.54 CE24.1 270.65,82.29 270.83,82.29 271.09,82.54 271.47,82.54 272.04,83.12 272.38,83.12 UE1.A8
  IN2 w0.089: v1(121.29,76.64) 121.99,76.64 122.13,76.5 122.13,75.93 122.55,75.51 126.3,75.51 126.99,74.82 126.99,73.71 126.08,72.8 126.08,70.6 127.13,69.54 136.67,69.54 138.09,70.96 138.09,74.76 139.08,75.75 140.45,75.75 141.43,74.77 141.96,74.77 142.01,74.82 142.48,74.82 142.6,74.7 143.54,74.7 143.7,74.85 144.41,74.85 144.48,74.77 145.27,74.77 145.35,74.85 146.51,74.85 147.24,75.58 147.81,75.58 148.54,74.86 151.9,74.86 154.27,72.49 155.93,72.49 155.97,72.45
  IN2 w0.127: 155.97,72.45 162.38,72.45 162.69,72.76 165.42,72.76 166.41,73.76 171.81,73.76 172.2,74.14 174.38,74.14 177.43,71.1 177.43,70.16 178.31,69.27 179.1,69.27 180.73,67.65 181.68,67.65 185.92,63.41 195.39,63.41 197.87,60.92 197.87,59.94 202.13,55.68 202.13,46.67 204.22,44.57 212.1,44.57 219.14,37.52 244.42,37.52 245.43,38.54 246.39,38.54 246.89,39.05 253.43,39.05 253.88,39.49 256.29,39.49 257.56,40.76 260.99,40.76 261.63,40.13 262.9,40.13 265.37,42.6 265.37,46.01 264.22,47.17 264.22,48.37 265.17,49.32 265.17,50.64 266.29,51.77 266.29,52.6 267.15,53.46 267.15,55.97 267.46,56.28 267.46,58.82 269.12,60.48 269.12,61 269.58,61.46 269.58,66.15 267.98,67.75 267.98,69.65 266.33,71.3 266.33,80 266.9,80.58 269.25,80.58 270.01,81.34 270.01,82.01 269.66,82.35 v1(269.56,82.35)
REM_DIODE1_P: length 236.2
  TOP w0.127: 270.4,81.65 270.08,81.97 269.81,81.97 v1(269.56,81.73) ; 270.4,81.65 270.77,82.03 270.96,82.03 271.21,82.29 271.57,82.29 272.15,82.86 272.48,82.86 272.62,82.73 UE1.A7 ; 270.4,81.65 CE24.2 ; QE3.1 121.33,75.47 v1(122.56,76.7) 122.03,77.23 QE3.2 121.65,77.23 121.05,77.83 CE35.2
  IN2 w0.089: 156.05,72.7 156.03,72.68 154.33,72.68 151.98,75.03 148.61,75.03 147.89,75.76 147.16,75.76 146.43,75.03 145.27,75.03 145.2,74.95 144.56,74.95 144.48,75.03 143.62,75.03 143.47,74.88 142.67,74.88 142.56,74.99 141.94,74.99 141.89,74.95 141.5,74.95 140.53,75.93 139.01,75.93 137.92,74.84 137.92,71.04 136.6,69.72 127.21,69.72 126.26,70.67 126.26,72.73 127.17,73.64 127.17,74.89 126.37,75.69 122.62,75.69 122.31,76 122.31,76.45 v1(122.56,76.7)
  IN2 w0.127: 156.05,72.7 162.27,72.7 162.59,73.02 165.32,73.02 166.31,74.01 171.71,74.01 172.09,74.4 174.49,74.4 177.68,71.21 177.68,70.27 178.42,69.53 179.21,69.53 180.83,67.9 181.78,67.9 186.02,63.66 195.5,63.66 198.13,61.03 198.13,60.04 202.38,55.79 202.38,46.77 204.33,44.82 212.2,44.82 219.25,37.78 244.31,37.78 245.33,38.79 246.28,38.79 246.79,39.3 253.33,39.3 253.77,39.74 256.19,39.74 257.46,41.01 261.12,41.01 261.75,40.38 262.79,40.38 265.12,42.71 265.12,45.91 263.96,47.06 263.96,48.47 264.91,49.42 264.91,50.75 266.04,51.87 266.04,52.7 266.9,53.56 266.9,56.08 267.2,56.38 267.2,58.93 268.87,60.59 268.87,61.11 269.32,61.57 269.32,66.04 267.72,67.64 267.72,69.55 266.07,71.2 266.07,80.11 266.79,80.83 269.14,80.83 269.66,81.35 269.66,81.63 v1(269.56,81.73)
REM_DIODE2_N: length 351
  TOP w0.127: UE1.A10 272.36,84.7 272,84.7 270.73,83.43 269.07,83.43 CE26.1 268.53,83.31 268.31,83.31 v1(268.17,83.45)
  IN2 w0.127: v1(40.07,44.14) 40.24,44.32 40.96,44.32 43.88,41.4 43.88,40.38 44.33,39.94 54.17,39.94 55.44,41.21 67.63,41.21 68.27,41.84 82.05,41.84 85.6,45.4 119.13,45.4 120.34,44.19 122.5,44.19 123.13,43.55 124.78,43.55 125.48,44.25 132.15,44.25 134.75,41.65 137.04,41.65 137.23,41.46 157.87,41.46 160.15,43.75 184.22,43.75 188.73,48.25 192.86,48.25 196.22,44.88 v1(196.22,44.51) ; v1(207.97,43.14) 208.13,43.3 212.17,43.3 219.34,36.13 245.83,36.13 247.23,37.52 252.33,37.52 252.91,38.09 259.62,38.09 260.76,39.24 262.9,39.24 265.86,42.2 266.09,42.2 267.66,43.76 267.66,44.74 267.42,44.98 267.42,47.65 267.57,47.8 267.57,51.27 268.51,52.21 268.51,53.49 268.89,53.87 268.89,55.94 270.14,57.19 270.14,61.73 271.2,62.8 271.2,67.78 268.93,70.06 268.93,72.04 269.69,72.81 269.69,79.22 270.71,80.24 270.71,82.76 268.76,84.7 267.85,84.7 267.4,84.26 267.4,83.56 267.66,83.31 268.03,83.31 v1(268.17,83.45)
  IN4 w0.127: v1(40.07,44.14) 39.89,44.32 37.15,44.32 36.52,43.68 36.52,41.65 35.57,40.7 30.11,40.7 27.82,42.98 25.66,42.98 22.87,40.19 22.87,36.92 14.96,29.01 12.58,29.01 12.26,28.7 12.26,27.79 12.49,27.55 12.66,27.55 v1(12.83,27.72)
  BOTTOM w0.127: QE5.3 14.8,27.55 14.43,27.55 CE37.2 13.84,27.62 12.93,27.62 v1(12.83,27.72) ; QE7.1 207.51,38.3 QE7.2 208.01,40.06 208.01,40.45 CE46.2 207.7,40.88 207.97,41.15 v1(207.97,43.14) 208.01,43.14 208.21,43.34 208.21,43.52 207.91,43.82 204.74,43.82 203.84,42.92 198.63,42.92 197.49,44.06 196.67,44.06 v1(196.22,44.51)
REM_DIODE2_P: length 353.7
  TOP w0.127: v1(268.17,82.86) 268.36,83.05 268.53,83.05 CE26.2 268.98,82.72 269.44,83.18 270.83,83.18 272.1,84.45 272.33,84.45 UE1.A9
  IN2 w0.127: v1(268.17,82.86) 267.98,83.05 267.55,83.05 267.15,83.45 267.15,84.36 267.74,84.96 268.87,84.96 270.96,82.86 270.96,80.13 269.94,79.11 269.94,72.7 269.18,71.94 269.18,70.16 271.45,67.89 271.45,62.69 270.39,61.63 270.39,57.08 269.14,55.84 269.14,53.77 268.76,53.38 268.76,52.1 267.82,51.16 267.82,47.69 267.67,47.54 267.67,45.08 267.91,44.84 267.91,43.66 266.2,41.95 265.96,41.95 263,38.98 260.86,38.98 259.72,37.84 253.01,37.84 252.44,37.27 247.33,37.27 245.94,35.87 219.24,35.87 212.06,43.05 208.75,43.05 v1(208.41,42.71) ; v1(40.01,44.7) 40.14,44.57 41.07,44.57 44.14,41.5 44.14,40.49 44.43,40.19 54.07,40.19 55.34,41.46 67.53,41.46 68.16,42.09 81.94,42.09 85.5,45.65 119.24,45.65 120.44,44.44 122.6,44.44 123.24,43.81 124.68,43.81 125.38,44.51 132.26,44.51 134.86,41.9 137.14,41.9 137.34,41.71 157.76,41.71 160.05,44 184.11,44 188.62,48.51 192.96,48.51 196.48,44.99 196.48,44.96 196.49,44.95 196.5,44.95 v1(196.92,44.53)
  IN4 w0.127: v1(40.01,44.7) 39.88,44.57 37.05,44.57 36.26,43.79 36.26,41.78 35.44,40.95 30.21,40.95 27.92,43.24 25.55,43.24 22.61,40.29 22.61,37.02 14.85,29.27 12.47,29.27 12.01,28.8 12.01,27.68 12.39,27.3 12.66,27.3 v1(12.83,27.13)
  BOTTOM w0.127: v1(12.83,27.13) 13.05,27.36 13.71,27.36 CE37.1 14.1,26.98 14.42,27.3 14.68,27.3 QE5.2 16.51,26.72 QE5.1 ; QE7.3 208.27,40.09 208.27,40.41 CE46.1 208.62,40.88 208.23,41.26 208.23,42.52 v1(208.41,42.71) 208.41,42.74 208.46,42.79 208.46,43.31 208.46,43.63 208.01,44.08 204.64,44.08 203.74,43.17 198.74,43.17 197.6,44.32 197.13,44.32 v1(196.92,44.53)
REM_DIODE4_N: length 385.3
  TOP w0.127: v1(193.87,56.88) 193.87,56.88 196.74,56.88 196.81,56.95 208.5,56.95 218.03,47.43 237.68,47.43 241.7,49.09 243.5,49.09 244.44,50.03 245.69,50.03 v1(245.75,49.97) ; v1(270.33,84.07) 270.08,84.32 CE27.1 269.56,84.37 269.56,85.48 270.12,86.04 271.91,86.04 272.19,85.76 UE1.A11
  IN1 w0.127: v1(45.87,42.05) 45.65,42.05 45.35,42.35 45.35,42.79 47.5,44.95 47.5,48.03 50.68,51.21 50.68,52.36 50.4,52.64 50.29,52.64 v1(50.23,52.69)
  IN2 w0.127: v1(45.87,42.05) 46.12,41.8 52.67,41.8 54.16,43.3 59.15,43.3 59.84,44 68.08,44 68.21,43.87 80.99,43.87 84.36,47.24 135.07,47.24 138.31,44 154.25,44 154.5,43.75 156.75,43.75 159.29,46.29 183.78,46.29 186.89,49.39 186.89,51.66 188.18,52.95 189.61,52.95 193.28,56.63 193.62,56.63 v1(193.87,56.88) ; v1(50.23,52.69) 50.06,52.51 48.82,52.51 48.25,51.94 45.6,51.94 44.77,52.76 44.77,54.35 43.63,55.49 43.63,56.26 44.08,56.7 44.08,59.49 43.57,60 43.57,63.9 45.97,66.3 45.97,74.65 47.16,75.85 47.16,77.63 50.14,80.6 50.14,83.91 53.6,87.37 53.6,90.61 51.7,92.51 51.7,95.68 53.02,97.01 53.02,97.9 54.39,99.28 54.88,99.28 56.63,101.02 59.65,101.02 60.8,99.88 62.51,99.88 63.15,99.24 76.58,99.24 77.09,98.74 81.34,98.74 81.98,99.37 87.54,99.37 87.75,99.16 87.75,98.65 88.12,98.28 88.98,98.28 89.28,98.58 89.28,98.73 v1(89.61,99.06)
  IN4 w0.127: v1(270.33,84.07) 270.52,83.88 270.52,77.51 269.37,76.36 269.37,72.36 268.99,71.98 268.99,69.02 267.95,67.97 264.63,67.97 261.53,64.87 261.53,59.72 258.7,56.89 257.23,56.89 252.28,51.94 250.54,51.94 247.87,49.27 246.11,49.27 245.75,49.63 v1(245.75,49.97)
  BOTTOM w0.127: CE39.1 89.73,99.75 89.48,99.5 89.48,99.18 v1(89.61,99.06) 89.94,98.73 QE6.3 ; v1(50.23,52.69) v2(49.57,52.69)
REM_DIODE4_P: length 387.4
  TOP w0.127: v1(245.32,49.62) 245.16,49.78 244.54,49.78 243.6,48.84 241.75,48.84 237.73,47.17 217.92,47.17 208.4,56.7 196.92,56.7 196.84,56.62 194.5,56.62 v1(194.25,56.37) ; v1(270.77,84.51) 270.64,84.51 270.27,84.89 CE27.2 270.06,84.96 269.82,85.2 269.82,85.37 270.23,85.78 271.81,85.78 272.23,85.36 273.02,85.36 UE1.B10
  IN1 w0.127: v1(50.23,52.13) 50.43,51.94 50.43,51.31 47.25,48.14 47.25,45.06 45.09,42.9 45.09,42.25 45.5,41.84 45.5,41.67 v1(45.62,41.55)
  IN2 w0.127: v1(45.62,41.55) 52.77,41.55 54.27,43.05 59.25,43.05 59.95,43.75 67.97,43.75 68.1,43.62 81.1,43.62 84.46,46.98 134.96,46.98 138.2,43.75 154.14,43.75 154.4,43.49 156.85,43.49 159.39,46.03 183.89,46.03 187.14,49.28 187.14,51.56 188.28,52.7 189.71,52.7 193.38,56.37 v1(194.25,56.37) ; v1(50.23,52.13) 50.11,52.25 48.93,52.25 48.36,51.68 45.49,51.68 44.52,52.66 44.52,54.24 43.38,55.39 43.38,56.36 43.82,56.81 43.82,59.39 43.31,59.9 43.31,64 45.71,66.4 45.71,74.76 46.91,75.95 46.91,77.73 49.88,80.71 49.88,84.01 53.35,87.48 53.35,90.5 51.44,92.41 51.44,95.79 52.76,97.11 52.76,98 54.29,99.53 54.77,99.53 56.52,101.28 59.76,101.28 60.9,100.13 62.62,100.13 63.25,99.5 76.68,99.5 77.19,98.99 81.24,98.99 81.87,99.63 87.65,99.63 88,99.27 88,98.75 88.23,98.53 88.87,98.53 89.03,98.69 v1(89.03,99.06)
  IN4 w0.127: v1(245.32,49.62) 245.4,49.62 246.01,49.02 247.97,49.02 250.64,51.68 252.38,51.68 257.34,56.64 258.81,56.64 261.79,59.61 261.79,64.77 264.74,67.72 268.05,67.72 269.25,68.91 269.25,71.88 269.63,72.26 269.63,76.26 270.77,77.4 v1(270.77,84.51)
  BOTTOM w0.127: CE39.2 89.22,99.55 89.22,99.25 v1(89.03,99.06) 88.64,98.66 QE6.2 88.64,97.09 QE6.1
RESERVE: length 14.7
  TOP w0.127: v1(310.73,97.56) v2(310.73,96.78)
  IN1 w0.084: v1(309.23,102.01) 310.03,101.21 310.03,100.06 309.51,99.54 309.51,98.79 v1(310.73,97.56)
  BOTTOM w0.127: v1(310.73,97.56) 311.19,97.1 DZ14.2 DZ14.8 311.19,94.79 311.66,94.32 T418.1 ; JFPBTN1.10 312.34,102.8 311.55,102.01 v1(309.23,102.01)
RESET_IN#: length 6.4
  TOP w0.102: RE362.2 273.16,72.57 273.16,75.88 273.88,76.59 273.88,77.18 274.22,77.52 UE1.C1
RESET_OUT: length 7.5
  TOP w0.127: v1(277,79.77) 277.39,80.16 UE1.G4 ; v1(279.25,74.38) 279.28,74.42 RE548.2
  IN4 w0.084: v1(279.25,74.38) 279.25,74.45 277.59,76.11 277.59,79.18 v1(277,79.77)
RESET_OUT#_R: length 6.5
  TOP w0.127: v1(60.08,95.78) 60.08,95.78 60.08,96.41 CC334.1 59.67,96.41 59.06,97.02 57.66,97.02 v2(57.21,97.48) 57.03,97.66 57.03,98.19 57.04,98.2 RC129.2 RC128.2
  BOTTOM w0.127: JXDP1.47 v1(60.08,95.78)
RING2: length 10.8
  IN1 w1.27: 288.68,39.43 296.87,39.43 298.74,41.3
  vias: v1(285.88,39.94) v1(286.45,39.94) v1(299.73,41.78) v1(299.73,41.21) v3(299.36,43.33)
RING2_R: length 8.1
  TOP w0.127: 302.96,46.29 303.18,46.5 v3(303.55,46.5)
  IN4 w1.27: JHP1.4 312.31,43.67 311.41,44.57 305.95,44.57
  vias: v1(302.33,45.71) v1(302.9,45.71) v1(304.3,44.32) v1(304.93,44.32)
RTC_DET#: length 147.1
  TOP w0.127: RC866.1 148.56,78.95 v1(149,78.51) ; PQ13.1 233.26,40.13 233.26,46.1 233.7,46.54 237.86,46.54 241.88,48.2 v2(246.08,48.2) 246.58,48.7 246.58,50.04 246.28,50.34 246.28,50.69 247.22,51.63 247.79,51.63 v1(248.21,51.46)
  IN2 w0.089: 161.76,80.83 159.89,80.83 158.83,79.78 156.29,79.78 155.91,79.39 152.05,79.39 151.81,79.15 149.31,79.15 149,78.85 v1(149,78.51)
  IN2 w0.122: v1(196.91,64.36) 196.12,65.14 187.9,65.14 182.79,70.25 180.38,70.25 179.14,71.49 179.14,72.03 174.25,76.92 169.02,76.92 167.73,78.21 167.73,79.08 167.61,79.2 167.32,79.2 165.43,81.1 162.38,81.1 162.11,80.83 161.76,80.83
  IN3 w0.122: v1(196.91,64.36) 196.91,63.75 199.42,61.23 206.66,61.23 220.12,47.77 239.41,47.77 240.06,48.42 245.14,50.58 247.04,51.57 247.85,51.57 v1(248.21,51.46)
  BOTTOM w0.076: v1(149,78.51) 148.75,78.25 UC1.CF22
RTCRST_ON: length 16
  TOP w0.127: v1(267.47,86.61) 265.83,88.25 QE12.2 263.97,88.45 RE93.1 264.78,89.26 v2(264.97,89.07) ; v1(276.22,86.18) 276.62,85.78 UE1.F11
  IN1 w0.084: v1(276.22,86.18) 276.01,86.18 275.6,85.77 271.76,85.77 271.31,86.21 270.42,86.21 270.28,86.35 268.3,86.35 268.05,86.61 v1(267.47,86.61)
RTCRST_ON_POWER: length 27.9
  TOP w0.127: v2(272.36,64.87) 272.96,65.47 v1(273.02,65.47) 273.4,65.09 RE565.2 ; v1(272.18,88.04) 272.74,88.04 UE1.B13
  IN2 w0.122: v1(272.18,88.04) 271.79,87.65 271.79,85.53 272.74,84.58 272.74,83.15 273.42,82.46 273.42,81.24 273.43,81.24 273.43,79.59 273.43,78.8 273.44,78.79 273.44,78.22 272.23,77.02 272.23,72 272.64,71.59 272.64,69 273.02,68.62 v1(273.02,65.47)
RTCRST_ON_POWER_R: length 12.2
  TOP w0.127: v2(279.44,63.91) 279.14,64.22 DE2.1 277.45,63.43 276.04,63.43 275.91,63.56 RE543.2 275.05,63.89 CE64.1 RE541.2 273.41,63.82 RE565.1 272.78,63.81 270.55,66.03 269.97,66.03 QE15.2
RTCRST_ON_POWER_R1: length 4.6
  TOP w0.127: v2(278.47,67.01) 278.24,66.78 DE2.2 278.23,65.91 QE17.2 276.83,65.9 CE65.1 RE543.1
RTD3_CIO_PWR_EN: length 257.5
  TOP w0.127: RT25.1 RT372.1 24.24,86.19 23.82,85.77 23.82,83.4 v1(23.75,83.33) ; v1(54.71,48.87) 54.71,47.72 v2(54.93,47.49)
  IN1 w0.084: v1(30.06,34.73) 29.85,34.93 29.85,42.33 30.68,43.15 30.68,48.19 31.38,48.9 31.38,52.7 30.37,53.71 30.22,53.71 29.25,54.68 29.25,55.72 28.75,56.22 28.75,60.15 27.07,61.83 27.07,62.36 25.25,64.19 25.25,69.63 25.93,70.3 25.93,72.43 26.36,72.86 30.67,72.86 31.29,73.49 31.29,81.43 30.2,82.53 28.11,82.53 27.86,82.28 24.8,82.28 v1(23.75,83.33)
  IN2 w0.089: 156.11,75.13 v1(155.77,74.79)
  IN2 w0.122: 156.11,75.13 156.16,75.18 156.34,75.18 159.55,78.38 163.14,78.38 164.55,79.79 v1(164.55,80.23)
  IN3 w0.122: v1(54.71,48.87) 55.99,48.87 57.42,50.3 60.84,50.3 60.88,50.35 62.32,50.35 63.03,51.06 64.58,51.06 65.17,51.64 71.91,51.64 71.94,51.67 72.91,51.67 73.24,52 87.2,52 90.53,55.33 133,55.33 136.05,58.37 136.05,67.48 136.41,67.84 136.92,67.84 138.58,66.18 142.44,66.18 142.6,66.02 142.6,64.5 142.67,64.43 142.67,64.11 142.56,64 142.56,62.52 143.6,61.48 144.59,61.48 145.21,60.86 147.92,60.86 148.87,61.81 148.87,63.72 149.17,64.02 149.17,66.48 149.42,66.73 149.42,68.36 150.08,69.02 152.01,69.02 156.01,73.02 156.11,73.02 156.23,73.14 156.23,73.66 155.81,74.08 155.81,74.34 155.77,74.38 v1(155.77,74.79)
  IN4 w0.084: v1(54.71,48.87) 53.18,48.87 50.4,46.1 49.51,46.1 49.02,45.61 49.02,45.04 46.92,42.94 43.44,42.94 41.6,41.1 41.6,40.2 35.63,34.22 30.99,34.22 30.49,34.73 v1(30.06,34.73)
  BOTTOM w0.076: UT1.F1 23.95,82.59 23.95,83.13 v1(23.75,83.33) ; v1(155.77,74.79) 154.76,74.79 154.52,75.03 153.79,75.03 arc(153.74,75.04) 153.71,75.07 arc(153.66,75.1) 153.6,75.11 153.17,75.11 152.91,75.37 UC1.CN26
  BOTTOM w0.127: RC753.1 171.38,83.5 169.11,81.22 169.11,80.19 167.84,78.92 167.26,78.92 165.56,80.62 164.75,80.62 164.55,80.43 164.55,80.23 v1(164.55,80.23)
RTD3_SELECT: length 343.8
  TOP w0.127: UE1.F13 276.44,87.54 276.44,88.36 275.45,89.34 v1(275.45,89.78) ; v1(45.79,62.48) v2(46.19,62.08)
  IN1 w0.084: v1(275.45,89.78) 276.19,90.52 278.44,90.52 278.89,90.97 281.91,90.97 282.54,90.34 283.39,90.34 284.15,91.1 288.18,91.1 289.84,89.44 290.61,89.44 v1(290.98,89.07)
  IN3 w0.122: v1(290.98,89.07) 290.57,89.48 288.28,89.48 288.16,89.35 288.16,88.96 287.88,88.68 287.88,88.59 285.11,85.83 285.11,83.64 285.38,83.38 285.38,83.06 285.12,82.8 284.05,82.8 283.72,82.48 283.72,81.15 282.5,79.93 282.5,77.11 282.1,76.71 282.1,75.85 282.14,75.82 282.14,75.28 282.02,75.17 282.02,74.66 282.14,74.54 282.14,73.56 280.63,72.05 280.63,69.44 279.53,68.34 279.53,65.89 279.72,65.7 279.72,65.19 278.8,64.28 278.8,62.13 279.6,61.33 279.75,61.33 280.23,60.86 280.23,59.98 279.47,59.22 279.47,57.88 279.13,57.54 278.58,57.54 277.3,56.26 277.3,54.79 276.53,54.02 274.89,54.02 274.57,53.7 274.34,53.7 272.68,52.04 272.68,51.11 271.61,50.05 271.09,50.05 270.5,49.46 270.5,45.38 269.2,44.08 268.51,44.08 266.88,42.45 265.04,42.45 262.15,39.56 260.94,39.56 259.36,37.99 256.82,37.99 256.62,37.78 251.79,37.78 250.37,36.36 247.46,36.36 247.06,35.96 245.8,35.96 244.88,35.03 237.8,35.03 237.32,35.51 225.43,35.51 225.21,35.73 222.05,35.73 220.37,37.4 215.52,37.4 207.9,45.02 203.93,45.02 202.8,46.14 153.8,46.14 152.57,44.92 142.24,44.92 138.27,48.89 95,48.89 92.97,46.86 83.68,46.86 83.33,46.51 64.33,46.51 64.12,46.3 59.82,46.3 59.49,45.97 58.97,45.97 58.63,46.3 53.37,46.3 50.36,49.31 50.36,51.4 48.64,53.13 44.85,53.13 43.76,54.22 43.76,56.35 46.07,58.67 46.4,58.67 47.07,59.34 47.07,61.64 46.23,62.48 v1(45.79,62.48)
  BOTTOM w0.127: v1(45.79,62.48) 44.49,62.48 42.39,64.59 42.39,67.48 41.71,68.15 RT447.2 41.03,68.07 40.69,67.73 UT32.6
RTD3_USB_PWR_EN: length 1.8
  TOP w0.076: v1(23.2,81.04) v2(23.2,81.75)
  TOP w0.127: RT26.1 23.15,80.99 v1(23.2,81.04)
  BOTTOM w0.127: UT1.D4 v1(23.2,81.04)
RUN_ON: length 581.5
  TOP w0.102: v1(183.44,94.99) 183.36,94.91 183.04,94.91 182.86,94.74 UZ3.5
  TOP w0.127: v1(31.54,36.25) 31.92,36.63 32.58,36.63 32.9,36.32 32.9,34.47 32.63,34.21 UZ54.1 ; RZ345.1 295.78,17.71 295.9,17.58 v1(295.92,17.58) ; v1(151.02,110.95) 150.58,110.95 150.11,110.47 RZ320.1 150.12,109.25 152.32,109.25 152.56,109.49 UZ35.2 ; RZ1423.1 139.64,111.32 140.34,112.02 v1(140.39,112.02) ; v1(190.68,50.64) v3(191.84,50.64) ; v1(277.61,60.42) 277.98,60.42 278.2,60.64 278.2,62.73 279.01,63.54 279.84,63.54 280.1,63.81 QE2.2 ; v1(266.97,45.03) 266.93,45 UZ47.3
  TOP w0.254: v1(75.38,29.71) 75.38,31.43 76.21,32.25 79.64,32.25 80,31.88 PR402.1
  IN1 w0.084: v1(277.76,34.54) 277.85,34.63 279.18,34.63 281.76,32.06 289.24,32.06 292.67,28.63 295.41,28.63 296.49,27.55 296.49,19.42 295.92,18.85 v1(295.92,17.58) ; v1(190.68,50.64) 190.68,50.53 192.27,48.94 194.15,48.94 196.61,46.49 198.04,46.49 203.17,41.35 203.17,41.31 203.85,40.63 v1(203.85,40.16) ; v1(277.61,60.42) 277.12,59.93 277.12,57.84 278.29,56.67 278.29,55.63 277.77,55.11 277.77,51.41 275.66,49.3 v1(275.66,48.63)
  IN2 w0.122: v1(174.58,80.8) 174.58,80.82 175.53,81.77 178.31,81.77 178.83,81.25 181.08,81.25 181.89,82.06 183.79,82.06 184.57,82.85 185.7,82.85 186.12,82.42 187.08,82.42 187.6,82.94 187.6,83.71 187.76,83.86 v1(187.76,83.89) ; v1(75.38,29.71) 75.38,30.54 75.16,30.76 58.59,30.76 53.21,36.14 33.71,36.14 33.22,36.63 31.92,36.63 v1(31.54,36.25)
  IN3 w0.122: v1(151.02,110.95) 151.23,111.16 153.02,111.16 153.78,111.91 157.79,111.91 157.95,112.07 160.96,112.07 162.03,111 162.03,109.5 163.27,108.26 166.81,108.26 170.06,111.51 171.25,111.51 178.57,104.19 178.57,102.69 180.46,100.8 180.46,98.38 181.48,97.37 181.48,96.13 181.6,96.01 183.2,96.01 183.44,95.77 v1(183.44,94.99) 183.2,94.75 183.2,94.29 183.44,94.05 183.44,89.5 187.6,85.34 187.6,84.49 187.76,84.34 v1(187.76,83.89) ; v1(277.61,60.42) 277.61,60.32 276.65,59.36 276.65,57.75 275.91,57.01 275.04,57.01 274.56,56.54 273.66,56.54 273.52,56.4 273.52,54.99 272.73,54.19 272.73,53.9 271.38,52.55 271.38,51.93 270.78,51.33 270.56,51.33 268.93,49.7 268.93,48.32 267.64,47.02 267.64,45.7 v1(266.97,45.03) ; v1(177.62,76.07) 177.62,75.55 179.65,73.53 179.84,73.53 182.48,70.88 182.48,63.78 181.27,62.57 181.27,61.36 182.57,60.06 182.57,58.48 189.24,51.81 189.51,51.81 190.68,50.64 v1(190.68,50.64) 192.51,50.64 192.89,51.02 206.82,51.02 217.14,40.7 225.63,40.7 227.45,38.87 237.22,38.87 237.37,39.02 242.94,39.02 243.32,39.41 246.17,39.41 246.62,39.86 249.84,39.86 253.48,43.49 253.86,43.49 254.62,44.26 258.13,44.26 260.91,47.03 263.08,47.03 265.65,49.6 266.29,49.6 v1(266.6,49.29) ; v1(203.85,40.16) 203.24,40.16 202.12,41.28 139.61,41.28 135.8,45.09 121.83,45.09 121.31,44.57 96.02,44.57 94.72,43.27 68.93,43.27 68.33,42.66 45.93,42.66 45.23,41.96 45.23,40.38 44.53,39.68 34.97,39.68 v1(31.54,36.25)
  BOTTOM w0.127: v1(266.97,45.03) 267.11,44.89 268.61,44.89 269.33,45.61 269.33,48 267.85,49.49 266.79,49.49 v1(266.6,49.29) ; v1(275.66,48.63) 275.41,48.63 275.02,48.25 275.02,46.73 274.2,45.9 274.2,43.05 274.77,42.48 274.77,40.25 273.4,38.88 273.4,38.07 273.95,37.52 274.83,37.52 276.04,36.32 277.31,36.32 278.2,35.43 278.2,34.98 v1(277.76,34.54) ; UE5.4 175.52,79.7 RE292.1 ; RE292.1 174.76,80.62 v1(174.58,80.8) ; RE292.1 174.44,79.7 174.25,79.51 174.25,77.91 175.01,77.15 175.01,76.7 176.16,75.56 177.04,75.56 177.55,76.07 v1(177.62,76.07) 177.34,76.35 RE280.1 ; v1(140.39,112.02) 140.39,111.58 140.58,111.39 150.58,111.39 v1(151.02,110.95)
RUN_ON#: length 3.5
  TOP w0.127: QE2.6 279.6,66.81 279.74,66.95 280.09,66.95 280.1,66.94 ; 280.1,66.94 280.2,67.03 v2(280.2,67.63) RE68.1 ; 280.1,66.94 QE2.5
RUN_ON_1.8V: length 4.3
  TOP w0.127: UZ8.3 294.38,19.65 294.51,19.52 CZ197.1 294.84,18.77 RZ345.2 v2(297.22,18.77)
RUN_ON_EC: length 181.5
  TOP w0.127: v2(175.53,79.58) 175.27,79.32 v1(175.27,79.11) ; UE1.E8 275.82,83.45 v1(275.52,83.76) ; RE812.2 265.14,90.02 265.78,89.39 267.74,89.39 v1(267.85,89.27)
  IN3 w0.122: v1(175.27,79.11) 175.65,79.11 176.73,78.04 179.27,78.04 179.87,77.43 180.9,77.43 181.31,77.84 181.87,77.84 181.99,77.73 181.99,77.24 184.19,75.03 184.19,71.9 184.86,71.23 184.86,57.84 186.87,55.84 188.13,55.84 192.73,51.24 206.92,51.24 217.24,40.92 225.76,40.92 227.58,39.09 237.13,39.09 237.28,39.25 242.84,39.25 243.23,39.63 246.08,39.63 246.53,40.08 248.81,40.08 249.37,40.64 250.31,40.64 253.38,43.72 253.76,43.72 254.55,44.51 258.07,44.51 260.81,47.25 262.99,47.25 265.56,49.82 266.38,49.82 266.38,49.82 267.15,49.82 269.46,52.12 269.46,52.89 270.17,53.6 270.53,53.6 271.19,54.26 271.19,54.95 270.83,55.31 270.83,56.23 272.04,57.44 272.04,58.42 272.61,58.99 272.61,59.88 274.08,61.36 274.08,64.61 274.74,65.27 274.74,71.08 274.98,71.33 274.98,72.53 276.74,74.29 276.74,77.45 275.84,78.35 275.84,79.59 275.83,79.6 275.83,82.37 275.52,82.68 v1(275.52,83.76)
  BOTTOM w0.127: RE292.2 v1(175.27,79.11) 176.03,79.11 176.54,78.61 UE5.2 ; v1(275.52,83.76) 275.15,83.4 273.72,83.4 272.36,84.76 272.36,86.54 272.6,86.79 272.6,88.32 272.47,88.45 270.96,88.45 270.01,89.4 267.98,89.4 v1(267.85,89.27)
RUNPWROK: length 25.8
  TOP w0.127: UE1.G3 277.42,79.31 v1(277.08,78.98) ; v1(282.28,67.79) 282.28,67.22 v2(281.88,66.81) 280.6,65.54 QE2.3 280.6,64.58 280.76,64.42 281.58,64.42 RE67.1
  IN1 w0.084: v1(277.08,78.98) 278.36,77.7 280.36,77.7 280.97,78.31 281.28,78.31 281.78,78.81 v1(283.5,78.81)
  IN2 w0.122: v1(283.5,78.81) 282.33,77.63 282.33,76.13 283.03,75.43 283.03,73.85 282,72.82 282,68.35 282.28,68.08 v1(282.28,67.79)
S1_OVP: length 42.7
  TOP w0.254: PR836.2 42,85.59 v1(41.43,85.59) ; v1(54.41,87.71) 54.87,88.17 PQ10.3 54.87,88.7 55.73,89.55 56.34,89.55 PR32.2 57.07,90.28 PR46.1
  IN2 w0.254: v1(41.43,85.59) 41.54,85.59 45.48,89.53 45.48,91.65 43.03,94.09 41.85,94.09 41.44,94.5 41.44,94.98 42.31,95.85 v1(42.31,96.67)
  IN3 w0.254: v1(42.31,96.67) 42.31,96.84 42.58,97.11 43.35,97.11 43.91,96.55 47.6,96.55 48.86,95.3 48.86,92.26 48.02,91.43 48.02,90.25 49.88,88.39 53.74,88.39 v1(54.41,87.71)
SBIOS_TX: length 225.5
  TOP w0.127: v1(291.79,96.58) 291.79,96.47 292.38,95.88 RE306.1
  IN2 w0.089: v1(157.49,83.84) 157.88,83.45 160.3,83.45 160.76,83.91 161.76,83.91
  IN2 w0.122: v1(267.28,88.77) 266.58,88.07 266.58,86.99 265.17,85.58 265.17,84.52 265.35,84.34 265.35,80.81 265.12,80.58 265.12,73.17 264.69,72.74 264.69,65.98 265.3,65.37 265.3,62.37 264.47,61.54 264.47,57.99 263.92,57.44 263.92,53.85 261.23,51.16 261.23,49.22 262.16,48.29 262.16,46.32 263.28,45.19 263.28,43.61 262.71,43.04 260.23,43.04 259.58,43.69 256.95,43.69 256.1,42.83 245.61,42.83 244.75,41.97 243.85,41.97 241.96,40.08 229.97,40.08 229.09,40.97 228.27,41.78 219.41,41.78 200.15,61.03 200.15,65.3 198.47,69.73 198.47,69.74 197.93,70.28 197.93,72.09 194.88,75.15 194.01,75.15 189.42,79.74 185.53,79.74 185.51,79.76 182.6,79.76 181.08,78.25 180.07,78.25 180.05,78.27 177.58,78.27 176.35,79.51 174.03,79.51 172.76,80.78 171.34,80.78 170.88,80.32 169.74,80.32 169.3,80.77 169.3,81.54 168.87,81.97 167.49,81.97 165.56,83.91 161.76,83.91 ; v1(291.79,96.58) 288.23,96.58 286.78,95.13 280.36,95.13 279.48,96.01 269.06,96.01 267.72,97.34 v1(267.72,98.93)
  IN3 w0.122: v1(267.72,98.93) 267.24,98.44 267.24,88.81 v1(267.28,88.77)
  BOTTOM w0.076: UC1.CP14 153.35,83.02 153.83,83.29 154.1,83.29 154.29,83.09 156.66,83.09 157.1,83.53
  BOTTOM w0.102: v1(157.49,83.84) 157.41,83.84 157.1,83.53
SCL_CHG: length 3.5
  TOP w0.203: PR715.2 42.02,52.35 v2(42.72,52.35) 43.35,52.35 44.25,53.25 PU700.22
SD/MMCCD#: length 29.9
  TOP w0.127: v1(301.63,53.14) JSD1.9 ; UR1.30 291.79,69 291.54,69.25 291.29,69.25 290.84,69.69 v1(290.84,69.78) v2(289.92,69.78)
  IN1 w0.084: v1(297.19,67.68) 297.19,66.41 298.26,65.34 298.26,62.82 300.83,60.26 301.82,60.26 302.96,59.11 302.96,54.16 301.94,53.14 v1(301.63,53.14)
  BOTTOM w0.127: v1(290.84,69.78) 290.84,69.76 293.42,67.18 296.68,67.18 v1(297.19,67.68)
SD/MMCCLK: length 2.7
  TOP w0.127: UR1.17 294.71,65.14 294.82,65.03 294.82,64.37 295.88,63.31 RR5.1
SD/MMCCLK_R: length 11.4
  TOP w0.127: v1(301.06,56.75) 301.75,57.43 JSD1.5 ; RR5.2 296.65,63.43 CR21.1 v2(297.3,62.43) 297.3,61.92 v1(298.33,60.89)
  IN1 w0.084: v1(298.33,60.89) 298.52,60.89 299.98,59.43 299.98,58.6 301.06,57.52 v1(301.06,56.75)
SD/MMCCMD: length 2.3
  TOP w0.127: UR1.19 295.15,65.94 v2(295.58,65.51) 296.01,65.08 RR6.1
SD/MMCCMD_R: length 12.7
  TOP w0.127: JSD1.3 301.95,59.23 v1(301.63,59.56) ; RR6.2 v1(297.81,65.08)
  IN1 w0.084: v1(297.81,65.08) 297.81,64.02 297.67,63.89 297.4,63.89 297.31,63.8 297.31,63.61 297.4,63.52 297.74,63.52 297.82,63.44 297.82,63.27 297.74,63.19 297.33,63.19 297.25,63.1 297.25,62.88 297.33,62.8 297.74,62.8 297.82,62.72 297.82,62.55 297.74,62.47 297.4,62.47 297.31,62.38 297.31,62.2 297.4,62.11 298.42,62.11 300.97,59.56 v1(301.63,59.56)
SD/MMCDAT0/RCLK+: length 3.5
  TOP w0.089: RR10.1 295.81,62.33 295.73,62.41 295.73,62.67 294.41,63.98 293.89,63.98 293.73,64.15 293.73,64.43 UR1.16
SD/MMCDAT0/RCLK+_R: length 12.8
  TOP w0.089: RR10.2 295.7,61.52 295.7,60.79 295.98,60.51 296.59,60.51 296.81,60.29 296.81,59.97 v1(297.15,59.64) ; JSD1.7 302.09,55.63 301.61,55.15 300.97,55.15 v1(300.59,55.53)
  IN1 w0.084: v1(300.59,55.53) 300.59,55.51 300.44,55.36 300.24,55.36 299.9,55.7 299.9,57.42 298.33,58.99 297.03,58.99 296.93,59.09 296.93,59.42 v1(297.15,59.64)
SD/MMCDAT1/RCLK-: length 3.4
  TOP w0.089: UR1.15 293.5,64.37 293.5,64.06 293.8,63.76 294.32,63.76 v4(294.7,63.38) 295.5,62.58 295.5,62.54 RR9.1
SD/MMCDAT1/RCLK-_R: length 12.8
  TOP w0.089: RR9.2 295.47,61.55 295.47,60.7 v4(295.66,60.52) 295.89,60.29 296.5,60.29 296.59,60.2 v1(296.59,59.62) ; v1(300.59,54.95) 300.61,54.93 301.7,54.93 301.73,54.95 301.85,54.95 302.07,54.73 JSD1.8
  IN1 w0.084: v1(296.59,59.62) 296.59,58.95 296.89,58.65 298.19,58.65 299.56,57.28 299.56,55.56 300.1,55.02 300.51,55.02 v1(300.59,54.95)
SD/MMCDAT2: length 2
  TOP w0.127: RR8.1 296.32,66.8 v2(295.52,66.8) 295.46,66.74 UR1.21
SD/MMCDAT2_R: length 12.4
  TOP w0.127: v1(301.63,61.61) 302.2,61.03 JSD1.1 ; v1(298.39,66.92) v2(297.83,66.92) 297.5,66.92 297.31,66.73 RR8.2
  IN1 w0.084: v1(301.63,61.61) 302.01,61.23 302.01,60.95 301.7,60.64 300.99,60.64 299.92,61.71 299.92,62.1 298.65,63.37 298.65,65.78 298.39,66.03 v1(298.39,66.92)
SD/MMCDAT3: length 2.1
  TOP w0.127: UR1.20 295.28,66.34 295.65,65.97 RR7.1
SD/MMCDAT3_R: length 12.8
  TOP w0.127: v1(301.06,61.27) 302.2,60.14 JSD1.2 ; RR7.2 298.74,65.97 v2(298.82,66.05) 298.98,66.21 v1(298.98,66.92)
  IN1 w0.084: v1(301.06,61.27) 301.06,61.72 300.05,62.72 300.05,62.84 300.19,62.98 300.19,63.1 300.08,63.22 299.96,63.22 299.81,63.08 299.7,63.08 299.58,63.2 299.58,63.32 299.72,63.46 299.72,63.58 299.6,63.7 299.48,63.7 299.34,63.55 299.22,63.55 299.04,63.74 299.04,65.94 298.98,66 v1(298.98,66.92)
SD_GPIO: length 3.2
  TOP w0.127: v2(290.91,70.64) 291.17,70.39 RR3.2 292.25,70.01 292.25,69.53 292.58,69.19 UR1.28
SD_RCOMP: length 11.1
  TOP w0.381: v1(157.88,65.85) 158.89,64.84 RC116.1
  IN2 w0.2: v1(151.42,70.28) 152.43,69.27 153.99,69.27 157.41,65.85 v1(157.88,65.85)
  BOTTOM w0.2: UC1.CK33 v1(151.42,70.28) UC1.CM34
SD_UHS2_D0N: length 34.4
  TOP w0.089: UR1.25 293.79,69.15 293.85,69.21 294.54,69.21 295.21,69.87 296.49,69.87 297.12,70.5 297.28,70.5 297.5,70.28 v1(297.5,70.24) ; JSD1.19 315.67,56.85 315.53,57 315.19,57 314.84,56.65 v1(314.84,56.45)
  IN1 w0.084: v1(297.5,70.24) 297.68,70.42 305.03,70.42 307.74,67.7 307.74,60.37 307.74,60.36 307.74,60.3 307.74,60.29 307.74,60.08 311.22,56.6 314.36,56.6 314.43,56.52 314.43,56.36 314.5,56.29 314.78,56.29 314.84,56.36 v1(314.84,56.45)
SD_UHS2_D0P: length 34.4
  TOP w0.089: UR1.26 293.38,69.06 293.76,69.43 294.45,69.43 295.12,70.1 v4(295.61,70.1) 296.4,70.1 297.02,70.72 297.4,70.72 v1(297.5,70.82) ; v1(314.71,57.08) 314.95,57.08 315.23,57.36 315.23,57.56 315.44,57.76 JSD1.18
  IN1 w0.084: v1(314.71,57.08) 314.57,56.94 314.5,56.94 314.5,56.94 311.36,56.94 308.08,60.22 308.08,67.84 305.17,70.75 297.57,70.75 v1(297.5,70.82)
SD_UHS2_D1N: length 32.4
  TOP w0.089: v1(299,69.39) 298.85,69.23 297.53,69.23 v4(297.18,68.88) 295.79,67.49 295.04,67.49 295,67.54 UR1.23 ; JSD1.21 315.36,55.03 315.28,54.96 315.28,54.67 315.17,54.55 314.83,54.55 v1(314.78,54.6)
  IN1 w0.084: v1(299,69.39) 299.1,69.29 300.06,69.29 300.44,68.91 303.14,68.91 306.79,65.25 306.79,59.16 311.35,54.6 v1(314.78,54.6)
SD_UHS2_D1P: length 32.4
  TOP w0.089: UR1.22 295,67.14 295.13,67.27 295.88,67.27 297.34,68.73 297.62,69.01 298.79,69.01 v1(299,68.81) ; v1(314.78,54.03) 314.78,54.06 315.05,54.33 315.37,54.33 315.57,54.12 JSD1.22
  IN1 w0.084: v1(314.78,54.03) 314.54,54.27 311.21,54.27 306.46,59.02 306.46,65.11 303,68.57 300.3,68.57 299.92,68.95 299.15,68.95 v1(299,68.81)
SDA_CHG: length 3.2
  TOP w0.203: PR713.2 v2(43.59,53.34) 43.89,53.34 44.2,53.65 PU700.21
SDWP: length 29.8
  TOP w0.127: UR1.29 292.18,69.03 291.59,69.62 v1(291.59,69.78) ; v2(289.06,48.84) 289.3,49.08 v1(289.3,49.78) 287.8,49.78 287.42,50.16 QR1.1
  IN4 w0.084: v1(291.59,69.78) 292.82,68.55 293.13,68.55 293.87,67.81 293.87,67.33 294.97,66.23 295.53,65.67 295.53,62.35 294.6,61.41 294.6,57.73 291.28,54.41 291.28,53.78 v1(290.71,53.21)
  BOTTOM w0.127: v1(289.3,49.78) 289.3,51.61 290.71,53.02 v1(290.71,53.21)
SIM_DET: length 32.5
  TOP w0.127: v1(297.31,57.5) DZ13.5 DZ13.6 294.59,57.5 293.55,58.53 v1(293.19,58.53)
  IN1 w0.084: v1(283.18,58.77) 283.83,58.77 284.49,59.43 285.18,59.43 286.3,58.32 289.21,58.32 289.83,58.94 292.4,58.94 292.82,58.53 v1(293.19,58.53)
  BOTTOM w0.127: v1(297.31,57.5) 296.11,58.7 296.11,64.7 297.36,65.95 JSIM1.2 ; JNGFF2.66 283.43,63.02 282.89,62.48 282.45,62.48 282.3,62.33 282.3,59.96 283.18,59.09 v1(283.18,58.77)
SIO_EXT_WAKE#: length 217.3
  TOP w0.127: RE703.1 278.47,97.74 279.53,98.8 v1(279.98,98.8) ; v2(171.49,82.82) 171.24,82.57 v1(171.24,82.15)
  IN1 w0.102: v1(171.24,82.15) 166.85,82.15 166.05,82.95 153.88,82.95 152.57,84.26 150.26,84.26 149.7,83.7 v1(149.59,83.7)
  IN2 w0.122: v1(266.9,98.99) 267.65,99.74 272.19,99.74 273.13,98.8 v1(279.98,98.8) ; v1(266.58,88.83) 266.36,88.61 266.36,87.08 264.95,85.67 264.95,84.43 265.13,84.25 265.13,80.9 264.9,80.67 264.9,73.26 264.46,72.83 264.46,65.89 265.08,65.28 265.08,62.46 264.24,61.63 264.24,58.1 263.7,57.55 263.7,53.94 261.01,51.25 261.01,49.13 261.93,48.2 261.93,46.22 263.06,45.1 263.06,43.71 262.61,43.26 260.33,43.26 259.66,43.93 256.88,43.93 256.01,43.06 245.51,43.06 244.65,42.2 243.76,42.2 241.87,40.3 230.06,40.3 229.18,41.19 228.37,42 219.5,42 200.37,61.13 200.37,65.34 198.7,69.77 198.7,69.83 198.16,70.38 198.16,72.8 195.58,75.37 194.1,75.37 189.51,79.96 185.63,79.96 185.61,79.99 180.04,79.99 179.48,79.43 179.16,79.43 178.94,79.64 176.77,79.64 176.68,79.73 174.21,79.73 173.71,80.23 173.71,81.43 173.42,81.72 171.67,81.72 v1(171.24,82.15)
  IN3 w0.122: v1(266.9,98.99) 267.01,98.87 267.01,89.39 266.58,88.96 v1(266.58,88.83)
  BOTTOM w0.089: UC1.CG12 v1(149.59,83.7)
  BOTTOM w0.127: v1(171.24,82.15) 171.28,82.15 171.39,82.04 RC748.1
SIO_EXT_WAKE#_EC: length 27
  TOP w0.102: UE1.M12 281.67,86.56 282,86.88 283.66,86.88 v1(283.71,86.83)
  TOP w0.127: v1(287.11,99.74) 286.66,99.74 286.53,99.86 v2(282.86,99.86) 281.76,99.86 279.99,98.1 279.26,98.1 278.96,97.8 278.96,97.48 278.49,97.01 RE703.2
  IN3 w0.122: v1(287.11,99.74) 287.31,99.54 287.31,98.26 286.52,97.47 286.52,94.93 284.83,93.24 284.83,91.18 284.61,90.96 284.61,87.77 283.71,86.87 v1(283.71,86.83)
SIO_PWRBTN#: length 441.5
  TOP w0.127: v2(47.5,46.02) 46.84,46.68 v1(46.68,46.68) ; RC241.1 CC269.1 62.31,95.12 v1(61.88,95.55) ; UE1.K11 v1(280.22,86.15)
  IN1 w0.084: v1(280.22,86.15) 280.5,86.44 281.78,86.44 282.45,85.77 285.3,85.77 285.8,86.27 286.56,86.27 286.87,86.58 287.18,86.58 287.23,86.54 289.88,86.54 v1(289.92,86.58)
  IN2 w0.122: v1(46.68,46.68) 47.47,46.68 47.77,46.98 47.77,47.76 48.17,48.17 51.76,48.17 52.27,47.65 57.54,47.65 58.58,48.69 63,48.69 63.42,48.27 79.17,48.27 82.71,51.81 141.48,51.81 144.02,49.28 145.67,49.28 147.09,50.69 148.84,50.69 149.74,49.8 151.74,49.8 152.07,49.47 154.9,49.47 157.62,52.19 160.79,52.19 161.8,53.21 163.33,53.21 164.69,54.57 166.01,54.57 v1(166.38,54.94)
  IN4 w0.084: v1(143.93,73.85) 143.45,74.34 143.45,74.73 143.33,74.86 142.88,74.86 142.6,74.58 142.6,69.7 146.13,66.17 147.94,66.17 149.22,64.89 149.85,64.89 150.56,64.17 151.82,64.17 155.62,60.38 155.62,60.03 156.18,59.47 156.18,58.75 156.18,58.75 156.18,58.16 158.87,55.47 165.89,55.47 166.38,54.97 v1(166.38,54.94) 166.38,54.65 167.03,54 168.31,54 169.07,54.75 169.07,55.07 169.5,55.51 170.6,55.51 171.08,55.99 174.73,55.99 174.9,56.16 175.98,56.16 176.27,56.44 183.15,56.44 188.02,51.56 188.02,51.21 192.65,46.58 200.69,46.58 208.83,38.44 209.19,38.44 210.89,36.75 212.79,36.75 215.56,33.98 218.83,33.98 220.29,32.51 223.67,32.51 224.4,31.78 230.75,31.78 230.83,31.86 238.3,31.86 240.13,30.03 244.8,30.03 245.05,30.28 250.45,30.28 251.34,31.17 255.72,31.17 257.64,33.09 258.72,33.09 258.83,33.21 258.83,34.2 258.92,34.28 260.04,34.28 260.17,34.41 260.17,35.36 263.66,38.86 263.66,41.92 261.47,44.11 261.47,44.65 262.54,45.71 266.53,45.71 267.27,46.45 267.27,46.85 268.55,48.13 268.55,50.2 268.58,50.23 268.58,50.25 269.96,51.63 273.11,51.63 273.38,51.36 275.53,51.36 275.79,51.62 275.79,51.89 276.33,52.43 277.67,52.43 278.32,53.07 280.93,53.07 281.36,53.5 284.33,53.5 285.47,54.63 287.37,54.63 287.47,54.73 290.81,54.73 294.05,57.98 294.05,61.64 294.99,62.57 294.99,65.45 291.1,69.34 290.76,69.34 290.47,69.63 290.47,70.04 290.68,70.25 290.68,71.64 290.32,71.99 290.32,73.15 289.11,74.36 289.11,75.17 288.47,75.81 288.47,77.76 289.41,78.7 289.41,79.38 290.33,80.29 290.33,80.89 289.84,81.38 289.84,83.48 290.19,83.83 290.19,85.86 289.92,86.13 v1(289.92,86.58) ; v1(46.68,46.68) 46.68,45.78 46.01,45.11 45.31,45.11 44.98,45.45 44.98,47.82 44.48,48.32 43.66,48.32 42.31,49.66 42.31,53.16 42.41,53.26 42.41,56.69 42.99,57.26 42.99,58.36 42.71,58.63 42.71,60.98 42.25,61.44 42.25,70.52 42.22,70.54 42.22,73.01 44.15,74.93 44.64,74.93 47.07,77.37 47.07,78.2 51.8,82.92 51.8,85 53.28,86.48 53.28,89.15 53.72,89.59 53.72,91.81 56.14,94.23 57.84,94.23 58.74,95.13 61.46,95.13 v1(61.88,95.55)
  BOTTOM w0.089: UC1.BU28 v1(143.93,73.85)
  BOTTOM w0.127: JXDP1.41 v1(61.88,95.55)
SIO_SLP_A#: length 193.4
  TOP w0.127: CC1469.1 RC233.1 v1(163.16,57.1) ; v1(198.32,49.65) v3(199.43,49.65)
  IN1 w0.084: v1(291.85,26.22) 291.57,25.93 289.07,25.93 286.96,28.04 279.72,28.04 278.31,29.46 277.06,29.46 275.73,28.13 255.36,28.13 254.71,28.78 254.25,28.78 253.6,28.13 240.39,28.13 237.29,31.24 234.24,31.24 229.74,26.74 227.88,26.74 227.79,26.82 227.79,27.88 225.07,30.61 219.97,30.61 217.55,33.03 208.22,33.03 207.71,33.54 207.71,34.09 207.93,34.31 207.93,40.59 198.87,49.65 v1(198.32,49.65)
  IN4 w0.084: v1(198.32,49.65) 195.73,49.65 195.53,49.45 191.31,49.45 189.11,51.66 189.11,52.01 183.6,57.52 174.74,57.52 174.29,57.07 170.63,57.07 170.15,56.59 168.62,56.59 168.22,56.19 166.7,56.19 166.25,56.64 163.63,56.64 v1(163.16,57.1)
  BOTTOM w0.076: UC1.BU37 143.69,68.41 143.69,67.4 144.91,66.17 144.91,64.44
  BOTTOM w0.114: 144.91,64.44 144.91,62.22 147.17,59.96 148.91,59.96 152.58,56.29 155.9,56.29 157.93,54.27 161.53,54.27 161.87,54.6 161.87,55.81 v1(163.16,57.1)
  BOTTOM w0.127: v1(291.85,26.22) 291.85,26.79 292.52,27.46 293.2,27.46 295.95,30.21 JAPS1.6
SIO_SLP_LAN#: length 32.2
  TOP w0.127: CC1471.1 RC761.1 158.77,56.56 RC344.1 RC68.1 159.61,56.57 v1(159.61,57.26)
  IN2 w0.076: 142.59,71.08 142.59,71.39 143.02,71.82 v1(143.02,71.95)
  IN2 w0.102: v1(159.61,57.26) 159.21,57.65 157.36,57.65 156,59.01 146.73,59.01 144.81,60.93 144.81,61.24 143.66,62.39 143.66,68.04 142.59,69.12 142.59,71.08
  BOTTOM w0.089: v1(143.02,71.95) 142.71,72.11 UC1.BT31
SIO_SLP_S0#: length 397.7
  TOP w0.127: RZ1419.1 148.53,48.16 148.53,48.57 v1(148.43,48.67) ; RC763.1 139.79,61.28 v1(140.01,61.5) ; v1(79,28.19) 78.24,28.95 78.24,29.52 77.73,30.03 77.73,31.11 77.87,31.25 PR425.1 ; RZ1407.1 188.32,81.48 RZ112.1 187.74,82.06 187.74,82.5 RZ362.2 187.31,82.94 187.31,83.21 186.7,83.82 v1(186.7,83.93) ; v1(177.93,28.96) v2(177.93,29.58)
  IN2 w0.122: v1(148.43,48.67) 148.43,48.65 149.91,47.17 155.38,47.17 157.73,49.53 v1(178.37,49.53) 181.81,49.53 183.71,51.43 183.71,53.9 185.81,56.01 188.35,56.01 v1(189.23,56.89)
  IN3 w0.122: v1(189.23,56.89) 186.77,56.89 185.53,58.12 185.53,71.51 184.86,72.18 184.86,75.49 183.22,77.13 183.22,78.23 180.14,81.31 180.14,82.32 179.24,83.22 v1(177.45,83.22) ; v1(148.43,48.67) 148.02,49.08 145.53,49.08 142.44,52.18 142.44,53.03 138.88,56.59 138.88,58.58 139.72,59.41 139.72,61.21 v1(140.01,61.5) ; v1(79,28.19) 79.06,28.12 79.06,27.11 79.9,26.27 89.59,26.27 90.21,25.65 92.91,25.65 94.11,26.85 98.81,26.85 98.82,26.87 100.83,26.87 101.73,25.97 103.96,25.97 104.27,26.28 120.4,26.28 120.72,25.97 148.72,25.97 150.31,27.55 156.09,27.55 157.11,28.57 160.28,28.57 162.06,26.79 172.53,26.79 173.14,27.39 173.9,27.39 174.19,27.68 176.34,27.68 177.62,28.96 v1(177.93,28.96) 177.94,28.95 178,28.95 178.06,28.89 178.06,28.51 178.7,27.87 178.7,26.28 179.33,25.65 181.62,25.65 181.96,25.99 190.4,25.99 191.97,27.55 198.19,27.55 202.36,23.38 227.16,23.38 229.34,25.55 234.04,25.55 235.4,26.92 235.4,26.94 236.39,27.92 250.63,27.92 251.28,28.57 253.88,28.57 254.16,28.85 261.02,28.85 261.88,29.71 264.39,29.71 265.02,30.34 266.44,30.34 267.06,29.72 273.72,29.72 274.33,30.33 274.76,30.33 275.38,29.71 276.53,29.71 278.76,31.94 280.86,31.94 282.9,29.9 286.02,29.9 286.56,29.36 290.55,29.36 291.03,28.89 v1(291.03,28.82)
  IN4 w0.084: v1(177.93,28.96) 177.93,30.53 179.18,31.78 189.58,31.78 189.99,32.19 189.99,37.55 187.6,39.93 187.6,40.69 187.39,40.91 186.47,40.91 178.37,49.01 v1(178.37,49.53)
  BOTTOM w0.076: UC1.BJ37 138.65,68.41 138.65,67.37 139.01,67 139.01,62.03
  BOTTOM w0.114: v1(140.01,61.5) 139.54,61.5 139.01,62.03
  BOTTOM w0.127: v1(291.03,28.82) 291.03,29.9 291.45,30.33 JAPS1.15 ; v1(186.7,83.93) 185.41,85.21 183.71,85.21 182.39,86.53 181.09,86.53 179.39,84.83 179.39,84.74 RC660.1 178.39,84.04 178.21,83.86 178.21,83.48 177.95,83.22 v1(177.45,83.22) 177.22,83.22 177.04,83.4 UC9.2
SIO_SLP_S3#: length 469.5
  TOP w0.127: v1(244.09,36.82) v3(244.09,36.15) ; RZ1416.1 v1(137.93,111.75) ; v1(150.83,47.58) 149.65,46.41 RZ1418.1 ; RC231.1 CC1468.1 145.97,55.94 v1(147.71,57.68)
  IN1 w0.084: v1(33.62,92.06) 31.76,92.06 29.47,89.77 28.05,89.77 27.63,89.36 27.63,89.19 26.35,87.91 26.35,87.43 26.13,87.22 26.13,86.65 25.58,86.1 23.55,86.1 23.05,85.59 v1(22.61,85.59) ; v1(293.31,26.28) 292.93,26.66 291.66,26.66 291.12,26.12 289.15,26.12 287.04,28.23 279.8,28.23 278.36,29.67 276.95,29.67 276.29,29 274.13,29 273.44,28.32 263.25,28.32 v1(262.91,28.66)
  IN2 w0.122: v1(167.06,53.09) 167.06,52.17 164.84,49.96 157.85,49.96 155.47,47.58 v1(150.83,47.58) ; v1(33.62,92.06) 34.32,92.75 34.32,96.22 32.61,97.94 32.61,102.38 32.89,102.67 33.41,102.67 34.21,101.87 34.21,101.26 35.18,100.29 v1(38.48,100.29) ; v1(137.93,111.75) 138.52,111.17 141.31,111.17 141.77,110.71 145.77,110.71 146.63,109.85 151.77,109.85 153.26,111.34 157.64,111.34 158.24,111.93 164.55,111.93 170.99,105.49 170.99,103.2 171.35,102.85 171.35,102.06 171.18,101.89 171.18,101.57 171.57,101.18 v1(171.57,101.13)
  IN3 w0.122: v1(182.07,63.98) 181.43,64.62 181.43,65.81 182.12,66.51 182.12,70.73 176.79,76.07 v1(176.79,76.32) ; v1(137.93,111.75) 137.93,111.48 137.81,111.36 137.05,111.36 136.59,111.81 113.62,111.81 111.53,109.72 105.63,109.72 105.36,110 103.17,110 102.39,109.22 91.41,109.22 90.08,110.55 89.29,110.55 88.69,109.95 82.9,109.95 82.67,110.17 81.85,110.17 81.7,110.32 79.42,110.32 77.96,111.78 67.23,111.78 66.99,111.53 54.77,111.53 51.69,108.45 46.09,108.45 38.48,100.84 v1(38.48,100.29) ; v1(171.57,101.13) 171.57,100.69 172.31,99.95 172.31,96.69 174.33,94.67 174.33,94.11 174.96,93.47 174.96,92.33 176.9,90.39 176.9,84.09 176.45,83.64 176.45,82.5 177.35,81.6 177.86,81.6 178.2,81.26 178.2,79.35 v1(178.1,79.25) ; v1(147.71,57.68) 147.71,57.64 149.75,55.59 156.79,55.59 158.26,54.13 165.71,54.13 166.75,53.09 v1(167.06,53.09) 168.17,53.09 170.5,50.75 177.89,50.75 178.25,51.11 178.25,53.27 179.62,54.64 v1(179.87,54.64) 180.25,54.64 180.41,54.48 181.14,54.48 181.93,55.27 182.62,55.27 189.53,48.36 206.95,48.36 216.4,38.91 224.78,38.91 226.61,37.08 237.96,37.08 238.08,37.2 243.31,37.2 243.69,36.82 v1(244.09,36.82)
  BOTTOM w0.076: 146.43,60.31 144.73,62.01 144.73,66.12 143.47,67.38 143.47,68.23 143.35,68.35 143.31,68.44 143.31,68.63 143.35,68.72 143.56,68.93 UC1.BU36 ; UT1.D2 23.33,82.3 23.33,82.78 23.07,83.04 23.07,83.92 22.9,84.08 22.9,84.54 22.61,84.83 v1(22.61,85.59)
  BOTTOM w0.127: v1(182.07,63.98) 181.09,64.95 179.33,64.95 177.3,62.92 177.3,61.4 178.46,60.24 178.46,57.02 179.87,55.6 v1(179.87,54.64) ; UE3.2 179.2,78.67 178.62,79.25 v1(178.1,79.25) 177.42,79.25 177.19,79.02 UE5.1 177.19,77.8 176.75,77.36 RE280.2 176.75,76.36 v1(176.79,76.32) ; v1(262.91,28.66) 262.41,28.66 260.37,30.7 258.79,30.7 258.23,31.27 255.15,31.27 254.45,30.56 254.45,29.97 253.12,28.64 247.02,28.64 243.07,32.58 243.07,34.32 244.09,35.34 v1(244.09,36.82) ; QE11.2 173.27,101.12 171.58,101.12 v1(171.57,101.13) ; v1(293.31,26.28) 293.31,26.6 296.81,30.09 297.82,30.09 297.95,30.22 JAPS1.2 ; v1(147.71,57.68) 147.71,59.03 146.43,60.31
SIO_SLP_S4#: length 388.2
  TOP w0.127: v1(228.35,27.11) 228.35,25.2 227.46,24.31 PR208.1 ; v1(139.13,112.01) 138.94,111.82 RZ1417.1 ; v1(161.38,57.21) RC232.1 CC1467.1
  TOP w0.254: PR513.1 127.97,27.88 v2(128.18,28.09) 128.66,28.57 v1(128.85,28.57)
  IN2 w0.122: v1(171.57,101.73) 171.57,102.99 171.22,103.34 171.22,105.58 164.65,112.16 158.14,112.16 157.55,111.56 153.17,111.56 153.09,111.49 150.89,111.49 150.49,111.08 150.49,110.66 149.9,110.07 146.72,110.07 145.85,110.94 141.86,110.94 141.41,111.39 139.75,111.39 v1(139.13,112.01)
  IN3 w0.122: v1(292.89,27.06) 292.04,27.91 292.04,29.46 291.92,29.58 286.65,29.58 286.08,30.16 283.09,30.16 281.08,32.17 278.67,32.17 276.43,29.93 275.47,29.93 274.85,30.55 274.23,30.55 273.62,29.94 267.16,29.94 266.53,30.57 264.92,30.57 264.29,29.94 260.85,29.94 259.99,29.08 254.07,29.08 253.79,28.8 251.18,28.8 250.54,28.15 236.29,28.15 235.18,27.03 235.18,27.01 233.94,25.78 230.7,25.78 229.88,26.6 229.88,26.85 229.56,27.17 229.56,27.36 229.35,27.57 228.47,27.57 228.35,27.45 v1(228.35,27.11) 228.35,26.92 228,26.57 228,24.85 226.98,23.83 202.55,23.83 198.37,28 191.78,28 191.17,27.39 185.74,27.39 184.85,26.5 181.08,26.5 178.8,28.78 v1(178.8,28.95) 178.8,29.29 178.44,29.65 177.55,29.65 176.13,28.22 174.1,28.22 173.74,27.87 172.98,27.87 172.35,27.24 162.25,27.24 160.46,29.02 156.92,29.02 155.9,28 150.12,28 150.12,28 150.06,28 148.6,26.54 130.88,26.54 v1(128.85,28.57) ; v1(171.57,101.73) 171.44,101.86 170.81,101.86 170.73,101.94 170.33,101.94 170.14,101.75 170.14,101.09 171.23,100 171.3,100 171.64,99.67 171.64,96.69 170.63,95.68 170.63,93.12 172.49,91.26 172.49,89.24 172.31,89.05 172.31,88.41 172.71,88.01 172.71,85.62 172.33,85.24 172.33,83.92 172.21,83.8 167.02,83.8 166.24,83.02 164.42,83.02 162.34,80.94 162.34,77.24 162.08,76.98 162.08,75.2 161.88,75.01 161.88,72.99 160.94,72.05 160.2,72.05 159.93,71.78 159.93,70.48 159.36,69.92 157.56,69.92 157.11,69.47 157.11,68.72 158.5,67.33 158.5,58.48 159.07,57.91 160.68,57.91 v1(161.38,57.21) 162.27,56.32 170.95,56.32 174.58,52.69 v1(175.11,52.69)
  IN4 w0.076: v1(143.93,74.49) 144.47,73.95 144.47,73.55 144.48,73.54 144.48,71.13 144.54,71.07
  IN4 w0.084: v1(178.8,28.95) 178.8,31 179.4,31.59 189.65,31.59 190.17,32.11 190.17,37.63 187.79,40.01 187.79,40.77 187.56,40.99 187.46,41.09 186.54,41.09 178.74,48.9 178.74,49.68 178.12,50.3 175.96,50.3 175.58,50.68 175.58,51.84 175.9,52.16 175.9,52.51 175.72,52.69 v1(175.11,52.69)
  IN4 w0.102: 144.54,71.07 145.08,70.52 145.08,69.88 146.55,68.41 146.55,68.27 147.44,67.38 149.71,67.38 151.3,65.78 151.65,65.78 153.32,64.12 154.1,64.12 158.66,59.56 160.92,59.56 161.38,59.09 v1(161.38,57.21)
  BOTTOM w0.089: UC1.BU27 v1(143.93,74.49)
  BOTTOM w0.127: JAPS1.5 296.45,30.39 293.13,27.06 v1(292.89,27.06)
