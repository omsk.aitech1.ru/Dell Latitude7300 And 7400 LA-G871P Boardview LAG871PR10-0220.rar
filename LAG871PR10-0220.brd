# Allegro board LAG871PR10-0220.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCDPHY_1P24 on BOTTOM (solid shape): 157.94,75.16 162.24,75.16 162.56,74.84 162.56,74.22 162.46,74.13 158.09,74.13 157.61,74.61 157.58,74.64 157.55,74.67 156.63,75.59 156.56,75.61 156.53,75.68 156.22,75.99 155.9,75.68 155.87,75.61 155.8,75.59 154.85,75.59 154.81,75.62 154.47,75.62 154.24,75.85 153.37,75.85 153.32,75.9 153.34,75.93 153.36,75.99 153.35,76.08 153.37,76.16 153.37,76.27 153.46,76.27 153.73,76.13 154.22,76.13 154.45,76.36 156.74,76.36
+VCCLDOSRAM_1P24 on BOTTOM (solid shape): 146.35,77.21 146.35,76.57 146.08,76.3 145.9,76.3 145.65,76.44 145.39,76.32 145.31,76.32 145.16,76.48 145.16,76.64 145.22,76.7 145.34,77.01 145.15,77.28 145.15,77.49 145.19,77.51 145.23,77.54 145.4,77.54 145.44,77.52 145.49,77.48 145.51,77.48 145.64,77.45 145.77,77.48 145.78,77.48 145.82,77.48 145.9,77.56 145.99,77.56
+VCCPDSW_1P05 on IN1 (solid shape): outline of 147 points within 142.63,74.8 145.99,76.38
+VCCPLL_OC on TOP (solid shape): outline of 698 points within 138.74,48.77 146.05,75.18
+VCCPLL_OC on IN2 (solid shape): outline of 162 points within 138.81,70.59 140.55,74.89
+VDDA_AVDD1 on TOP (solid shape): 284.78,47.93 284.85,47.86 284.85,47.23 284.78,47.15 283.94,47.15 283.38,46.6 283.04,46.6 282.98,46.65 282.98,47.62 283.05,47.69 283.66,47.69 283.91,47.94 284.77,47.94
+VSS_PLL on TOP (solid shape): 277.6,77.83 277.6,76.86 277.38,76.65 277.38,74.48 277.22,74.31 276.62,74.31 276.54,74.4 276.54,75.83 276.98,76.28 276.98,76.81 277.24,77.07 277.24,77.83 277.34,77.93 277.5,77.93
GND on TOP (solid shape): 15.51,51.62 15.51,49.98 13.07,49.98 13.07,51.61 13.2,51.73 15.39,51.73
GND on TOP (solid shape): 16.34,31.87 16.2,31.74 12.67,31.74 12.56,31.85 12.56,33.55 16.34,33.55
GND on TOP (solid shape): 19.51,41.03 17.85,41.03 17.74,41.14 17.74,43.58 17.89,43.73 19.51,43.73
GND on TOP (solid shape): 19.52,45.55 18.72,45.55 18.72,49.95 17.92,49.95 17.92,50.75 19.52,50.75
GND on TOP (solid shape): 19.52,32.75 17.92,32.75 17.92,33.55 18.72,33.55 18.72,37.95 19.52,37.95
GND on TOP (solid shape): 298.74,75.03 299.54,75.03 299.54,74.23 297.94,74.23 297.94,79.43 298.74,79.43
GND on TOP (solid shape): 300.16,83.6 300.16,81.83 299.93,81.59 297.95,81.59 297.95,83.85 299.91,83.85
GND on TOP (solid shape): 19.52,32.75 9.42,32.75 9.42,33.55 18.72,33.55 18.72,49.95 9.42,49.95 9.42,50.75 19.52,50.75
GND on TOP (solid shape): 39.56,16.75 39.56,15.65 39.44,15.54 37.92,15.54 37.78,15.67 37.78,16.74 37.88,16.84 39.46,16.84
GND on TOP (solid shape): 139.26,105.78 139.26,102.93 138.56,102.23 137.48,102.23 135.96,103.75 135.96,105.28 136.66,105.98 139.07,105.98
GND on TOP (solid shape): 171.9,42.41 171.9,39.94 171.71,39.74 171.39,39.74 170.95,40.19 170.95,42.54 171.08,42.67 171.65,42.67
GND on TOP (solid shape): 186.44,88.51 186.44,87.18 186.32,87.05 185.43,87.05 185.24,87.24 185.24,88.45 185.55,88.77 186.19,88.77
GND on TOP (solid shape): 187.2,85.53 187.2,84.32 187.14,84.26 186.12,84.26 186,84.39 186,85.66 186.12,85.78 186.95,85.78
GND on TOP (solid shape): 284.67,60.41 284.67,59.77 284.32,59.43 282.19,59.43 281.95,59.67 281.95,60.58 282.03,60.66 284.42,60.66
GND on TOP (solid shape): 299.54,91.43 298.74,91.43 298.74,87.03 297.94,87.03 297.94,92.23 299.54,92.23
GND on TOP (solid shape): 72.24,74.02 72.24,72.02 72.19,71.96 71.57,71.96 70.51,73.02 70.51,74.23 70.66,74.37 71.89,74.37
GND on TOP (solid shape): 126.58,61.65 126.58,58.91 125.95,58.27 125.44,58.27 125.44,61.58 125.69,61.83 126.4,61.83
GND on TOP (solid shape): 192.03,24.44 192.03,23.43 191.97,23.36 188.73,23.36 188.54,23.55 188.54,24.5 188.79,24.76 191.71,24.76
GND on TOP (solid shape): 266.02,52.48 266.02,52.04 265.9,51.92 263.3,51.92 263.21,52.02 263.21,52.39 263.29,52.47 263.29,52.47 263.36,52.53 265.96,52.53
GND on TOP (solid shape): 266.86,57.32 266.86,56.17 266.75,56.06 263.3,56.06 263.23,56.14 263.23,56.85 263.35,56.98 263.6,56.98 264.96,58.34 265.84,58.34
GND on TOP (solid shape): 292.68,32.95 292.68,32.4 292.37,32.09 291.22,32.09 291.03,32.28 291.03,32.95 291.18,33.11 292.52,33.11
GND on TOP (solid shape): 304.87,74.9 304.87,73.23 304.75,73.11 302.76,73.11 302.6,73.27 302.6,75.02 304.76,75.02
GND on TOP (solid shape): 308.04,91.43 298.74,91.43 298.74,75.03 308.04,75.03 308.04,74.23 297.94,74.23 297.94,92.23 308.04,92.23
GND on TOP (solid shape): 123.78,105.91 123.78,102.9 123.16,102.27 119.64,102.27 119.22,102.69 119.22,105.53 119.26,105.56 119.26,105.65 120.62,107.01 122.69,107.01
GND on TOP (solid shape): 294.18,61.82 294.67,61.82 294.77,61.72 294.77,59.84 294.07,59.14 292.51,59.14 292.36,59.29 292.36,61.69 292.7,62.03 293.96,62.03
GND on TOP (solid shape): 22.35,84.07 22.35,83.32 21.95,82.92 21.52,82.92 20.96,83.47 20.46,83.47 20.39,83.54 20.39,83.96 20.44,84.01 21.36,84.01 21.77,84.41 22.01,84.41
GND on TOP (solid shape): 115.19,78.16 117.15,78.16 117.22,78.09 117.22,77.45 117.12,77.36 115.13,77.36 114.85,77.07 114.65,77.07 114.48,77.24 114.48,78.39 114.59,78.49 114.86,78.49
GND on TOP (solid shape): 125.46,84.77 125.46,84.52 125.64,84.34 126.56,84.34 126.63,84.27 126.63,83.44 126.54,83.36 124.97,83.36 124.88,83.45 124.88,84.78 125.06,84.96 125.28,84.96
GND on TOP (solid shape): 268.78,28.86 268.78,28.2 268.55,27.97 265.61,27.97 265.41,28.17 265.41,28.67 265.46,28.72 265.91,28.72 266.04,28.59 266.94,28.59 267.33,28.98 268.66,28.98
GND on TOP (solid shape): 304.35,92.87 304.38,92.87 304.54,92.72 304.54,91.43 302.31,91.43 302.28,91.46 302.28,92.73 302.46,92.91 304.31,92.91
GND on TOP (solid shape): 25.15,72.67 28.47,72.67 28.67,72.47 28.67,71.52 28.52,71.37 25.28,71.37 24.33,72.32 23.25,72.32 23.24,72.31 23.11,72.45 23.11,72.77 23.19,72.85 24.97,72.85
GND on TOP (solid shape): 39.22,79.52 39.22,77.63 39.24,77.62 39.24,76.07 38.98,75.81 38.3,75.81 38.2,75.91 38.2,79.75 38.39,79.94 38.8,79.94
GND on TOP (solid shape): 59.52,87.34 59.52,84.73 59.23,84.44 58.71,84.44 58.07,83.8 57.99,83.8 57.51,84.27 57.51,85.02 57.99,85.5 57.99,87.62 58.11,87.74 59.12,87.74
GND on TOP (solid shape): 62.64,113.05 62.64,112.75 62.45,112.56 62.45,112.43 61.83,111.81 54.89,111.81 54.63,111.55 54.15,111.55 53.68,112.02 53.68,113.05 53.76,113.13 62.56,113.13
GND on TOP (solid shape): 140.47,76.3 141.1,76.3 141.15,76.26 141.17,76.26 141.17,75.75 141.1,75.69 140.66,75.69 140.4,75.42 139.35,75.42 139.33,75.45 139.33,76.18 139.75,76.61 140.16,76.61
GND on TOP (solid shape): 90.68,26.75 90.68,26.6 91,26.29 91,25.94 90.92,25.86 90.54,25.86 90.38,26.02 90.09,26.02 90.08,26.03 87.51,26.03 87.45,26.09 87.45,26.73 87.64,26.92 90.52,26.92
GND on TOP (solid shape): 113.99,82.98 118.32,82.98 118.41,82.89 118.41,81.2 118.31,81.1 114.12,81.1 113.91,81.3 113.91,81.97 113.91,82.02 113.25,82.69 113.25,82.94 113.37,83.07 113.9,83.07
GND on TOP (solid shape): 195.08,75.24 195.08,74.8 195.46,74.42 195.9,74.42 196.09,74.23 196.09,73.53 195.34,72.77 195.34,72.77 195.2,72.64 193.55,72.64 193.49,72.7 193.49,75.05 193.74,75.3 195.01,75.3
GND on TOP (solid shape): 267.9,65.7 269.54,65.7 269.73,65.51 269.73,64.55 269.65,64.46 264.18,64.46 264.04,64.6 264.04,65.35 264.22,65.53 266.49,65.53 267.11,66.15 267.46,66.15
GND on TOP (solid shape): 291.41,62.87 291.41,62.39 291.31,62.29 291.31,61.45 291.19,61.33 290.46,61.33 290.26,61.52 290.26,62.49 290.33,62.55 290.79,62.55 290.94,62.7 290.94,62.87 290.99,62.92 291.36,62.92
GND on TOP (solid shape): 97.91,85.91 97.91,85.54 97.79,85.42 94.89,85.42 94.76,85.54 94.76,85.82 94.89,85.94 95.53,85.94 95.77,86.18 95.77,86.96 95.87,87.06 96.76,87.06
GND on TOP (solid shape): 178.63,112.9 178.63,112.13 178.19,111.69 176.22,111.69 175.9,111.37 175.2,111.37 175.08,111.5 175.08,111.88 175.01,111.94 173.74,111.94 173.62,112.07 173.62,113.02 173.68,113.09 178.44,113.09
GND on TOP (solid shape): 179.14,41.27 179.14,40.32 178.95,40.13 177.87,40.13 177.68,40.32 177.68,41.4 176.92,42.16 174,42.16 173.62,41.78 172.98,41.78 172.92,41.84 172.92,42.41 173.49,42.98 177.43,42.98
GND on TOP (solid shape): 194.15,44.94 194.15,40.49 193.89,40.24 192.56,40.24 192.56,40.24 189.88,40.24 189.55,40.57 189.55,41.23 191.31,42.98 191.31,45.01 191.49,45.19 193.89,45.19
GND on TOP (solid shape): 122.5,29.6 122.5,27.24 122.62,27.11 122.94,27.11 123.2,26.85 123.2,24.38 123.13,24.31 121.67,24.31 121.55,24.44 121.55,27.08 121.11,27.51 120.12,27.51 119.96,27.68 119.96,29.84 120.08,29.97 122.13,29.97
GND on TOP (solid shape): 145.42,56.06 145.42,54.54 145.74,54.22 146.31,54.22 146.37,54.16 146.37,53.52 146.31,53.46 143.73,53.46 143.63,53.55 143.63,54.46 143.97,54.8 143.97,56.04 144.13,56.19 145.29,56.19
GND on TOP (solid shape): 186.95,60.22 187.91,60.22 188,60.13 188,59.7 187.93,59.62 187.93,58.9 187.93,58.9 187.93,58.74 187.86,58.68 187.37,58.68 187.23,58.82 187.23,59.13 186.19,60.18 186.19,60.42 186.34,60.57 186.6,60.57
GND on TOP (solid shape): 286.07,90.74 286.07,90.16 285.57,89.66 285.57,89.09 285.45,88.97 285.09,88.97 285.03,89.03 285.03,90.08 284.98,90.13 284.98,90.7 285.15,90.86 285.88,90.86 285.95,90.86
GND on TOP (solid shape): 23.75,88.15 23.75,88.03 23.73,87.95 23.75,87.86 23.75,86.93 23.53,86.71 22.28,86.71 22.14,86.86 22.14,87.97 22.48,88.3 23.59,88.3
GND on TOP (solid shape): 124.09,42.28 126.31,42.28 126.56,42.03 126.56,41.27 126.37,41.08 123.3,41.08 123.24,41.01 122.79,41.01 122.76,41.04 122.76,41.52 122.69,41.59 122.69,42.28 122.75,42.35 123.26,42.35 123.32,42.41 123.32,42.6 123.45,42.73 123.64,42.73
GND on TOP (solid shape): 133.91,86.39 133.91,85.29 133.7,85.07 133.7,84.78 133.6,84.68 133.37,84.68 133.24,84.81 133.24,85.09 133.25,85.09 133.25,85.14 133.51,85.4 133.51,85.5 133.51,85.5 133.51,86.37 133.55,86.42 133.88,86.42
GND on TOP (solid shape): 211.43,35.76 211.43,34.85 211.97,34.31 211.97,33.52 211.84,33.39 211.84,33.33 208.13,33.33 208.05,33.41 208.05,34.43 208.35,34.73 210,34.73 210.28,35.01 210.28,35.42 210.46,35.6 210.46,35.93 210.52,36 211.19,36
GND on TOP (solid shape): 129.6,87.52 129.6,85.45 129.58,85.42 129.44,85.42 129.43,85.43 129.39,85.43 129.32,85.44 129.25,85.43 128.55,85.43 128.51,85.47 128.51,86.42 128.55,86.46 128.91,86.46 129.05,86.6 129.05,87.49 129.2,87.63 129.48,87.63
GND on TOP (solid shape): 178.41,95.85 178.41,95.42 178.06,95.06 178.06,93.24 178.39,92.9 178.39,92.4 178.34,92.35 177.53,92.35 176.78,93.1 176.78,95.6 177.11,95.92 178.34,95.92
GND on TOP (solid shape): 73.03,24.06 74.68,24.06 74.81,24.19 74.81,24.36 75.13,24.68 76.69,24.68 76.69,24.68 77.75,24.68 77.86,24.57 77.86,23.62 77.6,23.36 70.75,23.36 70.55,23.55 70.55,24.38 70.87,24.7 72.4,24.7
GND on TOP (solid shape): 129.67,77.19 129.67,76.97 129.46,76.76 129.46,76.17 129.71,75.92 129.71,74.93 129.66,74.88 128.66,74.88 128.63,74.92 128.63,75.96 128.67,76 128.67,76.51 129,76.84 129.02,76.86 129.02,77.23 129.12,77.33 129.54,77.33
GND on TOP (solid shape): 274.14,66.61 274.14,66.1 274.52,65.72 274.52,65.21 274.58,65.14 276.19,65.14 276.26,65.08 276.26,64.52 276.19,64.45 273.84,64.45 273.79,64.5 273.79,65.35 273.44,65.71 273.44,66.61 273.54,66.7 274.04,66.7
GND on TOP (solid shape): 132.36,86.87 132.36,86.71 132.06,86.42 132.06,85.47 132.04,85.45 131.03,85.45 131,85.47 131,86.4 131.05,86.44 131.17,86.43 131.23,86.44 131.5,86.44 131.63,86.57 131.63,86.81 131.83,87.01 132.22,87.01
GND on TOP (solid shape): 295.54,72.84 295.54,72.6 295.46,72.38 295.54,72.17 295.54,72 295.3,71.76 292.54,71.76 292.48,71.83 292.48,72.32 292.6,72.45 294.38,72.45 294.87,72.94 295.44,72.94
GND on TOP (solid shape): 131.02,84.78 131.02,84.7 131.41,84.31 131.41,83.39 131.22,83.2 131.22,81.1 131.11,80.99 130.28,80.99 130.25,81.02 130.25,82.59 130.12,82.73 129.87,82.73 129.84,82.77 129.84,83.28 129.75,83.37 129.75,84.31 129.78,84.34 130.36,84.34 130.47,84.46 130.47,84.85 130.64,85.02 130.77,85.02
GND on TOP (solid shape): 110.58,45.45 110.58,40.37 110.45,40.24 109.81,40.24 109.28,39.7 108.83,39.7 108.79,39.75 108.79,40.1 108.98,40.29 108.98,40.82 108.8,41 108.42,41 108.26,40.84 108.26,40.46 108.04,40.24 107.28,40.24 107.02,40.49 107.02,45.57 107.4,45.95 110.07,45.95
GND on TOP (solid shape): 265.66,40.28 267.86,40.28 267.98,40.4 268.49,40.4 268.53,40.36 268.53,39.78 268.77,39.54 268.77,39.24 268.67,39.14 268.06,39.14 267.44,38.52 267.44,37.16 267.3,37.03 265.08,37.03 264.86,37.24 264.86,39.15 265.04,39.32 265.04,40.41 265.07,40.44 265.5,40.44
GND on TOP (solid shape): 99.72,95.69 100.34,95.69 100.53,95.5 100.53,95.05 99.44,93.97 99.42,93.97 99.09,93.95 98.76,93.9 98.64,93.78 98.34,93.78 98.33,93.79 98.16,93.73 97.99,93.66 97.22,93.66 97.03,93.85 97.03,94.48 97.93,95.38 97.93,96.04 98.12,96.24 99.17,96.24
GND on TOP (solid shape): 271.32,61.3 271.32,61.18 272.21,60.29 272.21,59.46 271.8,59.06 271.8,58.08 271.61,57.88 271.61,57.49 271.49,57.37 269.47,57.37 269.27,57.57 269.27,58.06 269.39,58.18 269.51,58.17 269.56,58.18 269.78,58.18 270.02,58.41 270.02,60.22 270.47,60.68 270.47,61.27 270.55,61.36 271.26,61.36
GND on TOP (solid shape): 22.17,81.15 22.17,80.77 22.29,80.64 23.44,80.64 23.5,80.58 23.5,80.13 23.46,80.09 23.46,79.66 23.83,79.29 23.83,78.79 24.08,78.54 24.08,78.32 23.97,78.21 23.9,78.21 23.88,78.19 20.64,78.19 20.58,78.26 20.58,78.67 20.64,78.73 20.83,78.73 21.15,79.05 21.15,79.69 21.53,80.07 21.53,81.21 21.6,81.27 22.04,81.27
GND on TOP (solid shape): 192.54,111.98 192.54,109.06 192.86,108.74 192.86,107.54 192.48,107.16 192.48,106.01 193.3,105.19 193.3,103.94 193.11,103.75 187.51,103.75 187.07,104.19 186.2,104.19 186.14,104.25 186.14,105.18 186.27,105.3 188.13,105.3 188.4,105.57 189.56,105.57 189.86,105.86 191.56,105.86 191.74,106.04 191.74,108.64 192.16,109.07 192.16,110.2 191.73,110.64 191.73,112.02 191.75,112.05 192.48,112.05
GND on TOP (solid shape): 69.35,82.04 69.35,80.26 69.03,79.94 68.52,79.94 68.08,79.5 68.08,76.32 67.89,76.13 60,76.13 59.57,76.56 57.25,76.56 57.09,76.71 57.09,79.43 57.47,79.81 59.44,79.81 59.82,80.19 66.43,80.19 66.55,80.32 67,80.32 67.22,80.54 67.22,81.27 67.13,81.37 67.13,82.1 67.19,82.16 69.22,82.16
GND on TOP (solid shape): 195.41,90.11 195.41,87.15 195.24,86.99 192.8,86.99 192.41,86.6 192.41,84.39 191.4,83.37 191.4,82.42 191.08,82.1 190.44,82.1 190.38,82.16 190.38,83.88 190.15,84.11 190.15,87.6 190.26,87.71 190.82,87.71 191.17,88.07 191.17,88.74 191.4,88.96 194.03,88.96 194.18,89.11 194.18,90.01 194.32,90.14 195.37,90.14
GND on TOP (solid shape): 281.37,33.9 282.14,33.9 282.2,33.84 282.2,33.2 281.95,32.95 280.93,32.95 280.61,32.63 280.61,31.17 280.42,30.98 280.42,30.35 280.23,30.16 279.28,30.16 278.33,31.11 278.23,31.11 277.95,31.4 277.95,31.74 278.07,31.87 279.66,31.87 279.79,32 279.79,32.76 279.6,32.95 279.04,32.95 278.9,33.09 278.9,33.84 279.15,34.09 281.18,34.09
GND on TOP (solid shape): 268.79,34.15 269.46,34.15 269.72,33.89 269.72,32.55 270.57,31.71 270.57,31.03 270.51,30.97 269.57,30.97 269.36,31.19 269.36,31.67 268.4,32.63 264.42,32.63 264,33.05 263.36,33.05 263.19,33.22 263.19,33.82 263.3,33.93 263.83,33.93 263.85,33.95 266.62,33.95 266.62,33.95 267.2,33.95 267.81,34.56 268.38,34.56
GND on TOP (solid shape): 23.2,77.37 23.26,77.37 23.37,77.37 23.46,77.27 23.46,75.09 23.31,74.94 22.92,74.94 22.51,75.35 22.05,75.35 21.87,75.53 21.87,76.82 21.92,76.86 22.97,76.86 23,76.89 23,77 22.98,77.09 22.98,77.2 22.99,77.24 22.99,77.31 23.05,77.37
GND on TOP (solid shape): 222.89,28.76 222.89,27.11 223.06,26.94 223.88,26.94 224.54,26.28 224.54,26.03 224.67,25.9 225.11,25.9 225.3,25.71 225.3,25.2 225.3,25.2 225.3,25.15 224.8,24.65 224.8,24.08 224.52,23.81 218.44,23.81 218.24,24.01 218.24,25.7 218.48,25.94 219.56,25.94 219.69,25.81 219.69,25.8 219.87,25.62 221.24,25.62 221.88,26.26 221.88,28.76 221.94,28.82 222.83,28.82
GND on TOP (solid shape): 134.59,76.48 134.59,76.27 134.58,76.26 134.57,76.17 134.58,76.08 134.59,76.07 134.59,75.95 134.7,75.84 134.7,74.94 134.7,74.93 134.7,74.86 134.68,74.84 133.66,74.84 133.62,74.88 133.62,75.8 133.7,75.87 134,75.87 134.15,76.03 134.15,76.11 134.17,76.19 134.15,76.27 134.15,76.51 134.26,76.61 134.46,76.61
GND on TOP (solid shape): 34.75,25.49 35.63,25.49 35.68,25.44 35.68,21.94 35.62,21.88 35.6,21.88 35.15,21.72 34.86,21.34 34.52,21.34 34.44,21.41 34.44,23.61 34.37,23.68 27.15,23.68 26.94,23.89 26.94,26.03 27.29,26.39 27.31,26.39 27.42,26.43 27.51,26.51 33.73,26.51
GND on TOP (solid shape): 43.88,68.17 43.88,67.16 43.51,66.8 43.33,66.8 42.82,66.29 42.82,66.11 42.58,65.87 42.58,65.86 42.57,65.84 42.47,65.68 42.48,65.49 42.49,65.46 42.43,65.4 41.8,65.4 41.73,65.47 41.73,66.26 41.76,66.27 41.97,66.44 42.05,66.7 42.05,66.89 43.43,68.27 43.78,68.27
GND on TOP (solid shape): 281.56,50.51 281.56,50.21 281.5,50.14 281.31,50.14 280.58,49.41 280.58,49.38 280.26,49.07 280.26,47.98 280.49,47.75 282.13,47.75 282.35,47.53 282.35,47.17 282.3,47.12 281.93,47.12 281.77,46.95 278.46,46.95 278.36,47.06 278.36,47.96 278.36,47.96 278.36,48.61 278.16,48.8 278.16,48.94 277.98,49.12 277.98,49.83 278.02,49.87 278.98,49.87 279.52,50.4 280.88,50.4 281.06,50.58 281.49,50.58
GND on TOP (solid shape): 315.23,109.1 315.94,108.81 316.23,108.1 316.23,106.1 315.22,106.1 314.32,107.05 313.23,107.77 313.23,109.1
GND on TOP (solid shape): 75.76,92.77 77.86,92.77 78.25,93.16 79.19,93.16 79.26,93.09 79.26,92.76 79.44,92.58 79.45,92.57 79.89,92.13 83.25,92.13 83.51,91.88 83.51,89.08 83.39,88.97 82.47,88.97 82.46,88.98 80.38,88.98 80.09,88.69 78.29,88.69 77.32,89.66 73.54,89.66 73.35,89.85 73.35,90.23 73.22,90.35 72.14,90.35 72.12,90.33 72.09,90.33 72.09,90.3 72.02,90.23 72.02,89.66 71.89,89.53 71.13,89.53 71,89.66 71,92.84 71.71,93.55 74.98,93.55
GND on TOP (solid shape): 127.73,87.53 127.73,87.27 127.63,87.17 127.3,87.17 127.18,87.04 127.18,86.91 127.14,86.77 127.18,86.62 127.18,86.57 127.21,86.53 127.21,86.47 127.17,86.43 127.17,85.49 127.14,85.46 126.72,85.46 126.61,85.48 126.5,85.46 126.14,85.46 126.11,85.48 126.11,86.4 126.14,86.43 126.75,86.43 126.89,86.57 126.89,87 126.71,87.18 126.41,87.18 126.31,87.29 126.31,87.56 126.38,87.63 127.63,87.63
GND on TOP (solid shape): 120.4,87.5 120.4,87.17 120.59,86.97 120.59,86.52 120.4,86.33 120.4,85.53 120.32,85.45 119.99,85.45 119.92,85.51 119.92,86.34 119.85,86.41 119.85,86.45 119.89,86.49 119.93,86.47 120.41,86.72 120.01,87.09 119.94,87.09 119.84,87.19 119.84,87.56 119.92,87.65 120.25,87.65
GND on TOP (solid shape): 188.77,100.25 188.77,99.48 188.28,98.98 188.28,98.36 188.62,98.01 191.35,98.01 191.8,97.57 192.76,97.57 192.91,97.72 194.11,97.72 194.33,97.5 194.33,96.65 194.14,96.46 193.27,96.46 193.21,96.53 193.21,96.88 192.82,97.28 191.58,97.28 191.2,96.89 190.18,96.89 190.12,96.96 190.12,97.09 189.93,97.28 188.47,97.28 188.34,97.15 185.23,97.15 184.98,97.4 184.98,99.32 185.35,99.69 188.24,99.84 188.24,100.26 188.29,100.31 188.72,100.31
GND on TOP (solid shape): 124.94,87.54 124.94,87.18 124.9,87.09 124.8,87.08 124.55,87.06 124.39,86.87 124.43,86.57 124.7,86.43 124.75,86.38 124.75,85.49 124.73,85.48 124.65,85.47 124.57,85.45 124.54,85.43 123.74,85.43 123.69,85.48 123.69,86.4 123.73,86.43 124.03,86.43 124.12,86.53 124.12,87.48 124.27,87.63 124.84,87.63
GND on TOP (solid shape): 69.01,113.13 69.09,113.09 69.1,112.99 69.41,112.55 69.72,112.99 69.73,113.09 69.82,113.13 75.06,113.13 75.16,113.02 75.16,111.8 75.07,111.7 68.54,111.7 68.43,111.81 63.85,111.81 63.75,111.91 63.75,113.06 63.82,113.13
GND on TOP (solid shape): 316.48,92.83 316.24,92.27 315.68,92.03 315.23,92.03 314.38,91.68 314.03,90.83 314.03,90.53 313.94,90.32 313.73,90.23 313.53,90.23 313.53,95.39 314.43,95.39 314.43,95.65 316.48,95.65
GND on TOP (solid shape): 141.09,80.83 141.17,80.84 141.62,80.84 141.71,80.75 141.71,80.67 141.79,80.58 141.83,80.56 141.88,80.54 141.95,80.47 141.97,80.43 141.97,80.22 141.85,80.1 141.83,80.09 141.6,80.09 141.34,79.83 141.34,78.87 141.46,78.74 141.97,78.74 142.04,78.66 142.04,78.64 142.14,78.42 142.37,78.32 142.39,78.32 142.62,78.08 142.62,77.69 142.51,77.57 142.3,77.57 141.98,77.89 141.41,77.89 141.31,77.79 141.31,77.06 141.25,77 140.77,77 140.66,77.11 140.66,77.5 140.46,77.7 140.46,79.84 140.74,80.12 140.74,80.71 140.87,80.84 141.01,80.84
GND on TOP (solid shape): 118.56,87.56 118.56,87.14 118.51,87.05 118.4,87.05 117.9,86.77 118.4,86.48 118.51,86.48 118.56,86.39 118.56,85.42 118.53,85.4 118.45,85.4 118.44,85.4 118.3,85.44 118.15,85.4 118.14,85.4 117.54,85.4 117.52,85.41 117.52,86.45 117.67,86.61 117.67,86.93 117.42,87.18 117.16,87.18 117.1,87.24 117.1,87.56 117.19,87.65 117.22,87.64 117.34,87.63 117.46,87.66 117.47,87.66 118.46,87.66
GND on TOP (solid shape): 122.43,87.4 122.44,87.37 122.46,87.32 122.49,87.28 122.53,87.25 122.55,87.23 122.55,86.89 122.52,86.77 122.53,86.71 122.54,86.65 122.37,86.47 122.37,85.45 122.34,85.42 122.06,85.42 122.03,85.43 121.97,85.44 121.91,85.43 121.87,85.42 121.33,85.42 121.28,85.47 121.28,86.57 121.35,86.64 121.35,86.79 121.6,86.79 121.6,86.74 121.61,86.69 121.62,86.64 121.65,86.59 121.68,86.55 121.72,86.51 121.76,86.48 121.8,86.46 121.85,86.44 121.9,86.44 121.96,86.44 122.01,86.44 122.06,86.46 122.1,86.48 122.15,86.51 122.18,86.55 122.21,86.59 122.24,86.64 122.25,86.69 122.26,86.74 122.26,86.79 122.25,86.84 122.24,86.89 122.21,86.94 122.18,86.98 122.15,87.02 122.1,87.05 122.06,87.07 122.01,87.09 121.96,87.1 121.9,87.1 121.85,87.09 121.8,87.07 121.76,87.05 121.72,87.02 121.68,86.98 121.65,86.94 121.62,86.89 121.61,86.84 121.6,86.79 121.35,86.79 121.35,87 121.18,87.18 120.92,87.18 120.79,87.3 120.79,87.53 120.9,87.63 122.19,87.63
GND on TOP (solid shape): 55.54,74.37 55.54,73.57 55.41,73.44 55.39,73.44 55,73.21 55.21,72.81 55.24,72.8 55.24,71.72 54.87,71.35 54.87,67.57 54.84,67.55 54.82,67.53 54.75,67.5 54.68,67.53 54.13,67.28 54.68,67.03 54.75,67.06 54.82,67.03 54.84,67.01 54.87,66.99 54.87,64.45 54.06,63.64 51.71,63.64 51.25,64.11 51.25,74.18 51.79,74.73 55.19,74.73
GND on TOP (solid shape): 83.91,86.05 83.91,85 84.13,84.79 84.13,82.08 84.03,81.99 83.78,81.99 83.54,81.75 83.54,81.2 83.36,81.02 82.47,81.02 82.18,80.73 82.18,76.67 82.05,76.55 82.05,75.94 82.37,75.62 82.37,74.33 83.26,73.43 83.26,72.32 83.16,72.22 80.38,72.22 79.06,70.9 79.06,68.32 78.49,67.75 76.4,67.75 75.83,68.32 75.83,72 76.19,72.36 76.19,73.82 76.71,74.35 76.71,75.56 77.1,75.94 78.32,75.94 78.47,75.78 78.47,74.75 78.74,74.49 79.45,74.49 79.57,74.47 79.68,74.48 79.69,74.49 79.75,74.49 80.02,74.75 80.02,76.79 78.99,77.81 78.29,77.81 78.11,78 78.11,78.88 78.27,79.04 79.07,79.04 79.08,79.05 79.1,79.05 79.36,79.31 79.36,79.33 79.38,79.35 79.38,81.78 78.67,82.49 78.67,83.7 77.79,84.58 77.79,85.33 77.85,85.39 77.92,85.41 77.99,85.45 78.12,85.45 78.62,85.45 78.68,85.45 79.2,85.45 79.21,85.45 79.26,85.45 79.33,85.41 79.4,85.39 79.52,85.27 81.03,85.27 81.22,85.46 83.31,85.46 83.39,85.54 83.39,86.05 83.44,86.11 83.86,86.11
GND on TOP (solid shape): 200.98,91.44 199.59,91.21 197.98,88.96 200.23,87.36 201.63,87.59 201.68,87.28 201.76,86.81 200.37,86.57 197.2,88.83 199.46,91.99 200.85,92.23
GND on TOP (solid shape): outline of 135 points within 83.83,24.02 89.69,30.89
GND on TOP (solid shape): 259.33,63.93 260.2,60.15 256.41,59.27 255.2,60.03 255.47,60.38 255.59,60.54 255.68,60.67 256.84,59.95 259.53,60.57 258.91,63.26 257.75,63.98 258.12,64.69
GND on TOP (solid shape): outline of 91 points within 39.75,19.84 55.63,31.37
GND on TOP (solid shape): 185.81,112.54 185.81,110.81 185.35,110.34 185.27,110.29 185.21,110.21 185.09,110.09 184.33,110.85 184.12,110.85 183.56,110.7 184.11,110.5 184.12,110.52 184.19,110.52 184.69,110.02 184.71,109.91 184.62,109.84 182.34,109.84 181.94,109.45 181.94,106.9 180.87,105.82 175.9,105.82 175.16,105.09 175.16,104.24 175.01,104.08 174.06,104.08 173.91,104.23 173.91,106.21 173.91,106.24 173.64,106.51 173.61,106.51 173.59,106.52 171.63,106.52 171.28,106.88 171.28,109.34 171.2,109.42 171.2,111.22 171.45,111.48 172.4,111.48 172.4,111.45 173.38,110.47 174.43,110.47 174.74,110.77 174.85,110.79 174.91,110.7 174.91,109.68 175.22,109.37 179.04,109.37 179.13,109.35 179.21,109.37 179.31,109.37 179.69,109.74 179.69,111.16 179.37,111.48 176.24,111.48 176.11,111.35 175.1,111.35 175.07,111.32 175.02,111.31 174.99,111.36 174.99,111.41 174.99,111.42 174.69,111.89 174.4,111.42 174.4,111.41 174.4,111.27 174.19,111.06 173.62,111.06 173.04,111.63 173.34,111.93 173.34,112.87 173.56,113.09 185.26,113.09
GND on TOP (solid shape): 184.08,29.44 184.08,28.51 184.22,28.38 184.47,28.38 184.54,28.31 184.54,26.69 185.56,25.67 185.52,25.64 185.45,25.28 185.74,25.07 185.81,25.04 185.84,24.97 185.84,24.07 185.52,23.75 181.76,23.75 181.58,23.93 181.58,24.95 181.59,24.96 181.39,25.4 180.96,25.18 180.96,25.18 180.56,25.18 180.45,25.2 180.35,25.18 178.08,25.18 177.92,25.22 177.76,25.18 177.54,25.18 177.39,25.24 177.23,25.23 177.16,25.23 177.1,25.28 177.04,25.36 176.95,25.42 176.95,26.01 177.07,26.12 178.57,26.12 179.08,26.63 180.84,26.63 180.98,26.49 180.98,26.31 181.16,26.12 182.31,26.12 182.49,25.95 182.49,25.53 182.45,25.51 182.3,25 182.84,25.01 182.91,25.05 183,25.01 183.14,24.9 183.33,24.88 183.35,24.88 183.52,24.72 183.52,24.69 184.04,24.43 183.78,24.95 183.75,24.95 183.59,25.12 183.6,25.21 183.78,25.39 183.78,26.47 183.58,26.66 182.82,26.66 182.76,26.73 182.76,28.25 182.89,28.38 183.62,28.38 183.74,28.5 183.74,29.45 183.83,29.55 183.98,29.55
GND on TOP (solid shape): outline of 190 points within 9.95,24.15 18.32,32.24
GND on TOP (solid shape): 17.85,35.68 17.85,34.09 17.82,34.07 14.46,34.07 14.17,33.78 13.5,33.78 13.47,33.8 12.85,33.89 12.37,34.29 8.58,34.29 8.58,34.28 8.45,34.16 8.45,18.82 8.71,18.56 10.24,17.63 10.84,15.95 10.84,15.05 10.94,14.81 11.18,14.71 12.98,14.71 13.22,14.81 13.32,15.05 13.32,18.75 13.73,19.64 14.68,19.89 14.68,19.42 14.06,19.31 13.78,18.75 13.78,15.05 13.54,14.49 12.98,14.25 11.18,14.25 10.62,14.49 10.38,15.05 10.38,15.95 9.74,17.51 8.18,18.15 2.4,18.15 2.1,18.21 1.84,18.39 1.22,19.01 1.04,19.27 0.98,19.57 0.98,31.65 1.07,31.86 1.28,31.95 2.23,31.95 3.08,32.3 3.43,33.15 3.43,34.45 3.52,34.66 3.73,34.75 12.65,34.75 13.42,34.25 14.02,34.95 14.02,36.21 17.32,36.21
GND on TOP (solid shape): 303.44,76.43 304.04,75.73 304.81,76.23 313.73,76.23 313.94,76.14 314.03,75.93 314.03,74.63 314.38,73.78 315.23,73.43 315.73,73.43 315.94,73.34 316.03,73.13 316.03,67.78 316.32,67 317.23,66.5 317.3,66.3 317.3,52.21 317.21,52.01 317,51.92 316.75,51.92 315.9,51.57 315.55,50.71 315.55,49.55 315.46,49.34 315.25,49.25 315.23,49.25 314.38,48.9 314.03,48.05 314.03,47.75 313.89,47.75 313.89,47.75 311.92,47.75 310.84,48.83 310.84,52.44 311.41,53.02 314.08,53.02 314.9,52.19 315.99,52.19 316.36,52.33 316.75,52.38 316.84,52.38 316.84,64.57 316.71,64.7 315.91,64.7 315.6,65.01 315.6,65.53 315.85,65.78 316.78,65.78 316.84,65.84 316.84,66.17 315.93,66.76 315.57,67.78 315.57,72.97 315.23,72.97 314.06,73.46 313.57,74.63 313.57,75.77 311.22,75.77 311.09,75.64 311.09,75.18 310.78,74.86 309.44,74.86 309,75.3 309,75.71 308.93,75.77 305.09,75.77 304.28,75.28 303.37,75.56 300.49,75.56 299.6,76.45 299.6,77.72 299.85,77.97 303.44,77.97
GND on TOP (solid shape): outline of 82 points within 0.2,47.03 17.85,82.33
GND on TOP (solid shape): outline of 293 points within 261.13,95.83 303.74,113.65
GND on TOP (solid shape): outline of 361 points within 101.8,97.91 117.42,109.26
GND on TOP (solid shape): outline of 761 points within 12.03,51.26 22.8,60.28
GND on TOP (solid shape): outline of 365 points within 118.9,72.36 138.74,87
GND on TOP (solid shape): outline of 170 points within 34.37,0.2 316.48,31.61
GND on TOP (solid shape): outline of 182 points within 34.37,0.2 316.48,31.61
GND on TOP (solid shape): outline of 285 points within 0.2,48.96 316.48,114.1
GND on BOTTOM (solid shape): 29.03,84.65 25.84,84.65 25.84,85.85 29.03,85.85
GND on BOTTOM (solid shape): 37.33,71.11 36.13,71.11 36.13,81.91 37.33,81.91
GND on BOTTOM (solid shape): 16.34,31.87 16.2,31.74 12.67,31.74 12.56,31.85 12.56,33.55 16.34,33.55
GND on BOTTOM (solid shape): 19.52,40.57 18.72,40.57 18.72,49.95 17.52,49.95 17.52,50.75 19.52,50.75
GND on BOTTOM (solid shape): 298.74,75.03 299.94,75.03 299.94,74.23 297.94,74.23 297.94,84.4 298.74,84.4
GND on BOTTOM (solid shape): 300.1,88.06 300.1,86.19 299.96,86.05 297.96,86.05 297.96,88.24 299.92,88.24
GND on BOTTOM (solid shape): 304.54,92.72 304.54,91.45 302.25,91.45 302.25,92.73 302.44,92.93 304.33,92.93
GND on BOTTOM (solid shape): 19.5,36.19 17.93,36.19 17.71,36.42 17.71,38.21 17.87,38.37 19.5,38.37
GND on BOTTOM (solid shape): 17.74,63.7 22.73,63.7 22.73,70.16 23.33,70.16 23.33,63.09 17.11,63.09 17.11,70.17 17.74,70.17
GND on BOTTOM (solid shape): 19.52,32.75 9.42,32.75 9.42,33.55 18.72,33.55 18.72,49.95 9.42,49.95 9.42,50.75 19.52,50.75
GND on BOTTOM (solid shape): 48.04,27.17 48.04,25.48 48,25.44 46.95,25.44 46.9,25.49 46.9,27.1 47.24,27.44 47.77,27.44
GND on BOTTOM (solid shape): 106.35,110.88 106.35,108.84 106.04,108.53 103.22,108.53 102.42,109.33 102.42,110.88 102.62,111.07 106.17,111.07
GND on BOTTOM (solid shape): 306.03,69.45 306.03,67.62 305.83,67.42 300.81,67.42 300.66,67.56 300.66,69.69 300.81,69.83 305.65,69.83
GND on BOTTOM (solid shape): 34.61,68.03 34.61,63.48 34.48,63.35 33.38,63.35 33.26,63.47 33.26,68.21 33.33,68.28 34.36,68.28
GND on BOTTOM (solid shape): 175.08,105.48 175.08,104.26 174.89,104.07 174.12,104.07 173.93,104.26 173.93,105.46 174.06,105.59 174.97,105.59
GND on BOTTOM (solid shape): 102.52,85.64 102.52,82.99 102.32,82.8 99.64,82.8 99.48,82.96 99.48,85.71 99.82,86.05 102.11,86.05
GND on BOTTOM (solid shape): 304.87,74.9 304.87,73.23 304.75,73.11 302.76,73.11 302.6,73.27 302.6,75.02 304.76,75.02
GND on BOTTOM (solid shape): 308.04,91.43 298.74,91.43 298.74,75.03 308.04,75.03 308.04,74.23 297.94,74.23 297.94,92.23 308.04,92.23
GND on BOTTOM (solid shape): 15.57,51.56 15.57,50.04 15.51,49.98 13.07,49.98 12.97,50.09 12.97,51.57 13.13,51.73 13.2,51.73 13.2,51.73 15.39,51.73
GND on BOTTOM (solid shape): 125.47,109.94 125.47,104.03 123.85,102.41 120.34,102.41 119.11,103.65 119.11,105.25 119.89,106.04 119.89,107.81 122.11,110.02 125.39,110.02
GND on BOTTOM (solid shape): 16.58,25.88 16.58,21.96 16.52,21.9 14.93,21.9 14.36,22.47 14.36,25.84 14.6,26.08 16.38,26.08
GND on BOTTOM (solid shape): 37.33,48.45 22.01,48.45 22.01,60.77 16.51,60.77 16.51,61.97 23.21,61.97 23.21,49.65 36.13,49.65 36.13,66.63 37.33,66.63
GND on BOTTOM (solid shape): 145.62,79.88 145.83,79.67 145.83,79.32 145.75,79.25 145.65,79.25 145.61,79.2 145.39,79.42 145.39,79.63 145.17,79.85 145.17,80.81 145.25,80.89 145.62,80.89
GND on BOTTOM (solid shape): 195.89,77.86 195.89,74.03 195.86,74.01 194.99,74.01 194.91,74.09 194.91,74.89 194.43,75.38 191.72,75.38 191.47,75.63 191.47,76.63 192.79,77.95 195.79,77.95
GND on BOTTOM (solid shape): 214.34,33.48 214.34,33.13 214.22,33.01 212.07,33.01 211.74,33.33 206.31,33.33 206.2,33.44 206.2,34.42 206.51,34.73 210.13,34.73 210.37,34.97 212.86,34.97
GND on BOTTOM (solid shape): 28.71,31.55 28.71,29.84 28.16,29.29 25.89,29.29 25.22,29.97 22.36,29.97 22.26,30.06 22.26,31.12 22.38,31.24 25.03,31.24 25.47,31.68 28.58,31.68
GND on BOTTOM (solid shape): 141.06,110.12 141.06,103.67 139.39,102.01 139.38,102.01 138.75,101.37 137.34,101.37 135.83,102.88 135.83,110.29 136.15,110.6 140.58,110.6
GND on BOTTOM (solid shape): 154.06,95.63 154.06,95.22 150.75,91.92 150.75,91.38 150.66,91.35 150.65,91.37 150.65,92.26 153.65,95.27 153.65,95.65 153.74,95.74 153.95,95.74
GND on BOTTOM (solid shape): 18.7,81.08 18.7,80.84 18.56,80.7 18.56,80.52 18.56,80.52 18.56,79.7 18.48,79.62 17.98,79.62 17.85,79.75 17.85,81.08 18.04,81.27 18.51,81.27
GND on BOTTOM (solid shape): 35.12,39.43 35.12,38.67 35.95,35.87 35.76,35.49 33.92,35.05 33.53,35.24 33.09,37.01 32.87,37.23 30.76,37.23 30.63,37.37 30.63,40.97 30.8,41.14 33.41,41.14
GND on BOTTOM (solid shape): 59.06,87.6 59.06,87.24 57.83,86.01 55.04,86.01 54.6,86.46 54.6,87.21 54.76,87.37 57.67,87.37 58.04,87.75 58.92,87.75
GND on BOTTOM (solid shape): 54.57,59.43 54.57,59.05 54.49,58.97 54.11,58.97 53.97,58.84 53.97,57.87 53.9,57.8 53.52,57.8 53.06,58.25 52.66,58.25 52.59,58.32 52.59,59.35 52.72,59.48 54.52,59.48
GND on BOTTOM (solid shape): 180.68,107.05 180.68,105.75 180.08,105.15 178.38,105.15 178.19,105.34 178.19,105.78 178.38,105.98 179.33,105.98 179.52,106.17 179.52,107.05 179.65,107.18 180.54,107.18
GND on BOTTOM (solid shape): 48.32,75.63 48.32,75.62 48.81,75.13 48.81,71.59 48.59,71.37 45.89,71.37 45.35,71.91 45.35,72.68 46.39,73.72 46.39,75.46 46.55,75.62 47.43,75.62 47.67,75.86 48.08,75.86
GND on BOTTOM (solid shape): 97.86,85.95 97.86,82.91 97.75,82.8 94.87,82.8 94.77,82.9 94.77,85.81 94.91,85.95 95.29,85.95 95.58,86.23 95.58,86.93 95.73,87.08 96.73,87.08
GND on BOTTOM (solid shape): 100.53,95.37 100.53,94.29 102.11,92.7 102.11,89.02 101.1,88 97.8,88 96.91,88.89 96.91,93.26 97,93.35 97,94.82 97.11,94.93 98.94,94.93 99.19,95.17 99.19,95.45 99.34,95.6 100.3,95.6
GND on BOTTOM (solid shape): 16.71,95.18 16.71,94.74 15.88,93.91 14.1,93.91 13.79,94.23 12.2,94.23 11.82,93.85 11.56,93.85 11.37,94.04 11.37,94.67 11.56,94.86 12.07,94.86 12.45,95.24 16.64,95.24
GND on BOTTOM (solid shape): 110.14,69.12 110.01,68.99 109.57,68.99 109.41,68.83 109.39,68.82 109.07,68.82 108.85,68.59 108.69,68.59 108.69,69.21 109.59,69.21 109.69,69.32 110.14,69.32
GND on BOTTOM (solid shape): 176.26,72.6 176.26,71.66 176.09,71.49 175.49,71.49 175.31,71.55 175.14,71.49 173.21,71.49 173.08,71.62 173.08,71.82 172.92,71.98 172.92,72.57 173.17,72.83 176.03,72.83
GND on BOTTOM (solid shape): 75.6,69.65 75.64,69.6 75.64,68.11 75.63,68.1 74.53,68.1 74.52,68.1 74.52,69.35 74.45,69.42 73.46,69.42 73.21,69.17 72.99,69.17 72.85,69.03 72.23,69.03 72.13,69.13 72.13,69.64 72.26,69.77 75.48,69.77
GND on BOTTOM (solid shape): 194.51,88.64 194.51,87.12 194.38,86.99 192.6,86.99 192.41,86.8 192.41,84.39 191.97,83.94 190.25,83.94 190.13,84.07 190.13,87.56 190.19,87.62 191.14,87.62 191.33,87.81 191.33,88.64 191.65,88.96 194.19,88.96
GND on BOTTOM (solid shape): 78,78.78 79.11,78.78 79.11,78.78 79.11,77.37 79.1,77.36 78,77.36 77.99,77.37 77.99,78.41 77.67,78.73 76.84,78.73 76.65,78.54 76.45,78.54 76.29,78.38 75.69,78.38 75.65,78.43 75.65,78.97 75.73,79.05 77.73,79.05
GND on BOTTOM (solid shape): 188.28,99.44 188.28,98.67 188.6,98.36 192.09,98.36 192.72,97.72 193.3,97.72 193.36,97.66 193.36,97.28 193.24,97.15 185.23,97.15 185.04,97.34 185.04,99.53 185.2,99.69 188.03,99.69
GND on BOTTOM (solid shape): 221.88,25.99 221.88,24.48 221.7,24.3 218.41,24.3 218.16,24.56 218.16,25.42 218,25.57 217.39,25.57 217.19,25.38 217.19,24.68 217.02,24.5 215.32,24.5 215.15,24.67 215.15,25.91 215.37,26.13 218.23,26.13 218.4,25.96 219.47,25.96 219.72,26.21 221.65,26.21
GND on BOTTOM (solid shape): 79.15,89.49 79.15,88.37 79.15,88.37 78.09,88.37 77.83,88.11 77.83,87.38 77.86,87.35 77.86,86.81 77.66,86.61 77.66,86.1 77.6,86.04 77.04,86.04 76.99,86.09 76.99,86.65 77.35,87 77.35,87.19 77.46,87.31 77.46,88.15 77.72,88.41 77.72,89.48 77.73,89.49 79.15,89.49
GND on BOTTOM (solid shape): 152.49,68.69 153.54,68.69 153.66,68.55 153.7,68.5 153.7,68.01 153.41,67.71 153.16,67.71 152.52,68.36 152.23,68.36 152.19,68.35 152.05,68.49 152.05,68.59 152.15,68.7 152.17,68.71 152.48,68.71
GND on BOTTOM (solid shape): 137.21,76.99 137.21,76.99 137.21,76.72 137.35,76.58 137.35,76.31 137.32,76.24 137.26,76.18 137.26,75.64 137.17,75.56 137.02,75.56 136.94,75.64 136.94,76.12 136.88,76.18 136.88,76.19 136.87,76.26 136.83,76.32 136.83,76.51 136.39,76.96 136.39,77.31 137.21,77.31
GND on BOTTOM (solid shape): 75.11,112.42 75.11,111.06 75.04,111 74.59,111 73.8,111.78 69.93,111.78 69.58,112.14 69.58,112.59 69.72,112.77 69.72,112.99 69.73,113.09 69.82,113.13 74.4,113.13
GND on BOTTOM (solid shape): 300.18,34.02 300.18,32.51 301.08,31.6 305.58,31.6 306.66,30.52 306.66,23.43 306.11,22.88 304.13,22.88 303.49,23.53 303.49,25.67 304.52,25.67 304.52,28.67 303.22,28.67 303.22,28.65 303.16,28.63 302.81,28.98 301.71,28.98 301.28,29.4 301.25,29.44 301.22,29.46 298.74,31.94 297.93,31.94 297.67,32.2 297.67,33.27 298.94,34.54 299.66,34.54
GND on BOTTOM (solid shape): 152.51,84.13 152.56,84.12 152.61,84.11 152.67,84.11 152.94,83.84 153.46,83.84 153.68,83.72 153.73,83.63 153.68,83.54 153.56,83.48 152.35,83.48 152.26,83.39 151.93,83.39 151.82,83.5 151.82,83.56 151.84,83.68 151.83,83.79 152.17,84.13
GND on BOTTOM (solid shape): 55.1,74.67 55.52,74.67 55.59,74.59 55.59,73.46 55.59,73.46 55.59,72.04 55.15,71.6 54.12,71.6 53.92,71.4 53.92,67.55 53.71,67.35 53,67.35 52.72,67.07 52.72,66.32 52.87,66.17 52.87,64.08 52.79,64 52.48,64 52.2,64.28 51.25,64.28 51.19,64.35 51.19,70.66 51.56,71.03 51.74,71.03 52.26,71.55 52.26,71.56 52.3,71.6 52.3,73.56 53.41,74.67 55.09,74.67
GND on BOTTOM (solid shape): 55.23,98.12 55.47,98.12 55.77,97.82 55.77,97.57 55.98,97.36 56.43,97.36 56.65,97.13 56.65,96.22 56.5,96.07 55.8,96.07 55.6,96.27 55.12,96.27 55.06,96.33 55.06,97.35 54.78,97.63 54.78,97.65 54.75,97.78 54.68,97.89 54.68,98.11 54.8,98.22 54.88,98.21 54.97,98.23 55.12,98.23
GND on BOTTOM (solid shape): 192.61,110.84 192.61,105.89 194.06,104.44 195.1,104.44 195.22,104.32 195.22,102.15 195.17,102.1 192.7,102.1 192.61,102.19 192.61,103.33 192.2,103.75 187.43,103.75 187.02,104.16 186.16,104.16 185.94,104.38 185.94,105.33 185.81,105.47 185.49,105.47 185.3,105.66 185.3,106.48 185.36,106.55 186.79,106.55 186.93,106.41 186.93,105.38 187.08,105.23 188.96,105.23 189.24,105.51 190.32,105.51 190.39,105.57 191.08,105.57 191.4,105.89 191.4,109.95 191.66,110.2 191.66,111.03 191.91,111.28 192.16,111.28
GND on BOTTOM (solid shape): 289.88,80.73 289.87,80.69 289.84,80.68 289.53,80.35 289.84,80.02 289.87,80 289.88,79.97 289.88,78.72 288.97,78.72 288.97,81.13 289.6,81.76 289.6,83.01 289.88,83.01
GND on BOTTOM (solid shape): 178.63,112.9 178.63,112.13 178.19,111.69 176.22,111.69 175.9,111.37 174.97,111.37 174.69,111.89 174.42,111.37 173.81,111.37 173.62,111.56 173.62,113.02 173.68,113.09 178.44,113.09
GND on BOTTOM (solid shape): 96.74,38.23 96.78,38.2 96.78,37.89 97.62,37.05 97.81,37.05 98.04,36.9 98.3,36.98 98.41,36.99 98.47,36.9 98.47,36.03 98.41,35.94 98.3,35.96 98.18,36.02 98.04,36.03 98.02,36.03 96.63,37.41 96.63,38.2 96.67,38.23 96.7,38.26
GND on BOTTOM (solid shape): 95.4,33.57 95.46,33.66 95.57,33.65 95.68,33.6 95.82,33.59 95.84,33.59 97.03,32.4 97.03,32.07 96.99,32.04 96.96,32.01 96.82,32.09 96.67,32.11 96.65,32.11 96.19,32.57 96.05,32.57 95.83,32.72 95.57,32.65 95.46,32.64 95.4,32.73
GND on BOTTOM (solid shape): 145.99,82.65 146.06,82.58 146.13,82.53 146.19,82.45 146.16,82.36 145.72,81.93 145.27,81.93 145.13,81.78 145.11,81.77 144.88,81.77 144.78,81.87 144.76,81.88 144.61,81.88 144.53,81.96 144.53,82.26 144.49,82.29 144.49,82.49 144.51,82.51 144.53,82.51 144.56,82.53 144.67,82.58 144.77,82.53 144.8,82.51 144.89,82.51 144.89,82.5 144.99,82.49 145.09,82.5 145.09,82.51 145.15,82.51 145.24,82.59 145.29,82.65
GND on BOTTOM (solid shape): 44.33,93.4 46.55,93.4 46.87,93.08 46.87,92.73 47.24,92.37 48.51,92.37 48.65,92.23 48.65,90.61 48.11,90.07 42.58,90.07 41.19,91.46 42.28,91.46 42.28,91.41 42.29,91.36 42.31,91.31 42.33,91.26 42.36,91.22 42.4,91.18 42.44,91.15 42.49,91.13 42.54,91.11 42.59,91.1 42.64,91.1 42.69,91.11 42.74,91.13 42.79,91.15 42.83,91.18 42.87,91.22 42.9,91.26 42.92,91.31 42.94,91.36 42.95,91.41 42.95,91.46 42.94,91.51 42.92,91.56 42.9,91.61 42.87,91.65 42.83,91.69 42.79,91.72 42.74,91.74 42.69,91.76 42.64,91.76 42.59,91.76 42.54,91.76 42.49,91.74 42.44,91.72 42.4,91.69 42.36,91.65 42.33,91.61 42.31,91.56 42.29,91.51 42.28,91.46 41.19,91.46 40.87,91.78 40.49,91.78 40.27,92.01 40.27,93.59 40.56,93.89 43.84,93.89
GND on BOTTOM (solid shape): 51.22,25.35 50.96,24.83 50.88,24.25 50.88,22.34 50.51,22.23 50.19,22 49.11,20.91 48.82,20.63 48.28,20.09 48.02,19.71 47.93,19.26 47.93,16.66 47.84,16.57 47.14,16.57 47.04,16.67 47.04,20.23 46.38,20.89 45.95,20.89 45.7,21.15 45.7,21.52 45.31,21.9 45.31,22.9 45.62,23.2 46.57,23.2 46.63,23.14 46.63,21.68 46.85,21.46 48.43,21.46 49.92,22.95 49.92,25.05 50.22,25.35
GND on BOTTOM (solid shape): 110.3,91.62 110.3,91.4 110.44,91.25 110.44,90.98 110.46,90.96 110.48,90.86 110.39,90.79 110.22,90.72 110.15,90.55 110.15,90.53 110.06,90.44 110.04,90.45 109.7,90.35 109.55,90.03 109.51,90 109.45,89.95 109.45,89.73 109.47,89.71 109.48,89.5 109.31,89.41 109.3,89.41 108.84,89.41 108.69,89.56 108.69,90.73 109.75,91.79 110.13,91.79
GND on BOTTOM (solid shape): 23.31,45.02 24.84,45.02 26.44,43.41 27.03,43.41 27.23,43.21 27.23,42.74 27.05,42.56 26.41,42.56 26.16,42.81 24.56,42.81 24.16,42.41 21.52,42.41 21.3,42.64 20.29,42.64 20.09,42.84 20.09,44.43 20.97,44.43 20.97,44.38 20.98,44.33 21,44.28 21.02,44.23 21.05,44.19 21.09,44.15 21.13,44.12 21.18,44.1 21.23,44.08 21.28,44.08 21.33,44.08 21.38,44.08 21.43,44.1 21.48,44.12 21.52,44.15 21.56,44.19 21.59,44.23 21.61,44.28 21.63,44.33 21.63,44.38 21.63,44.43 21.63,44.48 21.61,44.53 21.59,44.58 21.56,44.62 21.52,44.66 21.48,44.69 21.43,44.71 21.38,44.73 21.33,44.74 21.28,44.74 21.23,44.73 21.18,44.71 21.13,44.69 21.09,44.66 21.05,44.62 21.02,44.58 21,44.53 20.98,44.48 20.97,44.43 20.09,44.43 20.09,46.06 20.18,46.16 22.17,46.16
GND on BOTTOM (solid shape): 27.01,92.78 27.01,92.55 26.74,92.28 26.74,91.61 28.43,89.92 28.43,89.25 27.58,88.41 26.45,88.41 26.41,88.45 26.41,89.06 25.95,89.53 25.95,89.94 26.41,89.94 26.41,89.88 26.42,89.83 26.43,89.78 26.46,89.74 26.49,89.69 26.52,89.66 26.57,89.63 26.61,89.6 26.66,89.59 26.71,89.58 26.77,89.58 26.82,89.59 26.87,89.6 26.91,89.63 26.95,89.66 26.99,89.69 27.02,89.74 27.05,89.78 27.06,89.83 27.07,89.88 27.07,89.94 27.06,89.99 27.05,90.04 27.02,90.08 26.99,90.13 26.95,90.16 26.91,90.19 26.87,90.22 26.82,90.23 26.77,90.24 26.71,90.24 26.66,90.23 26.61,90.22 26.57,90.19 26.52,90.16 26.49,90.13 26.46,90.08 26.43,90.04 26.42,89.99 26.41,89.94 25.95,89.94 25.95,90.03 25.77,90.2 25.77,90.22 25.59,90.4 25.59,92.23 25.93,92.57 25.93,92.82 26.02,92.91 26.88,92.91
GND on BOTTOM (solid shape): 112.25,90.92 112.26,90.9 112.26,90.82 112.24,90.77 112.23,90.77 112.2,90.66 112.2,90.35 112.26,90.22 112.26,90.21 112.34,90.01 112.34,89.67 112.39,89.62 112.39,89.45 112.34,89.41 112.32,89.4 112.29,89.39 112.1,89.39 112.02,89.56 112,89.62 111.95,89.65 111.92,89.66 111.89,89.68 111.78,89.8 111.78,89.82 111.73,90.01 111.57,90.1 111.51,90.13 111.48,90.2 111.48,90.41 111.48,90.61 111.48,90.7 111.82,91.05 112.12,91.05
GND on BOTTOM (solid shape): 258.36,46.5 258.36,44.72 258.18,44.55 257.87,44.55 257.78,44.61 257.67,44.63 256.43,44.63 256.35,44.62 256.28,44.58 256.24,44.56 256.04,44.76 256.04,45.23 256.23,45.23 256.32,45.15 256.43,45.13 257.67,45.13 257.91,45.28 257.85,45.56 257.82,45.63 257.85,45.7 257.91,45.98 257.67,46.13 256.43,46.13 256.32,46.11 256.23,46.03 256.04,46.03 256.04,46.5 256.32,46.78 258.08,46.78
GND on BOTTOM (solid shape): 152.45,81.6 152.52,81.56 152.61,81.55 152.67,81.55 152.93,81.29 153.26,81.29 153.32,81.26 153.29,81.22 153.27,81.15 153.27,81.08 153.25,80.99 153.17,80.96 152.35,80.96 152.04,80.65 151.98,80.66 151.94,80.65 151.87,80.66 151.82,80.71 151.75,80.83 151.63,80.91 151.58,80.96 151.58,81.03 151.59,81.1 151.58,81.18 151.58,81.25 151.63,81.3 151.72,81.36 151.79,81.44 152.06,81.39 152.3,81.51 152.42,81.63
GND on BOTTOM (solid shape): 155.56,88.28 155.59,88.26 155.64,88.25 157.34,88.25 157.44,88.14 157.44,87.64 157.41,87.54 157.4,87.44 157.41,87.41 157.26,87.27 157.23,87.23 156.92,87.23 156.83,87.27 156.82,87.36 156.74,87.72 156.38,87.81 156.35,87.8 156.1,88.05 155.69,88.05 155.59,88.15 154.93,88.15 154.72,87.93 153.98,87.93 153.91,87.93 153.77,87.98 153.65,87.98 153.6,88.02 153.63,88.08 153.67,88.09 153.74,88.16 153.92,88.23 153.95,88.23 154.09,88.29 155.54,88.29
GND on BOTTOM (solid shape): 146.37,91.86 146.37,89.8 146.74,89.43 146.75,89.4 146.74,89.36 146.69,89.25 146.71,89.12 146.73,89.07 146.41,88.93 146.24,88.86 146.07,88.72 145.99,88.52 145.99,88.51 145.94,88.46 145.92,88.46 145.84,88.45 145.77,88.42 145.4,88.25 145.34,88.32 145.33,88.35 145.34,88.39 145.35,88.39 145.43,88.53 145.45,88.69 145.48,88.77 145.56,88.8 145.75,88.82 145.91,88.92 145.99,88.99 145.99,90.1 145.99,90.1 146.12,90.23 146.12,91.33 145.88,91.56 145.88,91.86 146.02,91.99 146.23,91.99
GND on BOTTOM (solid shape): 276.1,30.46 276.29,30.4 276.48,30.46 276.85,30.46 277.04,30.27 277.04,29.27 276.92,29.01 277.04,28.75 277.04,28.28 276.78,28.01 267.15,28.01 266.9,28.26 266.9,28.84 267.23,29.17 268.3,29.17 268.65,29.52 273.41,29.52 273.42,29.51 273.84,29.51 274.14,29.81 274.23,29.84 274.3,29.78 274.83,29.7 274.75,30.23 274.7,30.3 274.73,30.39 274.8,30.46
GND on BOTTOM (solid shape): outline of 83 points within 261.36,56.06 266.77,59.56
GND on BOTTOM (solid shape): 62.81,113.13 62.89,113.09 62.9,113 63.21,112.55 63.53,113 63.54,113.09 63.62,113.13 69.01,113.13 69.09,113.09 69.1,112.99 69.1,112.77 69.25,112.59 69.25,112 69.16,111.92 68.52,111.92 68.34,111.74 68.34,111.06 68.27,110.99 67.77,110.99 67.72,111.04 67.72,111.79 67.6,111.92 67.35,111.92 67.14,111.71 67.14,111.05 67.07,110.98 66.2,110.98 66.11,111.07 66.11,111.72 65.94,111.89 56.05,111.89 55.86,111.71 55.86,111.03 55.79,110.95 54.1,110.95 53.72,111.33 53.72,113.02 53.83,113.13
GND on BOTTOM (solid shape): 303.47,100.45 298.85,102.45 303.47,104.45 306.15,104.45 306.15,100.45 303.55,100.45
GND on BOTTOM (solid shape): 27.89,82.57 27.89,81.92 27.94,81.91 27.98,81.89 28.06,81.83 28.15,81.81 28.3,81.81 28.73,81.81 28.76,81.79 28.8,81.75 28.93,81.68 29.07,81.65 29.16,81.6 29.16,81.5 29.14,81.47 29.13,81.44 29.11,81.41 29.08,81.4 29.03,81.4 28.99,81.41 28.97,81.44 28.73,81.62 28.48,81.44 28.46,81.41 28.43,81.4 28.38,81.4 28.34,81.41 28.32,81.44 28.08,81.62 27.83,81.44 27.81,81.41 27.78,81.4 27.73,81.4 27.69,81.41 27.67,81.44 27.65,81.49 27.62,81.54 27.59,81.58 27.6,81.64 27.6,82.31 27.61,82.33 27.61,82.65 27.66,82.7 27.75,82.7
GND on BOTTOM (solid shape): 200.98,91.44 199.59,91.21 197.98,88.96 200.23,87.36 201.63,87.59 201.68,87.28 201.76,86.81 200.37,86.57 197.2,88.83 199.46,91.99 200.85,92.23
GND on BOTTOM (solid shape): 139.15,91.98 139.19,91.89 139.19,91.59 139.04,91.44 139.04,91.02 139.08,90.93 139.08,90.75 139.04,90.66 139.04,90.35 139.19,90.01 139.19,89.67 139.31,89.55 139.41,89.35 139.4,89.33 139.37,89.22 139.39,89.12 139.39,89.04 139.33,88.99 139.21,88.9 139.14,88.76 139.13,88.74 139.08,88.7 139.03,88.71 138.99,88.71 138.93,88.73 138.89,88.78 138.78,88.94 138.61,89.02 138.54,89.06 138.53,89.14 138.53,89.26 138.48,89.37 138.45,89.41 138.7,89.65 138.7,89.68 138.75,89.98 138.77,90 138.82,90.3 138.85,90.35 138.85,90.44 138.87,90.58 138.87,90.61 138.87,90.64 138.82,90.8 138.82,90.88 138.86,91.01 138.86,91.44 138.71,91.59 138.71,91.9 138.76,91.98 138.84,91.99 138.95,91.97 139.06,91.99
GND on BOTTOM (solid shape): outline of 114 points within 44.65,62.06 46.82,64.47
GND on BOTTOM (solid shape): outline of 110 points within 292.17,94.55 295.81,96.93
GND on BOTTOM (solid shape): 148.66,92.01 148.7,92.01 148.74,92.01 148.96,91.79 148.96,91.59 148.81,91.44 148.81,91.02 148.84,90.93 148.84,90.75 148.81,90.66 148.81,90.35 148.96,90.01 148.96,89.67 149.01,89.62 149.16,89.33 149.15,89.13 149.34,88.93 149.34,88.85 149.31,88.8 149.3,88.74 149.27,88.71 149.24,88.7 149.2,88.71 149.16,88.71 149.09,88.72 149.05,88.78 148.71,89.02 148.37,88.76 148.37,88.73 148.3,88.71 148.24,88.71 148.17,88.72 148.13,88.78 148.12,88.81 148.1,88.85 148.09,88.93 148.14,88.99 148.25,89.07 148.3,89.2 148.29,89.27 148.27,89.33 148.42,89.62 148.48,89.67 148.48,90.01 148.62,90.35 148.62,90.66 148.59,90.75 148.59,90.93 148.62,91.02 148.62,91.44 148.47,91.59 148.47,91.79 148.63,91.94 148.63,92.02
GND on BOTTOM (solid shape): 50.08,24.25 52.83,27 55.58,24.25 55.58,22.35 54.78,22.35 54.78,24.25 52.83,26.2 50.88,24.25 50.88,22.34 50.51,22.23 50.19,22 50.08,21.89
GND on BOTTOM (solid shape): 275.01,50.06 275.07,50.15 275.19,50.13 276.32,49 276.32,47.79 277.1,47.01 278.1,47.01 278.19,46.95 278.17,46.84 276.77,45.44 274.86,45.44 274.69,45.53 274.5,45.52 274.41,45.53 274.36,45.61 274.36,45.84 275.19,46.66 275.19,46.74 275.28,46.77 275.86,46.94 275.35,47.26 275.24,47.25 275.19,47.34 275.19,48.19 275.41,48.41 275.45,48.38 275.99,48.69 275.37,48.8 275.34,48.8 275.19,48.65 275.07,48.63 275.01,48.72
GND on BOTTOM (solid shape): 110.53,89.21 110.65,89.05 110.65,89.01 110.71,88.9 110.78,88.89 110.89,88.86 110.97,88.79 111.01,88.73 111.14,88.73 111.18,88.76 111.37,88.74 111.39,88.54 111.36,88.51 111.36,88.1 111.39,88.07 111.26,87.83 111.14,88.07 111.16,88.11 111.16,88.23 111.07,88.39 110.88,88.4 110.87,88.39 110.82,88.35 110.78,88.3 110.75,88.28 110.72,88.27 110.69,88.28 110.66,88.28 110.61,88.28 110.59,88.3 110.59,88.41 110.55,88.47 110.51,88.54 110.5,88.61 110.39,88.77 110.21,88.76 110.1,88.7 110.09,88.66 109.82,88.63 110,88.87 110.34,89.08 110.36,89.12
GND on BOTTOM (solid shape): 259.33,63.94 260.21,60.14 256.41,59.27 255.2,60.03 255.47,60.38 255.59,60.54 255.68,60.67 256.84,59.95 259.53,60.57 258.91,63.26 257.75,63.98 258.11,64.7
GND on BOTTOM (solid shape): outline of 89 points within 62.45,88.97 83.57,94.97
GND on BOTTOM (solid shape): outline of 149 points within 288.33,0.2 314.33,19.04
GND on BOTTOM (solid shape): 121.88,90.58 121.92,90.57 121.93,90.53 121.93,90.35 122.08,90.01 122.08,89.66 122.13,89.61 122.13,89.25 122.26,89.12 122.57,88.94 122.8,89.21 122.85,89.29 122.95,89.29 123.09,89.26 123.22,89.29 123.32,89.29 123.37,89.21 123.4,89.1 123.47,89 123.5,88.94 123.48,88.87 123.46,88.82 123.44,88.77 123.42,88.75 123.38,88.74 123.17,88.7 123.04,88.53 123,88.47 122.93,88.45 122.8,88.46 122.67,88.42 122.24,88.21 122.18,88.28 122.15,88.35 122.18,88.43 122.1,88.98 121.59,88.76 121.58,88.74 121.51,88.71 121.45,88.71 121.38,88.72 121.34,88.78 121.33,88.81 121.31,88.84 121.31,88.91 121.35,88.97 121.48,89.16 121.44,89.38 121.41,89.41 121.65,89.66 121.65,90.01 121.8,90.35 121.8,90.53 121.82,90.57 121.86,90.58
GND on BOTTOM (solid shape): outline of 167 points within 274.48,47.72 279.92,53.93
