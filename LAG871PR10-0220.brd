# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS#4: length 67.7
  IN4 w0.094: v1(110.02,64.39) 110.02,64.27 109.31,63.56 109.31,63.25 102.42,56.37 88.09,56.37 73.24,41.52 73.24,40.28 71.43,38.46 71.43,35.86 71.34,35.77 71.2,35.77 71.11,35.86 71.11,36.05 v1(70.81,36.35)
  BOTTOM w0.076: UC1.J35 113.97,69.62 114.02,69.72 114.14,69.76 114.23,69.74 114.28,69.59 114.28,69.43 114.24,69.28 114.24,69.11 114.27,68.92 114.27,68.8 114.24,68.61 114.23,68.61 114.23,67.54 114.38,67.39 114.38,67.04 114.09,66.75 112.07,66.75 110.73,65.42 110.73,64.24 110.66,64.16 110.26,64.16 v1(110.02,64.39)
  BOTTOM w0.104: JDIMM1.53 70.46,38.51 70.57,38.39 70.57,38.08 71.33,37.32 71.33,36.19 71.21,36.07 70.93,36.07 70.81,36.19 v1(70.81,36.35)
DDR_A_DQS#5: length 66.7
  IN4 w0.094: v1(76.45,34.36) 76.62,34.54 77.03,34.54 77.23,34.74 77.23,38.36 79.29,40.42 79.29,41.59 90.19,52.48 103.98,52.48 113.37,61.88 113.37,63.19 113.5,63.31 113.72,63.31 v1(113.94,63.09)
  BOTTOM w0.076: UC1.P34 116.53,70.07 116.67,69.93 116.82,69.9 116.89,69.86 116.91,69.79 116.96,69.62 116.96,69.42 116.92,69.26 116.92,69.12 116.95,68.93 116.95,68.79 116.92,68.6 116.91,68.4 116.91,67.6 117.07,67.45 117.07,67.07 117.07,67 116.59,66.52 114.68,64.61 114.68,63.48 114.52,63.32 114.18,63.32 v1(113.94,63.09)
  BOTTOM w0.104: v1(76.45,34.36) 76.72,34.63 76.82,34.63 76.96,34.5 76.96,33.39 75.84,32.28 75.84,31.93 75.7,31.79 JDIMM1.74
DDR_A_DQS#6: length 49.2
  IN1 w0.094: v1(114.4,35.12) 114.22,35.3 113.74,35.3 113.52,35.52 113.52,37 113.72,37.2 114.23,37.2 114.33,37.29 114.33,37.49 114.23,37.58 113.75,37.58 113.54,37.78 113.54,38.22 113.75,38.42 114.23,38.42 114.33,38.51 114.33,41.5 108.99,46.84 108.99,62.91 109.13,63.05 109.13,66.97 112.41,70.25 112.41,72.49 112.31,72.58 v1(112.04,72.58)
  BOTTOM w0.089: UC1.G30 v1(112.04,72.58)
  BOTTOM w0.104: v1(114.4,35.12) 114.23,35.29 113.88,35.29 113.67,35.5 113.67,35.9 113.75,35.99 113.75,36.99 113.96,37.19 JDIMM1.219
DDR_A_DQS#7: length 49.8
  IN1 w0.094: v1(119.51,35.44) 119.51,35.17 119.61,35.08 120.14,35.08 120.24,35.17 120.24,38.15 120.44,38.35 120.8,38.35 120.97,38.52 120.97,38.72 120.88,38.81 120.48,38.81 120.28,39.02 120.28,39.45 120.48,39.65 120.88,39.65 120.97,39.74 120.97,41.17 112.89,49.25 112.89,61.74 113.25,62.1 113.25,65.91 114.6,67.25 114.6,70.42 115.14,70.96 115.14,72.21 v1(114.77,72.58)
  BOTTOM w0.089: UC1.L30 v1(114.77,72.58)
  BOTTOM w0.104: JDIMM1.240 119.2,31.85 119.25,31.89 119.25,33 118.94,33.31 118.94,34.95 119.15,35.16 119.23,35.16 v1(119.51,35.44)
DDR_A_MA0: length 64.2
  IN4 w0.089: v1(121.08,62.76) 121.52,62.76 121.62,62.65 121.62,58.55 119.42,56.34
  IN4 w0.102: 119.42,56.34 119.42,55.34 108.35,44.27 96.88,44.27 91.21,38.6 91.21,37.91 90.99,37.69 90.99,32.1 91.1,32 91.3,32 91.4,32.1 91.4,33.49 91.5,33.6 91.71,33.6 91.81,33.49 91.81,32.1 91.91,32 93.1,32 93.21,32.1 v1(93.21,32.53)
  BOTTOM w0.076: UC1.AC37 122.12,68.44 122.12,67.67 122.39,67.39 122.39,66.15 121.85,65.61 121.85,64.85 121.51,64.5
  BOTTOM w0.089: 121.51,64.5 121.51,63.19 v1(121.08,62.76)
  BOTTOM w0.15: JDIMM1.144 v1(93.21,32.53)
DDR_A_MA1: length 65.7
  IN4 w0.089: 118.29,56.16 118.29,56.33 120.31,58.35 120.31,62.12 120.4,62.21 120.61,62.21 120.7,62.12 120.7,61.97 120.7,60.94 120.79,60.86 v1(121.08,60.86)
  IN4 w0.102: v1(90.04,36.01) 89.66,36.39 89.66,38.61 89.93,38.89 89.93,39.03 89.58,39.38 89.58,39.53 89.72,39.67 89.86,39.67 90.22,39.32 90.36,39.32 90.51,39.46 90.51,39.6 90.06,40.05 90.06,40.19 90.21,40.34 90.35,40.34 90.79,39.89 90.94,39.89 91.13,40.08 91.13,40.22 90.61,40.74 90.61,41.19 94.78,45.37 107.89,45.37 118.29,55.77 118.29,56.16
  BOTTOM w0.076: 121.83,64.31 122.02,64.49 122.02,65.37 122.61,65.96 122.61,67.4 122.28,67.73 122.28,68.18 122.48,68.38 122.48,68.65 122.21,69.13 UC1.AC36
  BOTTOM w0.089: 121.83,64.31 121.83,64.17
  BOTTOM w0.135: 121.83,64.17 121.83,60.59 121.7,60.46 121.48,60.46 v1(121.08,60.86)
  BOTTOM w0.15: JDIMM1.133 90.45,38.19 90.73,37.92 90.73,36.39 90.35,36.01 v1(90.04,36.01)
DDR_A_MA2: length 65.4
  IN4 w0.089: v1(121.08,62.13) 121.36,62.13 121.45,62.04 121.45,58.63 119.05,56.24
  IN4 w0.102: 119.05,56.24 119.05,55.49 108.2,44.63 96.72,44.63 93.84,41.75 93.7,41.75 93.02,42.42 92.88,42.42 92.73,42.28 92.73,42.14 93.41,41.46 93.41,41.32 93.26,41.17 93.12,41.17 92.45,41.85 92.3,41.85 91.49,41.04 91.49,40.9 92.17,40.22 92.17,40.08 90.84,38.75 90.84,38.06 90.63,37.84 90.63,34.59 90.52,34.49 v1(90.04,34.49)
  BOTTOM w0.076: UC1.AC34 121.95,70.22 121.95,69.09 121.99,68.98 121.99,68.74 121.95,68.63 121.95,67.6 122.09,67.46 122.09,67.46 122.11,67.44 122.11,66.1 121.69,65.67 121.69,64.94 121.25,64.5 121.25,63.43 120.73,62.91 120.73,62.48 v1(121.08,62.13)
  BOTTOM w0.15: JDIMM1.132 90.21,31.96 90.64,32.4 90.64,34.14 90.29,34.49 v1(90.04,34.49)
DDR_A_MA3: length 65.5
  IN4 w0.089: 118.68,56.26 120.53,58.11 120.53,60.13 120.62,60.22 v1(121.08,60.22)
  IN4 w0.102: v1(90.04,37.54) 90.26,37.76 90.26,38 90.47,38.21 90.47,38.91 91.62,40.06 91.62,40.25 90.97,40.9 90.97,41.04 92.88,42.94 93.02,42.94 93.7,42.27 93.84,42.27 93.98,42.42 93.98,42.56 93.31,43.23 93.31,43.38 93.45,43.52 93.6,43.52 94.27,42.85 94.41,42.85 94.56,42.99 94.56,43.13 93.88,43.81 93.88,43.95 94.03,44.09 94.17,44.09 94.85,43.42 94.99,43.42 95.13,43.57 95.13,43.71 94.46,44.38 94.46,44.53 94.62,44.68 94.76,44.68 95.43,44.01 95.58,44.01 95.74,44.17 95.74,44.31 95.34,44.72 95.34,44.86 95.48,45 95.62,45 96.03,44.6 96.17,44.6 96.57,45 108.04,45 118.68,55.64 118.68,56.26
  BOTTOM w0.076: UC1.AC35 122.53,69.52 122.53,68.89 122.64,68.69 122.64,68.31 122.44,68.12 122.44,67.8 122.77,67.47 122.77,65.89 122.18,65.3 122.18,63.99
  BOTTOM w0.135: v1(121.08,60.22) 121.38,59.92 122.01,59.92 122.18,60.1 122.18,63.99
  BOTTOM w0.15: JDIMM1.131 89.96,37.62 v1(90.04,37.54)
DDR_A_MA4: length 64.3
  IN4 w0.089: v1(119.35,61.86) 120.02,61.19 120.02,58.36 117.92,56.26
  IN4 w0.102: v1(90.04,32.97) 90.46,32.97 90.56,32.86 90.56,32.1 90.46,32 89.63,32 89.53,32.1 89.53,35.57 89.21,35.89 89.21,40.35 94.59,45.74 107.74,45.74 117.92,55.92 117.92,56.26
  BOTTOM w0.076: UC1.AA35 121.01,69.74 121.18,69.28 121.18,69.09 121.13,68.98 121.13,68.74 121.18,68.63 121.18,67.6 121.02,67.45 121.02,67 121.19,66.83 121.19,65.28 120.7,64.79 120.7,63.59 120.23,63.11 120.23,62.75 v1(119.35,61.86)
  BOTTOM w0.15: JDIMM1.128 89.21,32.13 v1(90.04,32.97)
DDR_A_MA5: length 66.2
  IN4 w0.089: 116.86,56.94 117.74,57.82 v1(117.74,59.71)
  IN4 w0.102: v1(88.28,32.84) 88.05,32.84 87.95,32.74 87.95,32.35 87.84,32.25 86.75,32.25 86.65,32.35 86.65,32.67 86.75,32.77 87.41,32.77 87.51,32.87 87.51,33.08 87.41,33.18 86.75,33.18 86.65,33.28 86.65,39.62 87.74,40.71 87.74,40.97 93.98,47.21 107.13,47.21 116.86,56.94
  BOTTOM w0.076: UC1.AB35 121.66,69.41 121.83,68.95 121.83,68.77 121.79,68.65 121.79,67.54 121.94,67.38 121.94,67.07 121.94,67.07 121.94,66.57 121.52,66.15 121.52,65.14 121.08,64.7 121.08,63.5
  BOTTOM w0.089: 121.08,63.5 120.56,62.98 120.56,60.89 119.6,59.92 117.95,59.92 v1(117.74,59.71)
  BOTTOM w0.15: JDIMM1.126 88.7,32.41 v1(88.28,32.84)
DDR_A_MA6: length 64.8
  IN4 w0.089: v1(119.37,63.22) 118.9,63.22 118.81,63.13 118.81,61.02 118.1,60.3 118.1,57.66 116.72,56.28
  IN4 w0.102: 116.72,56.28 107.28,46.84 94.14,46.84 88.1,40.81 88.1,39.94 88,39.83 87.38,39.83 87.01,39.47 87.01,33.75 87.12,33.65 87.66,33.65 87.76,33.75 87.76,35.78 87.86,35.89 v1(88.28,35.89)
  BOTTOM w0.076: UC1.AA37 121.01,68.44 121.01,67.67 120.85,67.51 120.85,66.93 121.03,66.76 121.03,65.34 120.49,64.8 120.49,63.74 119.96,63.22 v1(119.37,63.22)
  BOTTOM w0.15: v1(88.28,35.89) 88.96,36.56 JDIMM1.127
DDR_A_MA7: length 65.8
  IN4 w0.089: v1(119.35,61.23) 119.77,60.81 119.77,58.38
  IN4 w0.102: v1(88.28,34.36) 88.55,34.36 88.66,34.25 88.66,32.35 88.76,32.25 89.06,32.25 89.16,32.35 89.16,35.41 88.84,35.73 88.84,40.51 94.44,46.11 107.59,46.11 117.41,55.93 117.41,56.02 119.77,58.38
  BOTTOM w0.076: UC1.AA36 120.91,69.18 120.7,68.74 120.65,68.65 120.65,68.38 120.84,68.18 120.84,67.73 120.69,67.58 120.69,66.86 120.86,66.69 120.86,65.41 119.98,64.52 119.98,63.73 119.85,63.61 119.09,63.61 118.96,63.48 118.96,61.61 v1(119.35,61.23)
  BOTTOM w0.15: JDIMM1.122 87.7,33.79 v1(88.28,34.36)
DDR_A_MA8: length 63.7
  IN4 w0.102: v1(88.28,37.32) 88,37.32 87.89,37.2 87.89,36.67 87.79,36.57 87.48,36.57 87.38,36.67 87.38,37.59 87.64,37.84 88.37,37.84 88.47,37.94 88.47,38.14 88.37,38.25 87.48,38.25 87.38,38.35 87.38,38.55 87.48,38.65 88.37,38.65 88.47,38.75 88.47,38.96 88.37,39.06 87.53,39.06 87.43,39.16 87.43,39.36 87.53,39.47 88.37,39.47 88.47,39.57 88.47,40.66 94.29,46.48 107.43,46.48 117.04,56.08 117.04,56.13 118.75,57.84 118.75,60.32 118.85,60.43 v1(119.34,60.43)
  BOTTOM w0.076: UC1.AB34 121.3,69.9 121.3,69.42 121.34,69.3 121.34,69.07 121.3,68.95 121.3,68.77 121.34,68.65 121.34,67.54 121.18,67.38 121.18,67.07 121.36,66.9 121.36,65.21 120.87,64.72 120.87,63.52 120.39,63.05 120.39,61.73 120.18,61.51
  BOTTOM w0.089: v1(119.34,60.43) 119.46,60.43 120.18,61.14 120.18,61.51
  BOTTOM w0.15: JDIMM1.125 88.45,37.89 88.28,37.72 v1(88.28,37.32)
DDR_A_MA9: length 64.5
  IN4 w0.089: 115.13,56.77 116.83,58.48 116.83,60.9 v1(117.75,61.82)
  IN4 w0.102: v1(85.9,35.65) 85.46,36.09 85.46,39.99 86.11,40.65 86.11,40.91 88.86,43.65 88.86,43.79 88.69,43.96 88.69,44.1 88.83,44.25 88.98,44.25 89.14,44.08 89.29,44.08 89.43,44.22 89.43,44.37 89.01,44.79 89.01,44.93 89.16,45.07 89.3,45.07 89.72,44.65 89.86,44.65 90.01,44.8 90.01,44.94 89.59,45.36 89.59,45.5 89.73,45.65 89.88,45.65 90.29,45.23 90.44,45.23 90.58,45.37 90.58,45.52 90.18,45.92 90.18,46.1 92.4,48.32 106.67,48.32 115.13,56.77
  BOTTOM w0.076: UC1.W36 119.7,69.13 119.7,69.13 119.96,68.65 119.96,68.38 119.76,68.18 119.76,67.73 119.92,67.58 119.92,66.86 119.75,66.69 119.75,66.26 118.57,65.08 118.57,64.47
  BOTTOM w0.089: v1(117.75,61.82) 118.57,62.64 118.57,64.47
  BOTTOM w0.15: v1(85.9,35.65) 87.21,36.96 87.21,37.77 87.45,38.01 JDIMM1.121
DDR_A_MA10: length 63.6
  IN4 w0.089: v1(120.24,71.95) 120.6,71.58 120.6,70.95 123.46,68.09 123.46,67.03 124.04,66.44 124.04,58.15
  IN4 w0.102: v1(95.77,35.44) 95.46,35.44 95.34,35.57 95.34,37.07 97.2,38.94 97.5,38.94 99.55,40.98 109.71,40.98 120.73,52 120.88,52 121.03,51.85 121.18,51.85 121.32,51.99 121.32,52.13 121.16,52.29 121.16,52.44 121.31,52.58 121.45,52.58 121.61,52.42 121.75,52.42 121.9,52.57 121.9,52.71 121.74,52.87 121.74,53.01 121.88,53.15 122.03,53.15 122.18,53 122.33,53 122.47,53.14 122.47,53.28 122.31,53.44 122.31,53.59 122.7,53.98 122.7,55.18 123.71,56.19 123.71,57.81 124.04,58.15
  BOTTOM w0.089: UC1.Y31 v1(120.24,71.95)
  BOTTOM w0.15: v1(95.77,35.44) 95.23,34.9 95.23,32.22 95.71,31.75 JDIMM1.146
DDR_A_MA11: length 62.5
  IN4 w0.089: v1(119.52,64.14) 118.64,63.25 118.64,61.25 117.19,59.8 117.19,57.79 116.29,56.89
  IN4 w0.102: v1(85.9,34.12) 86.28,34.5 86.28,39.77 87.37,40.87 87.37,41.12 93.83,47.58 106.97,47.58 116.29,56.89
  BOTTOM w0.076: UC1.W34 120,69.86 120,68.91 120.12,68.69 120.12,68.31 119.93,68.12 119.93,67.8 120.08,67.64 120.08,66.8 119.91,66.62 119.91,66.19 119.01,65.28 119.01,64.65
  BOTTOM w0.089: 119.01,64.65 v1(119.52,64.14)
  BOTTOM w0.15: v1(85.9,34.12) 87.21,32.81 JDIMM1.120
DDR_A_MA12: length 63.9
  IN4 w0.089: 115.65,56.77 117.01,58.14 117.01,59.88 118.46,61.33 118.46,63.71 v1(119.52,64.77)
  IN4 w0.102: 115.65,56.77 106.82,47.95 93.68,47.95 93.26,47.53 93.12,47.53 92.7,47.95 92.55,47.95 92.41,47.81 92.41,47.66 92.83,47.24 92.83,47.1 92.68,46.96 92.54,46.96 92.12,47.37 91.98,47.37 91.83,47.23 91.83,47.09 92.25,46.67 92.25,46.52 92.11,46.38 91.97,46.38 91.55,46.8 91.4,46.8 91.26,46.66 91.26,46.51 91.68,46.09 91.68,45.95 91.53,45.81 91.39,45.81 90.97,46.22 90.83,46.22 90.68,46.08 90.68,45.94 91.1,45.52 91.1,45.37 86.48,40.75 86.48,40.5 85.9,39.91 v1(85.9,37.17)
  BOTTOM w0.076: v1(119.52,64.77) 119.78,65.03 120.26,65.03 120.7,65.47 120.7,66.62 120.52,66.8 120.52,67.64 120.68,67.8 120.68,68.12 120.48,68.31 120.48,68.69 120.6,68.9 120.6,69.83 UC1.AA34
  BOTTOM w0.15: JDIMM1.119 86.96,38.34 86.46,37.85 86.46,37.74 v1(85.9,37.17)
DDR_A_MA13: length 64.6
  IN4 w0.089: v1(122.06,71.32) 122.06,70.42 125.47,67.01 125.47,60.27
  IN4 w0.102: 125.47,60.27 124.81,59.62 124.81,55.73 123.81,54.73 123.81,52.91 114.71,43.81 114.57,43.81 114.41,43.97 114.26,43.97 114.12,43.83 114.12,43.68 114.28,43.53 114.28,43.38 114.13,43.24 113.99,43.24 113.83,43.4 113.69,43.4 113.54,43.25 113.54,43.11 113.7,42.95 113.7,42.81 113.56,42.66 113.42,42.66 113.26,42.82 113.11,42.82 112.97,42.68 112.97,42.53 113.13,42.38 113.13,42.23 112.98,42.09 112.84,42.09 112.68,42.25 112.54,42.25 112.39,42.1 112.39,41.96 112.55,41.8 112.55,41.66 112.41,41.51 112.21,41.51 112.08,41.64 111.93,41.64 111.82,41.53 111.82,41.38 111.98,41.23 111.98,41.08 111.83,40.94 111.69,40.94 111.53,41.1 111.39,41.1 111.24,40.95 111.24,40.81 111.51,40.54 111.51,40.38 110.45,39.32 99.45,39.32 97.58,37.45 97.58,34.33 97.73,34.18 v1(98.09,34.18)
  BOTTOM w0.089: v1(122.06,71.32) 122.51,71.53 UC1.AC32
  BOTTOM w0.15: v1(98.09,34.18) 98.56,33.71 98.56,32.35 98.71,32.2 JDIMM1.158
DDR_A_MA14: length 64.5
  IN4 w0.089: v1(122.06,71.89) 122.5,71.45 122.5,71.3 125.42,68.37 125.43,68.37 125.7,68.11 125.7,67.31 125.69,67.3 125.69,60.2
  IN4 w0.102: v1(98.09,37.23) 98.09,37.44 99.6,38.95 110.61,38.95 112.02,40.36 112.16,40.36 112.42,40.11 112.57,40.11 113.04,40.58 113.04,40.72 112.66,41.1 112.66,41.25 112.81,41.39 112.95,41.39 113.33,41.01 113.47,41.01 113.62,41.16 113.62,41.3 113.24,41.68 113.24,41.82 113.38,41.96 113.53,41.96 113.9,41.59 114.05,41.59 114.19,41.73 114.19,41.87 113.81,42.25 113.81,42.4 113.96,42.54 114.1,42.54 114.48,42.16 114.62,42.16 114.77,42.31 114.77,42.45 114.39,42.83 114.39,42.97 114.53,43.11 114.68,43.11 115.05,42.74 115.2,42.74 115.34,42.88 115.34,43.02 114.96,43.4 114.96,43.55 115.11,43.69 115.25,43.69 115.63,43.31 115.77,43.31 115.92,43.46 115.92,43.6 115.54,43.98 115.54,44.12 124.18,52.76 124.18,54.57 125.03,55.42 125.03,59.53 125.69,60.2
  BOTTOM w0.089: UC1.AC31 122.52,72.12 v1(122.06,71.89)
  BOTTOM w0.15: v1(98.09,37.23) 97.69,37.23 96.96,37.96 JDIMM1.151
DDR_A_MA15: length 63.8
  IN4 w0.089: 124.44,59.57 125.29,60.41 125.29,66.77 121.17,70.88 v1(121.17,71.28)
  IN4 w0.102: 124.44,59.57 124.44,55.88 123.44,54.88 123.44,53.07 117.11,46.74 116.95,46.74 116.83,46.86 116.63,46.86 116.48,46.71 116.48,46.57 116.64,46.41 116.64,46.27 116.5,46.12 116.35,46.12 116.2,46.28 116.05,46.28 115.91,46.14 115.91,45.99 116.07,45.84 116.07,45.69 115.92,45.55 115.78,45.55 115.62,45.71 115.48,45.71 115.33,45.56 115.33,45.42 115.49,45.26 115.49,45.12 115.35,44.97 115.2,44.97 115.05,45.13 114.9,45.13 114.76,44.99 114.76,44.84 114.92,44.69 114.92,44.54 114.77,44.4 114.63,44.4 114.47,44.56 114.33,44.56 110.75,40.98 110.75,40.38 110.06,39.69 99.29,39.69 97.14,37.54 97.14,33.6 v1(98.09,32.66)
  BOTTOM w0.089: v1(121.17,71.28) 121.19,71.33 UC1.AB32
  BOTTOM w0.15: JDIMM1.156 98.21,31.98 98.09,32.1 v1(98.09,32.66)
DDR_A_MA16: length 61.6
  IN4 w0.089: 123.34,57.56 123.34,58 123.87,58.52 123.87,66.24 120.79,69.31 120.79,70.27 120.24,70.82 v1(120.24,71.31)
  IN4 w0.102: v1(95.77,33.92) 94.9,34.78 94.9,37.16 97.96,40.22 97.96,40.6 98.71,41.35 109.56,41.35 122.34,54.13 122.34,55.34 123.34,56.34 123.34,57.56
  BOTTOM w0.089: UC1.Y32 v1(120.24,71.31)
  BOTTOM w0.15: JDIMM1.152 97.21,32.48 v1(95.77,33.92)
DDR_A_ODT0: length 68.4
  IN4 w0.089: 125.61,58.78 125.61,59.6 126.67,60.66 126.67,66.61 127.06,66.99 127.06,67.42 126.52,67.96 126.52,68.45 125.64,69.33 125.32,69.33 123.43,71.22 123.43,71.53 v1(123,71.96)
  IN4 w0.102: v1(99.08,35.16) 99.08,37.39 99.91,38.22 110.91,38.22 112.06,39.37 112.87,39.37 116.96,43.46 116.96,43.6 116.58,43.98 116.58,44.12 118.35,45.89 118.5,45.89 118.87,45.51 119.02,45.51 119.16,45.66 119.16,45.8 118.78,46.18 118.78,46.32 118.93,46.47 119.07,46.47 119.45,46.09 119.59,46.09 119.74,46.23 119.74,46.38 119.36,46.75 119.36,46.9 119.5,47.04 119.65,47.04 120.02,46.66 120.17,46.66 120.31,46.81 120.31,46.95 119.93,47.33 119.93,47.47 120.08,47.62 120.22,47.62 120.6,47.24 120.74,47.24 120.89,47.38 120.89,47.53 120.51,47.9 120.51,48.05 120.65,48.19 120.8,48.19 121.17,47.81 121.32,47.81 124.91,51.41 124.91,54.27 125.61,54.96 125.61,58.78
  BOTTOM w0.089: UC1.AE31 v1(123,71.96)
  BOTTOM w0.15: v1(99.08,35.16) 98.65,35.6 98.65,37.48 97.96,38.17 JDIMM1.155
DDR_A_ODT1: length 67.3
  IN4 w0.089: v1(123.93,71.95) 124.28,71.95 127.1,69.13 127.1,68.06 127.49,67.67 127.49,66.72 127.03,66.26 127.03,59.86
  IN4 w0.102: 127.03,59.86 126.35,59.18 126.35,54.61 125.65,53.91 125.65,51.11 118.48,43.94 118.26,43.94 117.92,44.27 117.78,44.27 117.62,44.12 117.62,43.98 117.99,43.61 117.99,43.44 112.02,37.48 103.3,37.48 103.2,37.38 103.2,36.42 103.09,36.32 102.89,36.32 102.79,36.42 102.79,37.38 102.69,37.48 101.96,37.48 101.84,37.36 101.84,35.02 101.73,34.92 101.51,34.92 101.41,35.02 101.41,36.07 101.31,36.17 101.1,36.17 101,36.07 101,35.02 100.9,34.92 100.66,34.92 100.56,35.02 100.56,36.03 100.43,36.17 v1(100.17,36.17)
  BOTTOM w0.089: UC1.AF31 124.34,72.16 v1(123.93,71.95)
  BOTTOM w0.15: JDIMM1.161 99.45,36.89 v1(100.17,36.17)
DDR_A_PARITY: length 60.2
  IN4 w0.089: 122.97,57.56 122.97,58.03 123.67,58.72 123.67,65.33 123.02,65.98 123.02,66.73 119.79,69.96 119.79,71.48 v1(119.33,71.95)
  IN4 w0.102: v1(94.45,36.21) 94.45,37.22 97.59,40.37 97.59,40.75 98.56,41.72 109.4,41.72 121.97,54.28 121.97,55.49 122.97,56.49 122.97,57.56
  BOTTOM w0.089: v1(119.33,71.95) UC1.W31
  BOTTOM w0.15: JDIMM1.143 92.96,37.7 v1(94.45,36.21)
DDR_B_ACT#: length 78.9
  IN1 w0.076: 118.72,71.08 118.79,71.15 118.79,73.32 v1(119.33,73.85)
  IN1 w0.089: 118.72,71.08 118.37,70.72 118.37,66.23 117.14,65.01 117.14,59.53
  IN1 w0.102: v1(161.09,33.27) 161.02,33.27 158.3,35.99 158.3,37.17 158.07,37.4 156.57,37.4 155.8,38.16 138.71,38.16 138.08,37.53 132.54,37.53 117.14,52.94 117.14,59.53
  BOTTOM w0.089: v1(119.33,73.85) 119.7,74.08 UC1.W28
  BOTTOM w0.15: v1(161.09,33.27) 161.44,33.27 162.9,31.81 JDIMM2.114
DDR_B_ALERT#: length 80.2
  IN1 w0.076: v1(120.24,73.22) 119.87,72.85 119.87,71.06
  IN1 w0.089: 119.87,71.06 119.61,70.8 119.61,66.27 118.68,65.33 118.68,59.23 118.25,58.8
  IN1 w0.102: 118.25,58.8 118.25,53.39 133,38.64 137.63,38.64 138.25,39.27 156.26,39.27 157.02,38.5 158.87,38.5 159.61,37.76 160.06,37.76 160.28,37.54 160.28,36.88 160.38,36.78 160.56,36.78 160.66,36.68 160.66,36.47 160.56,36.37 160.38,36.37 160.28,36.27 160.28,35.89 160.38,35.79 160.56,35.79 160.66,35.69 160.66,35.48 160.56,35.38 160.38,35.38 160.28,35.28 160.28,34.53 160.44,34.37 160.67,34.37 160.79,34.49 160.79,34.66 160.92,34.8 v1(161.09,34.8)
  BOTTOM w0.089: UC1.Y29 v1(120.24,73.22)
  BOTTOM w0.15: JDIMM2.116 163.41,31.88 162.24,33.04 162.24,33.65 v1(161.09,34.8)
DDR_B_BA0: length 78.9
  IN1 w0.102: v1(172.2,32.39) 170.41,32.39 170.31,32.49 170.31,32.76 170.44,32.89 170.77,32.89 170.87,32.99 170.87,33.42 170.97,33.52 171.17,33.52 171.27,33.42 171.27,32.99 171.38,32.89 171.71,32.89 171.81,32.99 171.81,37.64 168.87,40.57 168.87,40.67 164.29,45.25 162.5,45.25 161.67,46.07 160.05,46.07 159.31,46.82 146.65,46.82 146.26,47.2 135.94,47.2 124.99,58.16 124.99,61.5 v1(124.65,61.84)
  BOTTOM w0.076: UC1.AJ37 126.04,68.44 126.04,67.67 125.6,67.23 125.6,64.93 125.57,64.9 125.57,64.8
  BOTTOM w0.089: v1(124.65,61.84) 125.57,62.76 125.57,64.8
  BOTTOM w0.15: v1(172.2,32.39) 172.43,32.62 173.11,32.62 173.91,31.82 JDIMM2.150
DDR_B_BA1: length 79.7
  IN1 w0.102: v1(172.2,36.96) 172.2,37.77 169.24,40.72 169.24,40.82 168.74,41.32 168.74,41.46 169.1,41.83 169.1,41.97 168.97,42.11 168.82,42.11 168.46,41.74 168.32,41.74 168.2,41.87 168.2,42.01 168.56,42.37 168.56,42.52 168.41,42.66 168.27,42.66 167.91,42.3 167.77,42.3 167.62,42.44 167.62,42.58 167.98,42.95 167.98,43.09 167.84,43.23 167.7,43.23 167.33,42.87 167.19,42.87 166.98,43.08 166.98,43.22 167.35,43.59 167.35,43.73 167.2,43.87 167.06,43.87 166.7,43.51 166.55,43.51 166.41,43.65 166.41,43.8 166.77,44.16 166.77,44.3 166.63,44.45 166.48,44.45 166.12,44.09 165.98,44.09 165.82,44.25 165.82,44.39 166.18,44.75 166.18,44.9 166.03,45.04 165.89,45.04 165.53,44.68 165.38,44.68 165.24,44.82 165.24,44.97 165.6,45.33 165.6,45.47 165.46,45.62 165.32,45.62 164.95,45.25 164.81,45.25 164.45,45.62 162.65,45.62 161.82,46.44 160.21,46.44 159.46,47.18 146.8,47.18 146.41,47.57 136.1,47.57 125.43,58.24 125.43,59.3 125.18,59.55 125.18,61.94 v1(124.65,62.47)
  BOTTOM w0.076: UC1.AJ36 125.95,69.13 125.68,68.65 125.68,68.38 125.88,68.18 125.88,67.73 125.44,67.29 125.44,65 125.39,64.96 125.39,64.86
  BOTTOM w0.089: v1(124.65,62.47) 125.39,63.21 125.39,64.86
  BOTTOM w0.15: JDIMM2.145 172.65,38.09 173,37.74 173,36.95 172.87,36.81 172.35,36.81 v1(172.2,36.96)
DDR_B_BG0: length 77.2
  IN1 w0.076: 118.88,70.98 118.95,71.05 118.95,72.84 v1(119.33,73.22)
  IN1 w0.089: 118.88,70.98 118.64,70.74 118.64,66.73 118.64,66.13 118.22,65.71 118.22,59.68 117.6,59.06
  IN1 w0.102: v1(159.9,35.86) 158.96,35.86 158.67,36.15 158.67,37.33 158.23,37.76 156.72,37.76 155.95,38.53 138.56,38.53 137.93,37.9 132.7,37.9 117.51,53.09 117.51,58.97 117.6,59.06
  BOTTOM w0.089: UC1.W29 119.7,73.43 v1(119.33,73.22)
  BOTTOM w0.15: JDIMM2.115 163.16,38.33 162.03,37.2 160.56,36.52 v1(159.9,35.86)
DDR_B_BG1: length 77.5
  IN1 w0.076: 119.64,71.08 119.71,71.15 119.71,73.32 v1(120.24,73.85)
  IN1 w0.089: 119.64,71.08 119.43,70.87 119.43,66.37 118.45,65.39 118.45,59.38 117.88,58.81
  IN1 w0.102: v1(159.9,37.38) 159.65,37.38 159.52,37.25 159.52,36.33 159.42,36.22 159.14,36.22 159.03,36.33 159.03,37.82 158.72,38.13 156.87,38.13 156.1,38.9 138.41,38.9 137.78,38.27 132.85,38.27 117.88,53.24 117.88,58.81
  BOTTOM w0.089: UC1.Y28 v1(120.24,73.85)
  BOTTOM w0.15: v1(159.9,37.38) 161.2,37.38 161.77,37.58 162.65,38.46 JDIMM2.113
DDR_B_CKE0: length 75.4
  IN1 w0.089: v1(117.5,73.85) 117.88,73.48 117.88,70.83 117.42,70.38 117.42,66.36 117.23,66.16
  IN1 w0.102: v1(157.92,37.01) 156.43,37.01 155.65,37.79 141.02,37.79 141.02,37.79 138.86,37.79 138.24,37.17 132.39,37.17 116.77,52.78 116.77,65.71 117.23,66.16
  BOTTOM w0.089: UC1.T28 v1(117.5,73.85)
  BOTTOM w0.15: v1(157.92,37.01) 158.21,37.31 159.77,37.95 161.11,37.95 161.65,38.5 JDIMM2.109
DDR_B_CKE1: length 77.1
  IN1 w0.089: 116.89,67 117.13,67.24 117.13,72.84 v1(117.5,73.22)
  IN1 w0.102: v1(158.87,32.52) 158.68,32.33 135.63,32.33 133.88,33.32 131.95,35.25 126.73,42.31 116.41,52.63 116.41,66.52 116.89,67
  BOTTOM w0.089: UC1.T29 v1(117.5,73.22)
  BOTTOM w0.15: JDIMM2.110 161.9,31.82 161.21,32.52 v1(158.87,32.52)
DDR_B_CLK0: length 82.2
  IN1 w0.094: v1(169.06,35.74) 169.45,36.13 169.62,36.13 169.82,36.33 169.82,37.61 163.52,43.9 161.94,43.9 161.11,44.73 159.5,44.73 158.75,45.47 136.87,45.47 136.63,45.71 135.54,45.71 134.86,46.39 133.45,46.39 132.49,47.35 132.49,47.48 132.85,47.85 132.85,48.13 132.54,48.44 132.26,48.44 131.89,48.07 131.76,48.07 131.56,48.28 131.56,48.41 132.06,48.91 132.06,49.19 131.75,49.5 131.47,49.5 130.97,49 130.84,49 130.64,49.2 130.64,49.33 131.13,49.83 131.13,50.11 123.87,57.38 123.87,57.91 124.05,58.09 124.05,64.93 122.83,66.15 122.83,66.51 123.54,67.22 123.54,73.13 123.64,73.22 v1(123.88,73.22)
  BOTTOM w0.089: UC1.AF29 v1(123.88,73.22)
  BOTTOM w0.104: v1(169.06,35.74) 168.83,35.98 168.62,35.98 168.37,36.24 168.37,37.57 168.81,38.01 168.81,38.28 168.65,38.43 JDIMM2.137
DDR_B_CLK1: length 81.5
  IN1 w0.094: v1(169.06,34.22) 169.06,33.99 168.78,33.7 168.36,33.7 168.11,33.95 168.11,37.61 165.48,40.24 165.48,40.84 163.2,43.12 161.61,43.12 160.79,43.95 159.17,43.95 158.43,44.69 136.54,44.69 136.3,44.92 135.21,44.92 134.54,45.6 132.89,45.6 129.64,48.85 129.64,50.5 123.09,57.05 123.09,58.02 123.53,58.46 123.53,64.89 122.2,66.21 122.2,70.36 122.61,70.77 122.61,72.84 122.54,72.9 122.54,73.18 122.71,73.35 122.84,73.35 v1(122.97,73.22)
  BOTTOM w0.076: UC1.AE29 123.23,73.48 v1(122.97,73.22)
  BOTTOM w0.104: JDIMM2.138 168.91,31.99 168.34,32.55 168.34,33.5 168.63,33.79 168.87,33.79 169.06,33.98 v1(169.06,34.22)
DDR_B_CLK#0: length 82.2
  IN1 w0.094: v1(123.88,73.85) 123.88,73.75 123.37,73.24 123.37,70.82 123.36,70.8 123.36,67.3 122.65,66.59 122.65,66.07 123.87,64.85 123.87,58.17 123.69,57.99 123.69,57.3 130.95,50.04 130.95,49.91 130.45,49.41 130.45,49.12 130.76,48.82 131.05,48.82 131.54,49.31 131.68,49.31 131.88,49.11 131.88,48.98 131.38,48.48 131.38,48.2 131.69,47.89 131.97,47.89 132.33,48.25 132.47,48.25 132.67,48.05 132.67,47.92 132.3,47.56 132.3,47.27 133.37,46.2 134.79,46.2 135.46,45.53 136.55,45.53 136.79,45.29 158.68,45.29 159.42,44.55 161.04,44.55 161.86,43.72 163.45,43.72 169.63,37.53 169.63,36.41 169.54,36.32 169.26,36.32 v1(169.06,36.51)
  BOTTOM w0.089: UC1.AF28 v1(123.88,73.85)
  BOTTOM w0.104: v1(169.06,36.51) 169.06,36.37 168.87,36.18 168.7,36.18 168.56,36.32 168.56,37.49 169,37.93 169,38.21 169.16,38.36 JDIMM2.139
DDR_B_CLK#1: length 81.5
  IN1 w0.094: v1(122.97,73.85) 122.37,73.25 122.37,72.83 122.44,72.76 122.44,70.86 122.02,70.44 122.02,66.14 123.34,64.81 123.34,58.53 122.91,58.1 122.91,56.97 129.46,50.42 129.46,48.77 132.81,45.42 134.46,45.42 135.14,44.74 136.23,44.74 136.46,44.51 158.35,44.51 159.1,43.76 160.71,43.76 161.54,42.94 163.12,42.94 165.3,40.76 165.3,40.17 167.93,37.53 167.93,33.88 168.28,33.52 169,33.52 v1(169.06,33.46)
  BOTTOM w0.089: UC1.AE28 v1(122.97,73.85)
  BOTTOM w0.104: JDIMM2.140 169.41,31.96 169.25,32.11 169.06,32.11 168.54,32.63 168.54,33.42 168.71,33.59 168.93,33.59 v1(169.06,33.46)
DDR_B_CS#0: length 79.5
  IN1 w0.102: v1(126.31,65.39) 125.94,65.02 125.94,60.79 126.89,59.84 126.89,58.86 135.83,49.93 143.14,49.93 143.96,49.12 148.31,49.12 148.35,49.07 151.44,49.07 151.86,48.66 160.08,48.66 160.82,47.92 162.43,47.92 163.26,47.09 166.21,47.09 172.35,40.95 172.35,39.7 173.83,38.22 173.83,37.18 173.93,37.08 174.67,37.08 174.77,36.97 174.77,36.77 174.67,36.67 173.93,36.67 173.83,36.57 173.83,36.36 173.93,36.26 174.81,36.26 174.91,36.16 174.91,35.96 174.81,35.86 173.93,35.86 173.83,35.76 173.83,35.55 173.93,35.45 v1(175.29,35.45)
  BOTTOM w0.076: UC1.AL37 127.15,68.44 127.15,67.67 127.3,67.51 127.3,66.93 126.87,66.5 126.87,66.4
  BOTTOM w0.089: v1(126.31,65.39) 126.87,65.95 126.87,66.4
  BOTTOM w0.15: v1(175.29,35.45) 174.73,35.45 173.65,36.52 JDIMM2.149
DDR_B_CS#1: length 79.3
  IN1 w0.102: v1(126.31,63.48) 128,61.8 128,59.32 136.28,51.03 143.6,51.03 144.41,50.22 145.59,50.22 146.09,50.72 149.02,50.72 149.51,50.24 153.58,50.24 154.05,49.76 160.53,49.76 161.28,49.02 163.41,49.02 163.51,48.92 163.51,48.4 163.61,48.3 163.82,48.3 163.92,48.4 163.92,48.92 164.02,49.03 164.22,49.03 164.32,48.92 164.32,48.29 164.43,48.19 164.63,48.19 164.73,48.29 164.73,48.92 164.83,49.03 165.04,49.03 165.14,48.92 165.14,48.29 165.24,48.19 165.44,48.19 165.54,48.29 165.54,48.92 165.65,49.03 165.89,49.03 166,48.92 166,48.29 166.1,48.19 166.34,48.19 166.44,48.29 166.44,48.72 166.55,48.83 166.79,48.83 166.93,48.69 166.93,47.98 176.05,38.86 176.05,38.58 176.15,38.48 176.44,38.48 176.54,38.37 176.54,38.17 176.44,38.07 176.15,38.07 176.05,37.97 176.05,37.51 176.15,37.41 v1(176.41,37.41)
  BOTTOM w0.076: 127.23,66.29 127.23,66.39 127.63,66.8 127.63,67.64 127.48,67.8 127.48,68.12 127.67,68.31 127.67,68.69 127.57,68.89 127.57,69.52 UC1.AL35
  BOTTOM w0.089: 127.23,66.29 127.23,64.4 v1(126.31,63.48)
  BOTTOM w0.15: v1(176.41,37.41) 175.65,38.16 JDIMM2.157
DDR_B_D0: length 47.7
  IN4 w0.084: v1(135.18,34.55) 135.33,34.55 135.55,34.77 135.55,36.99 135.02,37.52 133.78,37.52 127.52,43.78 127.52,46.65 127.44,46.74 127.09,46.74 127.01,46.82 127.01,46.99 127.09,47.07 127.44,47.07 127.52,47.16 127.52,47.32 127.44,47.41 126.96,47.41 126.88,47.49 126.88,47.66 126.96,47.74 127.44,47.74 127.52,47.83 127.52,48 127.44,48.08 126.96,48.08 126.88,48.16 126.88,48.33 126.96,48.41 127.44,48.41 127.52,48.5 127.52,58.84 127.83,59.15 127.83,63.61 128.33,64.11 128.33,65.88 v1(127.8,66.42)
  BOTTOM w0.076: UC1.AN35 128.14,69.52 128.14,68.89 128.04,68.69 128.04,68.31 128.23,68.12 128.23,67.83 128.02,67.62 128.02,66.64 v1(127.8,66.42)
  BOTTOM w0.127: JDIMM2.4 135.41,31.81 134.58,32.64 134.58,33.94 v1(135.18,34.55)
DDR_B_D1: length 45.9
  IN4 w0.084: v1(129.1,66.59) 128.54,66.03 128.54,64.07 128.12,63.65 128.12,59.19 127.81,58.89 127.81,43.9 133.9,37.81 135.13,37.81 135.84,37.1 135.84,33.68 v1(135.18,33.02)
  BOTTOM w0.076: v1(129.1,66.59) 129.1,66.68 129.49,67.07 129.49,67.38 129.34,67.54 129.34,68.65 129.38,68.77 129.38,68.95 129.34,69.07 129.34,69.3 129.41,69.52 129.41,70.27 129.4,70.28 129.23,70.45 129.23,70.45 129.2,70.48 UC1.AN34
  BOTTOM w0.127: v1(135.18,33.02) 136.41,31.8 JDIMM2.8
DDR_B_D2: length 47.6
  IN4 w0.084: v1(129.1,65.96) 130.04,65.02 130.04,60.33 129.86,60.15 129.86,45.22 133.85,41.23 135.42,41.23 136.95,39.69 137.47,39.69 139.81,37.35 139.81,37.08 139.73,37 139.54,37 139.45,36.92 139.45,36.75 139.54,36.66 139.73,36.66 139.81,36.58 139.81,34.64 139.71,34.54 139.48,34.54 139.39,34.62 139.39,35.81 139.31,35.89 v1(139.02,35.89)
  BOTTOM w0.076: 129.41,66.26 129.48,66.34 129.48,66.82 129.66,67 129.66,67.45 129.5,67.6 129.5,68.63 129.54,68.74 129.54,68.98 129.5,69.09 129.5,69.28 129.67,69.74 UC1.AR35
  BOTTOM w0.089: 129.41,66.26 v1(129.1,65.96)
  BOTTOM w0.127: v1(139.02,35.89) 138.54,36.37 138.54,37.84 138.66,37.95 JDIMM2.17
DDR_B_D3: length 48.3
  IN4 w0.084: v1(139.02,32.84) 137.67,34.19 137.67,36.93 137.05,37.56 137.05,37.68 137.34,37.97 137.34,38.09 137.22,38.2 137.1,38.2 136.81,37.91 136.69,37.91 136.57,38.03 136.57,38.15 136.87,38.44 136.87,38.56 136.75,38.68 136.63,38.68 136.34,38.39 136.22,38.39 136.07,38.53 136.07,38.65 136.36,38.94 136.36,39.06 135.52,39.91 133.46,39.91 128.99,44.37 128.99,60.26 129.46,60.73 129.46,63.05 129.1,63.41 v1(129.1,63.42)
  BOTTOM w0.076: UC1.AR34 130.07,69.86 130.07,68.92 130.19,68.69 130.19,68.31 129.99,68.12 129.99,67.8 130.15,67.64 130.15,66.8 129.98,66.62 129.98,66.08 129.9,66
  BOTTOM w0.089: 129.9,66 129.84,65.94 129.84,64.16 v1(129.1,63.42)
  BOTTOM w0.127: JDIMM2.16 138.41,32.22 v1(139.02,32.84)
DDR_B_D4: length 47
  IN4 w0.084: v1(135.18,35.31) 134.89,35.31 134.81,35.39 134.81,36.15 134.67,36.29 134.2,36.29 127.71,42.78 126.33,42.78 126.24,42.86 126.24,48.9 126.33,48.99 126.86,48.99 126.95,49.07 126.95,49.24 126.86,49.32 126.33,49.32 126.24,49.41 126.24,49.58 126.33,49.66 126.86,49.66 126.95,49.74 126.95,49.91 126.86,49.99 126.33,49.99 126.24,50.08 126.24,50.26 126.33,50.35 126.86,50.35 126.95,50.43 126.95,50.62 126.86,50.7 126.58,50.7 126.5,50.78 126.5,50.95 126.58,51.04 126.86,51.04 126.95,51.12 126.95,59.02 127.47,59.54 127.47,64.19 v1(127.8,64.51)
  BOTTOM w0.076: 128.35,67.36 128.35,67.5 128.56,67.7 128.56,68.44 UC1.AN37
  BOTTOM w0.089: 128.35,67.36 128.35,65.07 v1(127.8,64.51)
  BOTTOM w0.127: v1(135.18,35.31) 135.76,35.89 135.76,37.74 136.16,38.13 JDIMM2.7
DDR_B_D5: length 47.7
  IN4 w0.084: v1(135.18,36.79) 135.01,36.96 135.01,37.13 134.9,37.24 134.65,37.24 134.57,37.15 134.57,36.66 134.49,36.58 134.32,36.58 134.23,36.66 134.23,37.15 134.15,37.24 133.66,37.24 127.83,43.07 126.71,43.07 126.63,43.15 126.63,43.32 126.71,43.4 127.15,43.4 127.24,43.49 127.24,43.67 127.15,43.76 126.71,43.76 126.63,43.84 126.63,44.01 126.71,44.09 127.15,44.09 127.24,44.17 127.24,44.36 127.15,44.44 126.68,44.44 126.59,44.53 126.59,44.69 126.68,44.77 127.15,44.77 127.24,44.86 127.24,45.03 127.15,45.11 126.68,45.11 126.59,45.19 126.59,45.36 126.68,45.45 127.15,45.45 127.24,45.53 127.24,45.7 127.15,45.78 126.68,45.78 126.59,45.86 126.59,46.03 126.68,46.12 127.15,46.12 127.24,46.2 127.24,46.37 127.15,46.45 126.68,46.45 126.59,46.53 126.59,48.6 126.69,48.7 127.09,48.7 127.24,48.85 127.24,58.8 127.64,59.21 127.64,63.67 128.15,64.18 128.15,64.79 v1(127.8,65.15)
  BOTTOM w0.076: 128.11,65.46 128.18,65.53 128.18,67.55 128.4,67.77 128.4,68.18 128.2,68.38 128.2,68.65 128.46,69.13 UC1.AN36
  BOTTOM w0.089: 128.11,65.46 v1(127.8,65.15)
  BOTTOM w0.127: v1(135.18,36.79) 135.16,36.81 JDIMM2.3
DDR_B_D6: length 48.9
  IN4 w0.084: v1(139.02,34.37) 138.04,34.37 137.96,34.45 137.96,34.63 138.04,34.72 138.48,34.72 138.56,34.8 138.56,34.97 138.48,35.05 138.04,35.05 137.96,35.14 137.96,35.3 138.04,35.39 138.48,35.39 138.56,35.47 138.56,35.64 138.48,35.72 138.04,35.72 137.96,35.81 137.96,35.98 138.04,36.06 138.48,36.06 138.56,36.14 138.56,36.31 138.48,36.39 138.04,36.39 137.96,36.48 137.96,36.65 138.04,36.73 138.23,36.73 138.31,36.81 138.31,36.98 138.23,37.07 137.95,37.07 137.63,37.39 137.63,38.21 135.64,40.19 133.58,40.19 129.28,44.49 129.28,60.08 129.63,60.44 129.63,63.53 129.11,64.05 v1(129.1,64.05)
  BOTTOM w0.076: 129.74,66.09 129.81,66.16 129.81,66.69 129.99,66.86 129.99,67.58 129.83,67.73 129.83,68.18 130.03,68.38 130.03,68.65 129.76,69.13 UC1.AR36
  BOTTOM w0.089: 129.74,66.09 129.67,66.02 129.67,64.61 v1(129.1,64.05)
  BOTTOM w0.127: v1(139.02,34.37) 139.66,33.73 139.66,32.44 139.41,32.18 JDIMM2.20
DDR_B_D7: length 47.9
  IN4 w0.084: v1(139.02,37.41) 138.01,37.41 137.91,37.51 137.91,37.79 138,37.87 138.55,37.87 138.63,37.96 138.63,38.12 138.55,38.21 138.03,38.21 137.89,38.34 137.89,38.46 138.03,38.6 138.03,38.72 137.91,38.84 137.8,38.84 137.66,38.7 137.54,38.7 137.41,38.83 137.41,38.95 137.55,39.09 137.55,39.21 137.43,39.33 137.31,39.33 137.17,39.19 137.05,39.19 135.3,40.94 134.86,40.94 134.77,40.86 134.77,40.57 134.69,40.48 134.52,40.48 134.44,40.57 134.44,40.86 134.35,40.94 134.16,40.94 134.08,40.86 134.08,40.57 133.99,40.48 133.7,40.48 133.51,40.67 133.51,40.79 133.63,40.91 133.63,41.04 133.46,41.21 133.34,41.21 133.21,41.09 133.1,41.09 132.98,41.2 132.98,41.32 133.1,41.45 133.1,41.57 132.98,41.68 132.84,41.68 132.73,41.57 132.61,41.57 132.5,41.68 132.5,41.8 132.63,41.92 132.63,42.04 132.51,42.16 132.39,42.16 132.27,42.03 132.15,42.03 132.03,42.15 132.03,42.27 132.15,42.4 132.15,42.51 132.03,42.63 131.92,42.63 131.79,42.51 131.67,42.51 131.55,42.63 131.55,42.75 131.68,42.87 131.68,42.99 131.56,43.11 131.44,43.11 131.32,42.98 131.2,42.98 131.08,43.1 131.08,43.22 131.2,43.35 131.2,43.46 131.09,43.58 130.97,43.58 130.84,43.46 130.72,43.46 130.61,43.58 130.61,43.7 130.73,43.82 130.73,43.94 130.61,44.06 130.49,44.06 130.37,43.93 130.25,43.93 130.13,44.05 130.13,44.17 130.26,44.29 130.26,44.41 130.14,44.53 130.02,44.53 129.89,44.41 129.77,44.41 129.66,44.53 129.66,44.64 129.78,44.77 129.78,44.89 129.57,45.1 129.57,60.13 129.81,60.36 129.81,64.65 129.13,65.32 v1(129.1,65.32)
  BOTTOM w0.076: UC1.AR37 129.67,68.44 129.67,67.67 129.82,67.51 129.82,66.93 129.65,66.76 129.65,66.25 129.57,66.18
  BOTTOM w0.089: v1(129.1,65.32) 129.49,65.71 129.49,66.09 129.57,66.18
  BOTTOM w0.127: JDIMM2.21 139.66,37.3 139.55,37.19 139.24,37.19 v1(139.02,37.41)
DDR_B_D8: length 48.3
  IN4 w0.084: v1(130.76,65.68) 131.31,65.14 131.31,64.21 131.54,63.98 131.54,62.25 131.23,61.95 131.23,46.21 134.85,42.6 137.12,42.6 138.82,40.9 138.82,40.38 139.04,40.16 139.56,40.16 142.23,37.49 142.23,34.62 142.15,34.54 141.44,34.54 141.36,34.62 141.36,35.48 v1(140.96,35.88)
  BOTTOM w0.076: 131.08,65.99 131.15,66.06 131.15,66.47 131.09,66.53 131.09,67.45 131.24,67.6 131.24,68.63 131.2,68.74 131.2,68.98 131.24,69.09 131.24,69.28 131.08,69.74 UC1.AU35
  BOTTOM w0.089: 131.08,65.99 v1(130.76,65.68)
  BOTTOM w0.127: JDIMM2.25 140.66,38.51 140.3,38.16 140.3,36.54 v1(140.96,35.88)
DDR_B_D9: length 48.5
  IN4 w0.084: v1(140.96,34.35) 140.67,34.35 140.59,34.44 140.59,37.67 140.23,38.03 140.23,38.15 140.43,38.35 140.43,38.47 140.31,38.59 140.2,38.59 139.99,38.39 139.87,38.39 139.75,38.51 139.75,38.62 139.96,38.83 139.96,38.95 139.84,39.07 139.72,39.07 139.52,38.86 139.4,38.86 139.28,38.98 139.28,39.1 139.48,39.3 139.48,39.42 139.37,39.54 139.25,39.54 139.11,39.4 138.99,39.4 138.25,40.14 138.25,40.66 136.88,42.02 134.61,42.02 130.63,46 130.63,61.84 131.15,62.36 131.15,62.75 v1(130.76,63.14)
  BOTTOM w0.076: 130.2,65.88 130.2,65.98 130.22,66 130.22,66.54 130.59,66.91 130.59,67.64 130.75,67.8 130.75,68.12 130.55,68.31 130.55,68.69 130.69,68.93 130.69,69.88 UC1.AU34
  BOTTOM w0.089: v1(130.76,63.14) 130.2,63.7 130.2,65.88
  BOTTOM w0.127: v1(140.96,34.35) 140.41,33.8 JDIMM2.24
DDR_B_D10: length 49.9
  IN4 w0.084: v1(144.95,34.24) 144.74,34.24 144.72,34.22 144.53,34.22 144.31,34.44 144.31,37.47 143.7,38.08 143.7,38.2 143.81,38.31 143.81,38.43 143.69,38.55 143.58,38.55 143.46,38.44 143.35,38.44 143.21,38.57 143.21,38.69 143.35,38.83 143.35,38.95 143.23,39.06 143.12,39.06 142.98,38.93 142.86,38.93 142.73,39.06 142.73,39.18 142.87,39.31 142.87,39.43 142.75,39.55 142.63,39.55 142.49,39.41 142.37,39.41 142.25,39.53 142.25,39.65 142.39,39.79 142.39,39.91 142.27,40.03 142.15,40.03 142.01,39.89 141.9,39.89 141.76,40.02 141.76,40.14 141.99,40.37 141.99,40.7 141.26,41.43 141.01,41.43 140.74,41.16 140.62,41.16 137.73,44.06 136.68,44.06 136.56,44.17 136.56,44.54 135.99,45.11 134.4,45.11 132.69,46.82 132.69,63.83 v1(132.07,64.45)
  BOTTOM w0.076: UC1.AW35 132.6,69.52 132.6,68.89 132.71,68.69 132.71,68.31 132.51,68.12 132.51,67.8 132.7,67.61 132.7,67.51
  BOTTOM w0.089: 132.7,67.51 132.7,65.09 v1(132.07,64.45)
  BOTTOM w0.127: JDIMM2.42 144.9,32.1 145.38,32.57 145.38,33.81 v1(144.95,34.24)
DDR_B_D11: length 48.8
  IN4 w0.084: v1(130.76,64.41) 131.36,63.81 131.36,62.32 130.92,61.88 130.92,46.12 134.73,42.31 137,42.31 138.54,40.78 138.54,40.26 138.92,39.88 139.44,39.88 141.94,37.37 141.94,36.27 141.86,36.19 141.44,36.19 141.36,36.27 141.36,37.01 v1(140.96,37.4)
  BOTTOM w0.076: UC1.AW34 131.55,70.48 131.32,70.26 131.32,69.54 131.41,69.3 131.41,69.07 131.37,68.95 131.37,68.77 131.41,68.65 131.41,67.54 131.25,67.38 131.25,66.6 131.32,66.53
  BOTTOM w0.089: v1(130.76,64.41) 131.32,64.97 131.32,66.53
  BOTTOM w0.127: v1(140.96,37.4) 141.31,37.4 141.44,37.28 141.44,36.43 141.57,36.3 141.76,36.3 141.91,36.45 141.91,37.61 141.66,37.87 JDIMM2.29
DDR_B_D12: length 47.9
  IN4 w0.084: v1(144.95,32.71) 144.02,33.64 143.73,33.64 143.64,33.72 143.64,34.16 143.77,34.28 143.9,34.28 144.02,34.41 144.02,37.36 141.36,40.02 141.36,40.14 141.7,40.48 141.7,40.59 141.27,41.01 141.1,41.01 140.79,40.7 140.67,40.7 137.61,43.77 136.36,43.77 136.28,43.85 136.28,44.42 135.87,44.82 134.28,44.82 132.4,46.7 132.4,60.92 132.43,60.95 132.43,63.71 132.17,63.97 131.84,63.97 131.62,64.2 131.62,65.46 v1(130.76,66.31)
  BOTTOM w0.076: v1(130.76,66.31) 130.92,66.47 130.92,67.51 131.08,67.67 131.08,68.44 UC1.AU37
  BOTTOM w0.127: v1(144.95,32.71) 144.33,32.71 143.9,32.29 JDIMM2.38
DDR_B_D13: length 47.4
  IN4 w0.084: v1(130.76,63.77) 130.35,63.36 130.35,45.88 134.49,41.73 135.6,41.73 136.03,41.31 136.19,41.31 136.62,41.73 136.77,41.73 136.9,41.6 136.9,41.48 136.44,41.02 136.44,40.9 136.55,40.78 136.67,40.78 137.13,41.25 137.25,41.25 137.96,40.54 137.96,39.89 140.3,37.55 140.3,34.17 140.22,34.08 139.88,34.08 139.75,33.95 139.75,33.73 139.83,33.65 140.14,33.65 v1(140.96,32.83)
  BOTTOM w0.076: UC1.AU36 130.98,69.13 130.72,68.65 130.72,68.38 130.91,68.18 130.91,67.73 130.76,67.58 130.76,66.84 130.38,66.47 130.38,65.93 130.38,65.92 130.38,65.82
  BOTTOM w0.089: 130.38,65.82 130.38,64.16 v1(130.76,63.77)
  BOTTOM w0.127: JDIMM2.28 141.41,32.39 v1(140.96,32.83)
DDR_B_D14: length 48.8
  IN4 w0.084: v1(132.07,65.72) 132.98,64.81 132.98,48.53 133.12,48.38 133.12,48.26 132.98,48.12 132.98,48 133.1,47.88 133.22,47.88 133.36,48.03 133.48,48.03 133.61,47.9 133.61,47.75 132.98,47.11 132.98,46.93 133.11,46.8 133.23,46.8 133.9,47.47 134.01,47.47 134.13,47.35 134.13,47.23 133.47,46.57 133.47,46.45 133.59,46.33 133.7,46.33 134.37,46.99 134.49,46.99 134.61,46.88 134.61,46.76 133.94,46.09 133.94,45.97 134.43,45.48 134.67,45.48 135.29,46.1 135.41,46.1 135.54,45.97 135.54,45.85 135.33,45.63 135.33,45.52 135.45,45.4 135.57,45.4 135.78,45.61 135.9,45.61 137.16,44.34 137.85,44.34 140.47,41.72 141.38,41.72 142.31,40.79 142.31,40.39 144.1,38.6 144.1,38.13 v1(144.95,37.28)
  BOTTOM w0.076: 132.52,67.46 132.52,67.56 132.35,67.73 132.35,68.18 132.55,68.38 132.55,68.65 132.28,69.13 UC1.AW36
  BOTTOM w0.089: 132.52,67.46 132.52,66.18 v1(132.07,65.72)
  BOTTOM w0.127: JDIMM2.41 144.66,38.22 144.26,37.83 144.26,37.31 144.46,37.11 144.78,37.11 v1(144.95,37.28)
DDR_B_D15: length 48
  IN4 w0.084: v1(144.95,35.76) 145.21,35.76 145.29,35.68 145.29,35.14 145.38,35.05 145.55,35.05 145.62,35.12 145.62,37.49 144.96,38.15 144.85,38.15 144.74,38.04 144.63,38.04 144.51,38.16 144.51,38.28 144.61,38.38 144.61,38.5 142.6,40.51 142.6,40.91 141.5,42 140.59,42 137.97,44.63 137.28,44.63 135.41,46.5 135.29,46.5 134.61,45.83 134.49,45.83 134.35,45.97 134.35,46.09 135.02,46.77 135.02,46.89 133.27,48.65 133.27,59.21 133.24,59.23 133.24,65.19 v1(132.07,66.36)
  BOTTOM w0.076: 132.35,67.41 132.35,67.51 132.18,67.67 132.18,68.29 132.28,68.39 UC1.AW37
  BOTTOM w0.089: v1(132.07,66.36) 132.35,66.64 132.35,67.41
  BOTTOM w0.127: JDIMM2.37 143.66,37.05 v1(144.95,35.76)
DDR_B_D16: length 84.5
  IN1 w0.084: v1(179.36,33.03) 178.19,34.2 178.19,35.72 178.52,36.05 178.52,37.55 178.43,37.64 178.01,37.64 177.93,37.72 177.93,37.89 178.01,37.97 178.19,37.97 178.31,38.09 178.31,38.26 178.23,38.35 178.01,38.35 177.93,38.43 177.93,38.88 176.49,40.32 176.49,41.02 175.73,41.78 175.03,41.78 172.5,44.31 172.5,45.01 167.15,50.36 163.44,50.36 162.84,50.96 161.23,50.96 161.09,51.1 155.61,51.1 155,51.71 151.98,51.71 151.85,51.83 150.56,51.83 150.33,52.06 145.78,52.06 145.47,52.37 136.84,52.37 129.54,59.67 129.54,67.3 129.26,67.59 127.72,67.59 127.32,67.99 127.32,68.76 125.31,70.76 125.31,72.88 v1(125.71,73.27)
  BOTTOM w0.089: v1(125.71,73.27) 126.1,73.5 UC1.AJ29
  BOTTOM w0.127: v1(179.36,33.03) 179.36,32.35 178.91,31.89 JDIMM2.170
DDR_B_D17: length 84.8
  IN1 w0.084: v1(125.71,72.64) 125.47,72.4 125.47,70.84 127.97,68.35 128.99,68.35 129.83,67.5 129.83,59.78 136.96,52.66 145.59,52.66 145.9,52.35 150.45,52.35 150.68,52.12 151.46,52.12 151.85,52.51 154.61,52.51 155.73,51.39 161.21,51.39 161.35,51.24 162.96,51.24 163.56,50.65 167.35,50.65 172.79,45.21 172.79,44.42 175.14,42.07 175.93,42.07 177.23,40.77 177.23,39.98 178.6,38.61 178.6,37.88 178.99,37.49 178.99,35.76 178.91,35.68 178.56,35.68 178.47,35.6 178.47,35.33 178.56,35.24 178.87,35.24 178.95,35.16 178.95,34.99 178.87,34.91 178.56,34.91 178.47,34.82 178.47,34.64 178.56,34.55 v1(179.36,34.55)
  BOTTOM w0.089: UC1.AJ30 126.1,72.85 v1(125.71,72.64)
  BOTTOM w0.127: JDIMM2.174 179.91,32.06 180.08,32.24 180.08,33.84 v1(179.36,34.55)
DDR_B_D18: length 84.8
  IN1 w0.084: v1(182.52,33.03) 183.33,33.03 183.41,33.11 183.41,38 182.52,38.89 182.52,39.01 182.89,39.37 182.89,39.49 182.77,39.61 182.65,39.61 182.29,39.25 182.17,39.25 182.05,39.36 182.05,39.48 182.41,39.85 182.41,39.96 182.29,40.08 182.17,40.08 181.81,39.72 181.69,39.72 181.56,39.85 181.56,39.97 181.98,40.39 181.98,40.51 170.06,52.43 169.47,52.43 168.64,53.26 167.91,53.26 167.38,53.79 164.11,53.79 163.74,54.16 158.02,54.16 156.6,55.57 145.36,55.57 144.66,56.27 137.03,56.27 132.95,60.36 132.95,67.39 130.51,69.83 130.02,69.83 128.49,71.36 v1(128.42,71.36)
  BOTTOM w0.089: v1(128.42,71.36) 128.25,71.53 UC1.AM32
  BOTTOM w0.127: JDIMM2.182 181.91,32.41 v1(182.52,33.03)
DDR_B_D19: length 85.4
  IN1 w0.084: v1(127.53,72.07) 128.05,71.54 128.05,71.16 128.3,70.91 128.7,70.91 130.03,69.58 130.52,69.58 132.77,67.32 132.77,60.13 137.37,55.53 145,55.53 145.24,55.28 151.26,55.28 151.72,54.83 156.29,54.83 157.25,53.87 163.62,53.87 163.99,53.5 167.26,53.5 167.79,52.97 168.52,52.97 169.35,52.14 169.94,52.14 176.99,45.08 176.99,44.96 176.89,44.86 176.89,44.74 177.01,44.62 177.13,44.62 177.23,44.73 177.35,44.73 177.47,44.61 177.47,44.49 177.36,44.38 177.36,44.27 177.48,44.15 177.6,44.15 177.7,44.25 177.82,44.25 177.94,44.13 177.94,44.02 177.84,43.91 177.84,43.79 177.96,43.67 178.07,43.67 178.18,43.78 178.3,43.78 178.42,43.66 178.42,43.54 178.31,43.44 178.31,43.32 178.43,43.2 178.55,43.2 178.65,43.3 178.77,43.3 178.89,43.18 178.89,43.07 178.79,42.96 178.79,42.84 178.9,42.72 179.02,42.72 179.13,42.83 179.25,42.83 179.37,42.71 179.37,42.59 179.26,42.49 179.26,42.37 179.38,42.25 179.5,42.25 179.6,42.35 179.72,42.35 181.01,41.06 181.01,40 183.01,37.99 183.01,34.64 182.93,34.55 v1(182.52,34.55)
  BOTTOM w0.089: v1(127.53,72.07) 127.64,72.18 UC1.AM31
  BOTTOM w0.127: v1(182.52,34.55) 183.01,34.06 183.01,32.61 182.91,32.51 JDIMM2.186
DDR_B_D20: length 86.2
  IN1 w0.084: v1(127.53,72.66) 127.25,72.94 126.53,72.94 126.24,72.65 126.24,72.42 125.79,71.97 125.79,71.02 128.11,68.69 129.13,68.69 130.4,67.42 130.4,60.02 137.2,53.23 145.82,53.23 146.13,52.92 150.69,52.92 150.92,52.69 151.23,52.69 151.61,53.08 154.85,53.08 155.97,51.96 160.6,51.96 161.45,51.96 161.59,51.82 163.2,51.82 163.8,51.22 167.8,51.22 178.18,40.85 178.31,40.85 178.44,40.71 178.44,40.09 179.62,38.92 179.62,38.48 179.7,38.4 180.14,38.4 180.22,38.32 180.22,38.13 180.14,38.05 179.79,38.05 179.71,37.96 179.71,37.79 179.79,37.71 180.14,37.71 180.22,37.63 180.22,37.46 180.14,37.38 179.79,37.38 179.71,37.29 179.71,37.12 179.79,37.04 180.14,37.04 180.22,36.96 180.22,36.79 180.14,36.71 179.79,36.71 179.71,36.62 179.71,36.45 179.79,36.37 180.14,36.37 180.22,36.29 180.22,36.02 180.14,35.93 179.5,35.93 v1(179.36,36.08)
  BOTTOM w0.089: UC1.AM30 127.7,72.83 v1(127.53,72.66)
  BOTTOM w0.127: JDIMM2.173 179.65,38.22 179.76,38.12 179.76,36.47 v1(179.36,36.08)
DDR_B_D21: length 85.9
  IN1 w0.084: v1(127.53,73.22) 126.29,73.22 126.08,73.01 126.08,72.48 125.63,72.04 125.63,70.93 128.04,68.52 129.06,68.52 130.12,67.46 130.12,59.9 137.08,52.94 145.7,52.94 146.01,52.63 150.57,52.63 150.8,52.41 151.35,52.41 151.73,52.79 154.73,52.79 155.85,51.67 161.33,51.67 161.47,51.53 163.08,51.53 163.68,50.94 167.47,50.94 173.38,45.03 173.38,44.91 173.1,44.64 173.1,44.52 173.22,44.4 173.34,44.4 173.62,44.67 173.73,44.67 173.85,44.55 173.85,44.44 173.58,44.16 173.58,44.04 173.7,43.92 173.82,43.92 174.09,44.2 174.21,44.2 174.33,44.08 174.33,43.96 174.05,43.69 174.05,43.57 174.17,43.45 174.29,43.45 174.56,43.72 174.68,43.72 174.8,43.61 174.8,43.49 174.53,43.21 174.53,43.09 174.65,42.97 174.76,42.97 175.04,43.25 175.16,43.25 175.28,43.13 175.28,43.01 175,42.74 175,42.62 175.12,42.5 175.24,42.5 175.51,42.78 175.63,42.78 177.52,40.89 177.52,40.1 177.93,39.69 178.05,39.69 178.18,39.83 178.3,39.83 178.42,39.71 178.42,39.59 178.28,39.46 178.28,39.34 178.4,39.22 178.52,39.22 178.66,39.35 178.77,39.35 178.89,39.23 178.89,39.12 178.76,38.98 178.76,38.86 178.94,38.68 179.25,38.68 179.33,38.6 179.33,38.43 179.25,38.34 178.97,38.34 178.89,38.26 178.89,38.08 178.97,37.99 179.31,37.99 179.36,37.93 v1(179.36,37.6)
  BOTTOM w0.089: UC1.AM29 v1(127.53,73.22)
  BOTTOM w0.127: v1(179.36,37.6) 178.65,38.31 JDIMM2.169
DDR_B_D22: length 82.9
  IN1 w0.084: v1(182.52,37.6) 182.52,38.08 181.3,39.3 180.72,39.88 180.72,40.95 180.17,41.5 180.05,41.5 179.95,41.39 179.83,41.39 176.39,44.83 176.39,44.95 176.49,45.06 176.49,45.18 176.37,45.29 176.26,45.29 176.15,45.19 176.03,45.19 175.91,45.31 175.91,45.43 176.02,45.53 176.02,45.65 175.9,45.77 175.78,45.77 175.68,45.66 175.56,45.66 175.44,45.78 175.44,45.9 175.54,46.01 175.54,46.12 175.43,46.24 175.31,46.24 175.2,46.14 175.08,46.14 174.97,46.26 174.97,46.38 175.07,46.48 175.07,46.6 174.95,46.72 174.83,46.72 174.73,46.61 174.61,46.61 174.49,46.73 174.49,46.85 174.6,46.95 174.6,47.07 174.48,47.19 174.36,47.19 174.25,47.09 174.14,47.09 174.02,47.21 174.02,47.32 174.12,47.43 174.12,47.55 174,47.67 173.88,47.67 173.78,47.56 173.66,47.56 173.54,47.68 173.54,47.8 173.65,47.9 173.65,48.02 173.53,48.14 173.41,48.14 173.3,48.04 173.19,48.04 173.07,48.16 173.07,48.27 173.17,48.38 173.17,48.5 173.05,48.62 172.94,48.62 172.83,48.51 172.71,48.51 172.59,48.63 172.59,48.75 172.7,48.85 172.7,48.97 172.58,49.09 172.46,49.09 172.36,48.99 172.24,48.99 172.12,49.1 172.12,49.22 172.22,49.33 172.22,49.45 172.1,49.56 171.99,49.56 171.88,49.46 171.76,49.46 171.64,49.58 171.64,49.7 171.75,49.8 171.75,49.92 169.82,51.85 169.23,51.85 168.4,52.69 166.29,52.69 165.87,53.1 163.98,53.1 163.5,53.58 157.13,53.58 156.17,54.54 151.6,54.54 151.14,55 145.12,55 144.88,55.24 137.25,55.24 132.6,59.89 132.6,67.25 130.45,69.4 129.96,69.4 128.61,70.75 128.19,70.75 v1(127.53,71.42)
  BOTTOM w0.089: UC1.AJ31 126.26,72.09 126.26,71.84 126.46,71.64 126.78,71.64 126.95,71.82 127.19,71.82 127.53,71.48 v1(127.53,71.42)
  BOTTOM w0.127: v1(182.52,37.6) 183.16,38.24 JDIMM2.187
DDR_B_D23: length 83.4
  IN1 w0.084: v1(182.52,36.08) 182.15,36.08 182.07,36.16 182.07,38.13 180.44,39.76 180.44,40.83 180.33,40.94 180.21,40.94 180.1,40.83 179.99,40.83 171.15,49.67 171.15,49.79 171.25,49.89 171.25,50.01 171.13,50.13 171.01,50.13 170.91,50.02 170.79,50.02 170.67,50.14 170.67,50.26 170.78,50.37 170.78,50.48 170.66,50.6 170.54,50.6 170.44,50.5 170.32,50.5 170.2,50.62 170.2,50.74 170.3,50.84 170.3,50.96 170.18,51.08 170.07,51.08 169.96,50.97 169.84,50.97 169.72,51.09 169.72,51.21 169.83,51.31 169.83,51.43 169.7,51.57 169.12,51.57 168.28,52.4 166.17,52.4 165.75,52.82 163.86,52.82 163.38,53.3 157.01,53.3 156.06,54.25 150.74,54.25 150.58,54.09 146.62,54.09 146.31,54.4 137.68,54.4 132.43,59.66 132.43,67.18 130.37,69.23 129.89,69.23 128.53,70.59 128.13,70.59 127.76,70.95 v1(127.21,70.95)
  BOTTOM w0.089: v1(127.21,70.95) 126.73,70.47 126.45,70.47 126.16,70.76 UC1.AJ32
  BOTTOM w0.127: JDIMM2.183 182.16,38.11 181.95,37.9 181.95,36.64 v1(182.52,36.08)
DDR_B_D24: length 84.3
  IN4 w0.084: v1(129.35,71.95) 128.99,71.59 128.99,70.16 130.77,68.39 131.34,68.39 132.12,67.6 133.63,67.6 133.79,67.76 134.87,67.76 135.03,67.6 135.92,67.6 136.16,67.84 136.94,67.84 139.65,65.13 139.65,61.36 140.04,60.97 140.04,60.71 140.71,60.04 140.71,58.33 140.81,58.23 140.81,53.85 143.3,51.36 143.55,51.36 146.23,48.68 146.81,48.68 147.99,47.49 148.77,47.49 155.07,41.19 157.03,41.19 159.58,38.65 182.73,38.65 183.3,38.07 183.3,36.53 183.38,36.45 183.56,36.45 183.65,36.36 183.65,36.2 183.56,36.11 183.38,36.11 183.3,36.03 183.3,35.84 183.38,35.76 v1(184.38,35.76)
  BOTTOM w0.089: UC1.AR31 v1(129.35,71.95)
  BOTTOM w0.127: JDIMM2.191 184.16,38.12 183.62,37.59 183.62,36.21 184.07,35.76 v1(184.38,35.76)
DDR_B_D25: length 83.5
  IN4 w0.084: v1(129.35,71.31) 129.17,71.13 129.17,70.23 130.84,68.56 131.41,68.56 131.56,68.41 136.72,68.41 139.41,65.72 139.41,65.62 139.83,65.2 139.83,63.58 140.37,63.03 140.37,60.62 140.89,60.11 140.89,58.46 141.1,58.24 141.1,53.97 143.42,51.65 144.31,51.65 144.47,51.49 145.28,51.49 146.06,50.72 146.06,50.24 147.04,49.26 147.38,49.26 147.77,48.87 147.77,48.38 148.37,47.78 148.89,47.78 155.19,41.48 157.17,41.48 159.71,38.95 160.16,38.95 160.24,39.03 160.24,39.12 160.33,39.2 160.49,39.2 160.58,39.12 160.58,39.03 160.66,38.95 160.83,38.95 160.91,39.03 160.91,39.12 161,39.2 161.16,39.2 161.25,39.12 161.25,39.03 161.33,38.95 161.5,38.95 161.58,39.03 161.58,39.12 161.67,39.2 161.83,39.2 161.92,39.12 161.92,39.03 162,38.95 162.17,38.95 162.25,39.03 162.25,39.12 162.34,39.2 162.5,39.2 162.59,39.12 162.59,39.03 162.67,38.95 162.84,38.95 162.92,39.03 162.92,39.12 163.01,39.2 163.18,39.2 163.26,39.12 163.26,39.03 163.34,38.95 163.53,38.95 163.61,39.03 163.61,39.12 163.7,39.2 163.86,39.2 163.95,39.12 163.95,39.03 164.03,38.95 164.2,38.95 164.28,39.03 164.28,39.12 164.37,39.2 164.53,39.2 164.62,39.12 164.62,39.03 164.7,38.95 164.87,38.95 164.95,39.03 164.95,39.12 165.04,39.2 165.2,39.2 165.29,39.12 165.29,39.03 165.37,38.95 165.54,38.95 165.62,39.03 165.62,39.12 165.71,39.2 165.88,39.2 165.96,39.12 165.96,39.03 166.04,38.95 166.23,38.95 166.31,39.03 166.31,39.12 166.4,39.2 166.56,39.2 166.65,39.12 166.65,39.03 166.73,38.95 166.92,38.95 167,39.03 167,39.12 167.08,39.2 167.25,39.2 167.34,39.12 167.34,39.03 167.42,38.95 167.6,38.95 167.69,39.03 167.69,39.12 167.77,39.2 167.94,39.2 168.02,39.12 168.02,39.03 168.11,38.95 182.96,38.95 183.59,38.32 183.59,37.37 183.67,37.28 v1(184.38,37.28)
  BOTTOM w0.089: UC1.AR32 v1(129.35,71.31)
  BOTTOM w0.127: JDIMM2.195 185.16,38.06 v1(184.38,37.28)
