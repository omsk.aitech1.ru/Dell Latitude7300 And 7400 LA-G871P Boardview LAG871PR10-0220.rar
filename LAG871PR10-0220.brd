# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP1_P0_C: length 3
  BOTTOM w0.076: CT10.2 33.61,80.55 33.38,80.55 32.71,79.88 32.26,79.88 32.14,80 31.75,80 arc(31.62,79.97) 31.51,79.9 UT1.AB7
CPU_DP1_P1: length 131.8
  IN4 w0.094: v1(126.55,88.04) 126.26,88.33 126.19,88.33 126,88.52 126,90.28 126.18,90.46 126.18,98.12 126.84,98.78 126.84,101.76 124.03,104.57 124.03,104.98 120.94,108.07 112.93,108.07 111.93,107.07 101.65,107.07 100.99,107.73 94.09,107.73 91.64,105.28 83.78,105.28 83.61,105.11 78.35,105.11 77.49,104.25 71.03,104.25 70.54,104.75 61.83,104.75 60.21,106.37 54.06,106.37 48.25,100.57 47.75,100.57 45.4,98.21 45.4,96.16 44.46,95.22 44.46,91.79 44.62,91.63 44.62,88.99 43.05,87.42 43.05,86.43 40.4,83.77 40.4,82.54 39.72,81.86 37.75,81.86 37.1,81.22 37.1,79.71 36.75,79.37 35.55,79.37 v1(35.36,79.18)
  BOTTOM w0.089: v1(126.55,88.04) UC1.AJ6
  BOTTOM w0.104: v1(35.36,79.18) 35.23,79.31 34.66,79.31 CT12.1
CPU_DP1_P1_C: length 2.8
  BOTTOM w0.076: UT1.AB9 31.54,78.69 arc(31.61,78.64) 31.7,78.62 32.02,78.62 32.42,79.01 32.86,79.01 33.03,79.18 33.74,79.18 CT12.2
CPU_DP1_P2: length 130.3
  IN4 w0.094: v1(34.71,77.83) 34.71,78.03 34.81,78.13 34.96,78.13 35.03,78.06 36.62,78.06 37.86,79.3 37.86,80.9 38.25,81.28 40,81.28 40.98,82.26 40.98,83.53 43.63,86.19 43.63,87.18 45.2,88.75 45.2,91.91 45.05,92.07 45.05,94.87 46.06,95.88 46.06,97.22 52.67,103.83 54.64,103.83 56.04,105.22 60.27,105.22 61.93,103.57 65.3,103.57 65.72,103.99 70.19,103.99 70.61,103.58 78.06,103.58 79.01,104.53 84.1,104.53 84.21,104.64 91.89,104.64 94.37,107.12 100.46,107.12 101.15,106.43 112.15,106.43 112.46,106.74 121.44,106.74 123.38,104.8 123.38,104.07 124.33,103.12 124.33,101.38 125.55,100.17 125.55,90.47 125.08,90 125.08,89.57 124.97,89.47 124.97,89.15 125.08,89.05 125.08,88.48 124.98,88.38 124.81,88.38 124.7,88.49 v1(124.7,88.74)
  BOTTOM w0.076: UC1.AF5 v1(124.7,88.74)
  BOTTOM w0.104: CT14.1 34.38,78.11 34.55,78.11 34.71,77.94 v1(34.71,77.83)
CPU_DP1_P2_C: length 2.5
  BOTTOM w0.076: CT14.2 33.43,78.1 33.22,78.1 33.09,77.97 32.5,77.97 arc(32.34,77.94) 32.2,77.85 32.13,77.77 arc(32.05,77.72) 31.95,77.7 31.7,77.7 arc(31.61,77.72) 31.54,77.77 UT1.AB11
CPU_DP1_P3: length 122.5
  IN4 w0.094: v1(123.78,88.04) 123.51,88.31 123.43,88.31 123.22,88.52 123.22,96.55 122.94,96.83 122.94,99.51 119.78,102.67 116.28,102.67 114.49,104.45 94.28,104.45 91.63,101.79 81.3,101.79 80.16,100.65 77.02,100.65 76.66,101 71.29,101 70.57,101.73 61.04,101.73 60.78,102 53.35,102 49.76,98.41 49.76,96.81 48.38,95.42 48.38,93.69 47.38,92.69 47.38,88.89 46.97,88.49 46.97,85.28 45.79,84.09 45,84.09 44.23,83.32 44.23,82.95 38.75,77.47 37.92,77.47 37.1,76.65 35.56,76.65 v1(35.39,76.48)
  BOTTOM w0.089: v1(123.78,88.04) UC1.AE6
  BOTTOM w0.104: CT16.1 34.32,76.7 35.17,76.7 v1(35.39,76.48)
CPU_DP1_P3_C: length 2.4
  BOTTOM w0.076: CT16.2 33.29,76.66 32.96,76.66 32.74,76.89 32.2,76.89 32.09,76.78 31.7,76.78 arc(31.61,76.8) 31.54,76.85 UT1.AB13
CPU_DP2_AUXN: length 118.6
  TOP w0.104: v1(38.16,72.33) 38.49,72.66 38.49,72.81 38.28,73.02 37.79,73.02 37.66,72.89 37.38,72.89 CT175.1
  IN4 w0.094: v1(120.74,97.71) 120.74,97.71 119.8,97.71 119.7,97.81 119.7,98.74 118.12,100.33 113.79,100.33 112.59,101.53 100.22,101.53 99.45,102.31 96.09,102.31 92.38,98.6 81.98,98.6 81.74,98.36 76.08,98.36 75.96,98.47 73.48,98.47 73.11,98.1 66.07,98.1 65.87,97.91 63.19,97.91 62.29,98.81 57.85,98.81 57.37,99.29 54.26,99.29 52.52,97.54 52.52,94.4 50.37,92.26 50.37,88.79 49.24,87.65 49.24,84.51 46.15,81.42 45.73,81.42 40.78,76.47 40.78,74.49 39.59,73.3 38.46,73.3 38.23,73.06 38.23,72.4 v1(38.16,72.33)
  BOTTOM w0.076: UC1.AD4 123.08,89.55 123.35,90.12 123.35,90.34 123.22,90.48 123.22,93.7 122.95,93.97 122.95,96.16 122.95,96.89 122.25,97.59 120.86,97.59 v1(120.74,97.71)
CPU_DP2_AUXN_C: length 11.6
  TOP w0.104: v1(35.29,72.06) 35.49,72.26 35.71,72.26 36.03,72.57 36.23,72.57 CT175.2
  IN4 w0.094: v1(35.29,72.06) 35.04,72.31 33.1,72.31 32.35,73.06 32.09,73.06 31.71,73.44 31.71,76.33 30.99,77.06 30.13,77.06 29.93,77.26 29.93,77.56 v1(29.7,77.79)
  BOTTOM w0.104: UT1.W12 v1(29.7,77.79)
CPU_DP2_AUXP: length 118.5
  TOP w0.104: v1(38.74,72.33) 38.74,72.83 38.36,73.21 37.71,73.21 37.58,73.08 CT169.1
  IN4 w0.094: v1(38.74,72.33) 38.41,72.67 38.41,72.99 38.54,73.12 39.67,73.12 40.96,74.42 40.96,76.39 45.81,81.24 46.22,81.24 49.42,84.43 49.42,87.57 50.56,88.71 50.56,92.18 52.7,94.32 52.7,97.46 54.34,99.1 57.29,99.1 57.77,98.62 62.22,98.62 63.12,97.72 65.95,97.72 66.14,97.92 73.19,97.92 73.56,98.29 75.88,98.29 76,98.17 81.81,98.17 82.06,98.42 92.46,98.42 96.16,102.12 99.38,102.12 100.15,101.35 112.51,101.35 113.72,100.15 118.04,100.15 119.52,98.67 119.52,97.73 119.72,97.53 120.36,97.53 v1(120.74,97.16)
  BOTTOM w0.076: v1(120.74,97.16) 121,97.42 122.18,97.42 122.79,96.82 122.79,96.23 122.78,96.23 122.78,93.88 123.05,93.61 123.05,90.61 122.99,90.54 122.85,90.54 122.77,90.47 122.77,90 122.85,89.92 123.01,89.92 123.09,90 UC1.AD3
CPU_DP2_AUXP_C: length 11.6
  TOP w0.104: CT169.2 36.04,72.77 35.95,72.77 35.63,72.45 35.48,72.45 v1(35.29,72.64)
  IN4 w0.094: v1(30.35,77.79) 30.12,77.56 30.12,77.33 30.21,77.24 31.06,77.24 31.9,76.41 31.9,73.51 32.17,73.24 32.43,73.24 33.18,72.49 35.14,72.49 v1(35.29,72.64)
  BOTTOM w0.104: v1(30.35,77.79) 30.35,77.47 30.42,77.4 30.61,77.4 UT1.Y12
CPU_DP2_CTRL_CLK: length 13.7
  TOP w0.127: RC176.1 153.55,100.01 153.3,99.75 153.3,99.24 v1(153.42,99.12)
  BOTTOM w0.076: 151.01,96.48 151.01,96.47 151.67,95.81 151.67,94.25 149.85,92.43 149.85,90.83 149.75,90.72 149.75,90.42 149.67,90.34 149.67,90.04 149.94,89.77 UC1.CH4
  BOTTOM w0.127: 151.01,96.48 151,96.76 151,97.48 152.2,98.67 153.15,98.67 153.42,98.95 153.42,99.12 v1(153.42,99.12)
CPU_DP2_CTRL_DATA: length 14.1
  TOP w0.127: RC502.1 154.31,99.94 v1(153.87,99.5) 153.99,99.37 v2(155,99.37)
  BOTTOM w0.076: UC1.CH3 149.94,90.59 150.03,90.69 150.03,92.37 151.83,94.18 151.83,95.88 151.43,96.28 151.43,96.39 151.51,96.47 151.51,96.48
  BOTTOM w0.127: 151.51,96.48 151.51,96.76 151.51,97.27 152.41,98.16 153.36,98.16 153.93,98.74 153.93,99.33 153.87,99.39 v1(153.87,99.5)
CPU_DP2_HPD: length 262.9
  TOP w0.127: v2(55.38,48.84) 54.78,49.43 v1(54.74,49.43) ; v1(30.35,79.75) 30.39,79.79 RT29.1
  IN1 w0.084: v1(28.98,34.67) 28.98,35.35 29.48,35.86 29.48,42.48 30.31,43.31 30.31,49.77 27.6,52.47 27.6,57.12 28.19,57.71 28.19,59.92 25.66,62.45 25.66,62.99 24.69,63.95 24.69,71.99 26.13,73.42 30.43,73.42 30.74,73.72 30.74,79.63 30.62,79.75 v1(30.35,79.75)
  IN2 w0.102: v1(156.48,87.47) 157.34,88.32 160.82,88.32 162.31,86.84 165.43,86.84 166.54,87.94 169.57,87.94 v1(170.14,88.51)
  IN3 w0.122: v1(170.14,88.51) 169.69,88.07 169.46,88.07 169.14,87.75 169.14,86.93 167.91,85.71 165.98,85.71 165.09,84.81 163.67,84.81 158.09,79.23 158.09,76.63 157.8,76.35 155.73,76.35 153.9,74.52 153.9,71.58 151.77,69.45 150.1,69.45 149.18,68.52 149.18,67.32 148.93,67.06 148.93,64.09 148.65,63.81 148.65,61.91 147.83,61.09 145.35,61.09 144.74,61.7 143.75,61.7 142.89,62.55 142.89,66.05 142.47,66.47 142.31,66.47 141.65,67.12 137.96,67.12 137.01,68.06 136.32,68.06 135.83,67.57 135.83,58.47 132.91,55.55 90.43,55.55 87.1,52.22 73.15,52.22 72.81,51.89 69.95,51.89 69.16,52.68 65.88,52.68 64.49,51.28 62.93,51.28 62.22,50.57 60.79,50.57 60.74,50.52 57.33,50.52 56.24,49.43 v1(54.74,49.43)
  IN4 w0.084: v1(28.98,34.67) 29.48,34.67 29.91,35.1 30.38,35.1 31.07,34.41 35.55,34.41 41.41,40.27 41.41,41.17 43.36,43.12 46.84,43.12 48.84,45.12 48.84,45.87 49.45,46.48 50.53,46.48 53.1,49.06 54.37,49.06 54.74,49.43 v1(54.74,49.43)
  BOTTOM w0.076: UC1.CM6 152.18,87.8 152.74,87.8 152.85,87.84 153.09,87.84 153.2,87.8 153.39,87.8 153.5,87.84 153.74,87.84 153.88,87.79 154.77,87.79 154.99,88.01 155.54,88.01 155.64,87.91 156.04,87.91 v1(156.48,87.47)
  BOTTOM w0.127: v1(30.35,79.75) 30.67,80.07 UT1.Y6
CPU_DP2_N0: length 120.9
  IN4 w0.094: v1(121.94,92.82) 121.94,92.82 122.47,92.82 122.82,93.17 122.82,96.11 122.49,96.44 122.49,99.38 119.7,102.17 115.06,102.17 113.18,104.05 94.47,104.05 91.76,101.34 81.46,101.34 80.37,100.25 76.85,100.25 76.5,100.6 71.1,100.6 70.37,101.33 60.88,101.33 60.61,101.6 53.51,101.6 50.18,98.26 50.18,96.5 48.85,95.17 48.85,93.55 47.82,92.53 47.82,88.77 47.38,88.33 47.38,85.13 45.95,83.69 45.43,83.69 44.92,83.19 44.92,83.08 38.73,76.89 37.91,76.89 36.57,75.56 34.87,75.56 v1(34.7,75.73)
  BOTTOM w0.076: UC1.AC4 122.52,89.47 122.27,89.72 122.27,89.97 122.09,90.39 122.09,90.63 122.13,90.73 122.13,90.95 122.09,91.05 122.09,91.39 122.25,91.54 122.25,92.51 v1(121.94,92.82)
  BOTTOM w0.104: CT176.1 34.3,75.63 34.61,75.63 v1(34.7,75.73)
CPU_DP2_N0_C: length 2.5
  BOTTOM w0.076: UT1.AC15 31.74,76.09 arc(31.66,76.12) 31.63,76.2 arc(31.67,76.28) 31.75,76.32 32.11,76.32 32.29,76.14 32.49,76.14 32.69,75.94 32.9,75.94 33.15,75.69 33.28,75.69 CT176.2
CPU_DP2_N1: length 119.8
  IN4 w0.094: v1(35.33,73.76) 35.49,73.92 36.02,73.92 37.97,75.88 38.8,75.88 45.33,82.4 45.74,82.4 48.19,84.86 48.19,88.06 49.38,89.24 49.38,92.73 49.98,93.34 49.98,94.19 51,95.21 51,97.98 53.85,100.83 60.01,100.83 60.28,100.57 62.55,100.57 63.54,99.57 70.63,99.57 70.87,99.82 76.2,99.82 76.53,99.49 80.83,99.49 81.87,100.52 92.91,100.52 95.67,103.29 112.61,103.29 114.49,101.4 119.34,101.4 121.34,99.4 121.34,96.76 120.98,96.4 120.98,95.38 121.3,95.06 121.6,95.06 v1(121.87,94.79)
  BOTTOM w0.076: UC1.AC1 122.63,91.16 122.7,91.23 122.7,92.82 122.62,92.89 122.52,92.89 122.47,92.95 122.47,93.14 122.54,93.21 122.63,93.21 122.7,93.29 122.7,93.47 122.63,93.54 122.53,93.54 122.46,93.62 122.46,95.25 122.37,95.34 122.2,95.34 122.12,95.25 122.12,94.87 122.04,94.79 v1(121.87,94.79)
  BOTTOM w0.104: v1(35.33,73.76) 35.14,73.95 34.93,73.95 34.54,74.34 34.31,74.34 34.12,74.15 CT171.1
CPU_DP2_N1_C: length 2.9
  BOTTOM w0.076: UT1.AC17 31.74,75.17 arc(31.66,75.14) 31.62,75.06 arc(31.66,74.97) 31.74,74.94 32.09,74.94 32.26,75.11 32.77,75.11 32.9,74.99 32.9,74.61 33.11,74.39 33.3,74.39 CT171.2
CPU_DP2_N2: length 127.8
  IN4 w0.094: v1(124.31,96.77) 123.93,97.15 123.93,97.52 123.52,97.93 123.52,100.54 120.02,104.05 120.02,104.1 119.09,105.03 93.93,105.03 92.38,103.48 88.82,103.48 88.02,102.68 79.58,102.68 78.51,101.61 73.2,101.61 72.45,102.36 61.23,102.36 59.58,104.01 56.85,104.01 55.44,102.61 53.13,102.61 49.08,98.56 49.08,97.03 47.78,95.74 47.78,93.96 46.55,92.73 46.55,90.04 46.39,89.88 46.39,86.45 45.61,85.67 45.34,85.67 42.98,83.31 42.98,82.59 38.64,78.24 37.87,78.24 37.09,77.46 35.17,77.46 34.11,76.4 34.11,73.28 34.2,73.18 34.33,73.18 v1(34.68,73.53)
  BOTTOM w0.076: v1(124.31,96.77) 123.81,96.28 123.81,94.56 123.93,94.45 123.93,91.71 123.93,91.71 123.93,91.54 124.08,91.39 124.08,91.05 124.04,90.95 124.04,90.73 124.08,90.63 124.08,90.38 123.93,90.04 123.93,89.73 123.65,89.45 UC1.AE4
  BOTTOM w0.104: v1(34.68,73.53) 34.49,73.34 34.31,73.34 CT168.1
CPU_DP2_N2_C: length 3.2
  BOTTOM w0.076: UT1.AC19 31.74,74.25 arc(31.66,74.28) 31.63,74.36 arc(31.67,74.44) 31.75,74.48 32.11,74.48 32.23,74.35 32.65,74.35 33.03,73.97 33.03,73.46 33.21,73.28 33.3,73.28 CT168.2
CPU_DP2_N3: length 121
  IN4 w0.094: v1(120.71,99.48) 119.92,99.48 118.39,101 114.07,101 112.18,102.89 95.85,102.89 93.02,100.06 83.38,100.06 82.7,99.38 81.68,99.38 81.39,99.09 76.24,99.09 75.95,99.37 71.14,99.37 70.88,99.11 63.01,99.11 62.73,99.39 59.87,99.39 59.39,99.87 54.02,99.87 51.74,97.59 51.74,94.48 49.79,92.52 49.79,89.02 48.65,87.89 48.65,84.75 45.9,82 45.49,82 39.69,76.21 39.69,74.23 39.35,73.88 37.32,73.88 36.66,73.23 36.66,72.58 35.74,71.66 35.33,71.66 35.13,71.46 35.13,71.37 v1(34.81,71.05)
  BOTTOM w0.076: UC1.AE1 123.55,91.27 123.55,93.84 123.41,93.97 123.41,97.32 122.82,97.91
  BOTTOM w0.104: v1(120.71,99.48) 121,99.48 121.1,99.37 121.1,99.14 121.2,99.03 122.48,99.03 122.82,98.7 122.82,97.91 ; v1(34.81,71.05) 35.07,71.31 35.07,71.45 34.96,71.56 34.74,71.56 34.6,71.7 34.6,71.93 34.51,72.02 34.37,72.02 34.16,71.81 CT170.1
CPU_DP2_N3_C: length 3.1
  BOTTOM w0.076: CT170.2 33.22,72.16 32.91,72.16 32.73,72.33 32.73,72.7 32.23,73.2 32.12,73.2 32.03,73.1 31.74,73.1 arc(31.66,73.13) 31.62,73.22 arc(31.66,73.3) 31.74,73.33 UT1.AC21
CPU_DP2_P0: length 121
  IN4 w0.094: v1(34.7,75.14) 34.7,75.23 34.84,75.38 36.65,75.38 37.98,76.71 38.81,76.71 45.1,83 45.1,83.11 45.5,83.51 46.03,83.51 47.57,85.05 47.57,88.25 48,88.69 48,92.45 49.03,93.48 49.03,95.09 50.36,96.43 50.36,98.19 53.59,101.41 60.53,101.41 60.8,101.15 70.3,101.15 71.02,100.42 76.42,100.42 76.78,100.07 80.45,100.07 81.54,101.16 91.83,101.16 94.54,103.87 113.11,103.87 114.99,101.99 119.62,101.99 122.31,99.3 122.31,96.36 122.63,96.04 122.63,93.24 122.4,93.01 122.32,93.01 122.23,93.1 122.23,93.36 122.07,93.52 v1(121.85,93.52)
  BOTTOM w0.076: UC1.AC3 122.51,89.88 122.26,90.45 122.26,90.61 122.29,90.7 122.29,90.98 122.26,91.07 122.26,91.32 122.41,91.47 122.41,92.58 122.29,92.7 122.29,93.01 121.85,93.45 v1(121.85,93.52)
  BOTTOM w0.104: CT177.1 34.18,75.43 34.41,75.43 v1(34.7,75.14)
CPU_DP2_P0_C: length 2.5
  BOTTOM w0.076: CT177.2 33.26,75.52 33.08,75.52 32.83,75.77 32.62,75.77 32.42,75.97 32.2,75.97 32.09,75.86 31.7,75.86 arc(31.61,75.88) 31.54,75.93 UT1.AB15
CPU_DP2_P1: length 119.9
  IN4 w0.094: v1(35.33,74.35) 35.57,74.11 35.94,74.11 37.9,76.06 38.72,76.06 45.25,82.59 45.67,82.59 48.01,84.93 48.01,88.13 49.19,89.31 49.19,92.81 49.8,93.41 49.8,94.27 50.81,95.28 50.81,98.06 53.77,101.01 60.08,101.01 60.35,100.75 62.62,100.75 63.62,99.75 70.55,99.75 70.8,100 76.28,100 76.61,99.67 80.76,99.67 81.79,100.7 92.83,100.7 95.6,103.47 112.69,103.47 114.57,101.58 119.41,101.58 121.53,99.47 121.53,96.68 121.16,96.32 121.16,95.45 121.37,95.24 121.61,95.24 v1(121.87,95.5)
  BOTTOM w0.076: UC1.AC2 122.87,91.19 122.87,91.3 122.87,93.54 122.82,93.59 122.62,93.78 122.62,95.32 122.44,95.5 v1(121.87,95.5)
  BOTTOM w0.104: CT172.1 34.12,74.73 34.31,74.54 34.62,74.54 35,74.16 35.14,74.16 v1(35.33,74.35)
CPU_DP2_P1_C: length 2.9
  BOTTOM w0.076: UT1.AB17 31.51,75.3 arc(31.62,75.37) 31.75,75.4 32.17,75.4 32.29,75.28 32.84,75.28 33.06,75.06 33.06,74.68 33.18,74.56 33.37,74.56 CT172.2
CPU_DP2_P2: length 127.9
  IN4 w0.094: v1(34.68,72.94) 34.67,72.95 34.17,72.95 33.92,73.2 33.92,76.48 35.09,77.64 37.01,77.64 37.79,78.43 38.56,78.43 42.8,82.67 42.8,83.38 45.27,85.85 45.53,85.85 46.21,86.52 46.21,89.95 46.37,90.11 46.37,92.81 47.6,94.04 47.6,95.82 48.9,97.11 48.9,98.63 53.05,102.79 55.37,102.79 56.77,104.2 59.65,104.2 61.31,102.55 72.53,102.55 73.28,101.79 78.44,101.79 79.5,102.86 87.94,102.86 88.75,103.66 92.3,103.66 93.85,105.21 119.16,105.21 120.2,104.18 120.2,104.12 123.71,100.62 123.71,98.01 v1(124.31,97.41)
  BOTTOM w0.076: v1(124.31,97.41) 124.02,97.12 124.02,97.12 123.95,97.05 123.95,96.65 123.65,96.35 123.65,95.45 123.65,94.49 123.76,94.38 123.76,91.71 123.76,91.71 123.76,91.47 123.91,91.32 123.91,91.07 123.88,90.98 123.88,90.7 123.91,90.61 123.91,90.42 123.69,89.91 UC1.AE3
  BOTTOM w0.104: v1(34.68,72.94) 34.48,73.15 34.33,73.15 CT174.1
CPU_DP2_P2_C: length 3.1
  BOTTOM w0.076: CT174.2 33.38,73.12 33.37,73.11 33.14,73.11 32.86,73.39 32.86,73.9 32.58,74.19 32.26,74.19 32.09,74.02 31.7,74.02 arc(31.61,74.04) 31.54,74.09 UT1.AB19
CPU_DP2_P3: length 121.1
  IN4 w0.094: v1(120.71,98.84) 120.37,98.84 120.28,98.94 120.28,99.2 120.18,99.29 119.84,99.29 118.31,100.82 113.99,100.82 112.11,102.7 95.92,102.7 93.1,99.88 83.46,99.88 82.78,99.2 81.76,99.2 81.46,98.9 76.16,98.9 75.88,99.19 71.22,99.19 70.96,98.93 62.93,98.93 62.65,99.21 59.79,99.21 59.31,99.69 54.1,99.69 51.92,97.51 51.92,94.4 49.97,92.45 49.97,88.94 48.84,87.81 48.84,84.67 45.98,81.82 45.56,81.82 39.88,76.13 39.88,74.15 39.42,73.7 37.4,73.7 36.85,73.15 36.85,72.51 35.82,71.48 35.41,71.48 35.31,71.39 35.31,71.13 v1(35.39,71.05)
  BOTTOM w0.076: 122.62,97.91 122.62,97.9 122.64,97.89 122.64,97.84 122.74,97.73 122.76,97.73 123.25,97.25 123.25,93.91 123.38,93.77 123.38,93.47 123.38,91.01 UC1.AE2
  BOTTOM w0.104: v1(120.71,98.84) 122.4,98.84 122.62,98.62 122.62,97.91 ; v1(35.39,71.05) 35.26,71.19 35.26,71.55 34.59,72.21 34.31,72.21 CT173.1
CPU_DP2_P3_C: length 3
  BOTTOM w0.076: CT173.2 33.5,72.32 32.98,72.32 32.9,72.4 32.9,72.76 32.11,73.56 31.75,73.56 arc(31.62,73.53) 31.51,73.46 UT1.AB21
CPU_DP3_AUXN: length 9.5
  TOP w0.127: T1.1 124.85,94.87 v1(124.31,94.87)
  IN1 w0.084: v1(125.63,87.4) 125.39,87.63 125.2,87.63 125.08,87.75 125.08,89.88 125.04,89.93 125.04,94.14 v1(124.31,94.87)
  BOTTOM w0.089: v1(125.63,87.4) UC1.AG7
CPU_DP3_AUXP: length 9.7
  TOP w0.127: T2.1 123.66,95.5 v1(124.31,95.5)
  IN1 w0.084: v1(124.31,95.5) 125.31,94.49 125.31,92.99 125.26,92.93 125.26,87.88 125.32,87.82 125.41,87.82 v1(125.63,88.04)
  BOTTOM w0.089: v1(125.63,88.04) UC1.AG6
CPU_GC6_FB_EN: length 4.1
  TOP w0.127: v1(153.76,67.49) 153.61,67.34 T383.1
  BOTTOM w0.089: 152.14,68.11 151.9,68.36 151.9,68.69 152.06,68.84 152.06,68.84 UC1.CM35
  BOTTOM w0.114: v1(153.76,67.49) 152.76,67.49 152.14,68.11
CPU_POPIRCOMP: length 1.2
  TOP w0.356: v1(142.1,74.43) 142.31,74.63 RC106.1
  BOTTOM w0.254: UC1.BP27 v1(142.1,74.43)
CPU_XDP_PRDY#: length 66.7
  TOP w0.127: v1(72.53,101.74) 72.53,101.41 v2(72.14,101.02)
  IN2 w0.122: v1(119.43,93.6) 119.43,93.57 118.53,92.67 118.08,92.67 117.4,91.99 112.42,91.99 111.28,93.12 111.28,93.33 109.93,94.67 109.93,98.47 109.1,99.31 107.24,99.31 105.29,101.25 103.86,101.25 103.7,101.41 102.4,101.41 101.09,102.71 93.4,102.71 92.39,101.7 80.78,101.7 79.95,100.87 77.89,100.87 77.36,101.4 72.87,101.4 v1(72.53,101.74)
  BOTTOM w0.076: UC1.W1 120.08,92.94 120.01,93.02
  BOTTOM w0.114: 120.01,93.02 v1(119.43,93.6)
  BOTTOM w0.127: v1(72.53,101.74) 72.87,101.4 73.53,101.4 74.71,100.22 74.71,98.73 74.05,98.07 73.85,98.07 73.09,97.31 72.82,97.31 72.68,97.18 JXDP1.5
CPU_XDP_PREQ#: length 72.4
  TOP w0.127: v2(86.12,109.05) 85.68,108.6 RC138.2 85.4,107.98 85.16,107.74 85.16,106.01 v1(85.29,105.88)
  IN2 w0.122: v1(85.29,105.88) 85.29,105.84 85.75,105.39 87.43,105.39 87.71,105.11 91.57,105.11 92.16,105.7 102.33,105.7 103.2,104.83 109.93,104.83 113.23,101.54 116.21,101.54 117.16,100.58 117.16,96.64 118.3,95.5 v1(119.43,95.5)
  BOTTOM w0.076: 119.83,93.69 119.83,93.53 120.34,93.02 120.34,91 120.08,90.75 UC1.W2
  BOTTOM w0.114: 119.83,93.69 119.83,95.1 v1(119.43,95.5)
  BOTTOM w0.127: JXDP1.3 73.28,97.18 73.94,97.84 74.14,97.84 74.94,98.64 74.94,100.31 72.9,102.35 72.9,103.19 73.14,103.43 81.24,103.43 83.21,105.4 84.96,105.4 85.29,105.74 v1(85.29,105.88)
CPU_XDP_TCLK: length 74.8
  TOP w0.127: v1(106.46,93.53) 106.46,93.84 v3(105.29,95.01) 104.95,95.35 104.95,96.44 RC328.1 ; v1(57.5,95.71) 57.16,96.06 RC139.1
  IN2 w0.122: v1(106.46,93.53) 105.71,93.53 105.67,93.49 101.96,93.49 100.94,94.51 99.62,94.51 98.4,95.73 93.78,95.73 93.1,96.41 79.26,96.41 78.81,95.97 71.77,95.97 71.52,95.72 70.08,95.72 69.52,95.16 68.71,95.16 68.27,95.61 67.52,95.61 65.95,94.04 64.2,94.04 63.98,94.27 60.99,94.27 60.52,94.74 58.01,94.74 57.5,95.24 v1(57.5,95.71)
  IN4 w0.084: v1(118.23,88.04) 118.09,88.04 117.8,88.32 117.28,88.32 116.94,88.67 116.94,89.06 116.67,89.32 107.08,89.32 106.46,89.94 v1(106.46,93.53)
  BOTTOM w0.089: v1(118.23,88.04) UC1.T6
  BOTTOM w0.127: v1(57.5,95.71) 57.08,96.13 JXDP1.57
CPU_XDP_TDI: length 80.6
  TOP w0.127: v1(105,93.92) 104.55,93.47 102.37,93.47 v3(101.92,93.92) 101.73,93.92 101.42,94.23 RC134.1 ; RC851.1 57.32,101.96 v1(57.32,102.6)
  IN2 w0.122: v1(57.32,102.6) 57.32,102.34 57.64,102.02 60.04,102.02 61.11,100.96 70.45,100.96 71.12,100.28 76.88,100.28 77.42,99.75 80.41,99.75 81.24,100.58 91.89,100.58 92.36,100.11 99.51,100.11 99.69,100.29 103.24,100.29 103.39,100.14 104.73,100.14 105.11,99.76 105.11,94.03 v1(105,93.92)
  IN4 w0.076: v1(119.16,88.04) 118.78,88.41 118.78,89.12 116.87,91.03 112.68,91.03 111.64,91.03 111.28,90.67 109.67,90.67 109.11,91.23
  IN4 w0.102: 109.11,91.23 109.11,92.54 107.49,94.16 105.32,94.16 105.08,93.92 v1(105,93.92)
  BOTTOM w0.089: v1(119.16,88.04) UC1.U6
CPU_XDP_TDO: length 75.8
  TOP w0.127: RC135.1 105.99,96.42 105.99,95.95 v1(106,95.94) ; RC850.1 60.52,102.68 60.34,102.86 v3(60,102.86) v1(59.28,102.86)
  IN2 w0.122: v1(106,95.94) 106,96.71 106.39,97.11 106.39,99.52 105.11,100.81 103.67,100.81 103.52,100.96 100.79,100.96 99.48,102.27 94.98,102.27 93.96,101.25 80.97,101.25 80.13,100.42 77.71,100.42 77.17,100.95 71.4,100.95 70.72,101.63 61.38,101.63 60.32,102.69 59.45,102.69 v1(59.28,102.86)
  IN4 w0.076: 112.67,92.39 113.13,91.92 118.32,91.92 119.71,90.53 119.78,90.53 121.01,89.3 v1(121,88.67)
  IN4 w0.102: 112.67,92.39 110.75,92.39 110.04,93.1 110.04,93.54 108.07,95.51 106.1,95.51 106,95.61 v1(106,95.94)
  BOTTOM w0.089: v1(121,88.67) UC1.Y5
CPU_XDP_TMS: length 80
  TOP w0.127: v1(58.49,102.58) 57.84,103.23 57.03,103.23 56.7,102.9 v3(56.49,102.9) 56.43,102.83 56.27,102.67 RC852.1 ; v1(107.08,93.54) 107.08,93.94 105.45,95.56 105.45,96.45 RC131.1
  IN2 w0.122: v1(58.49,102.58) 58.49,102.37 58.61,102.24 60.14,102.24 61.2,101.18 70.54,101.18 71.21,100.51 76.98,100.51 77.51,99.97 80.32,99.97 81.15,100.81 94.21,100.81 95.23,101.82 99.3,101.82 100.6,100.51 103.33,100.51 103.49,100.36 104.84,100.36 105.33,99.87 105.33,94.7 106,94.03 106.59,94.03 v1(107.08,93.54)
  IN4 w0.076: 108.93,91.15 110.24,89.85 112.02,89.85 112.79,90.62 112.87,90.62 112.89,90.64 116.8,90.64 118.23,89.2 v1(118.23,88.67)
  IN4 w0.084: v1(107.08,93.54) 107.41,93.87 107.53,93.87 108.93,92.46 108.93,91.15
  BOTTOM w0.089: v1(118.23,88.67) UC1.T5
CPU_XDP_TRST#: length 83.1
  TOP w0.127: v3(108.78,96.62) 108.49,96.62 107.97,96.09 v1(107.97,95.9) ; RC853.1 54.5,100.26 v1(54.5,100.34)
  IN2 w0.122: v1(54.5,100.34) 54.5,100.57 55.95,102.02 57.18,103.25 59.44,103.25 59.78,102.91 60.41,102.91 61.48,101.85 70.82,101.85 71.49,101.18 77.26,101.18 77.8,100.64 80.04,100.64 80.87,101.48 93.8,101.48 94.82,102.49 99.58,102.49 100.88,101.18 103.61,101.18 103.76,101.03 105.2,101.03 106.61,99.62 106.61,99.43 106.61,97.26 v1(107.97,95.9)
  IN4 w0.076: 113.08,92.41 113.39,92.1 118.52,92.1 119.85,90.76 120,90.76 121.55,89.21 121.55,88.56 v1(121,88.02)
  IN4 w0.084: 112.9,92.59 113.08,92.41
  IN4 w0.102: v1(107.97,95.9) 110.24,93.63 110.24,93.19 110.79,92.64 112.85,92.64 112.9,92.59
  BOTTOM w0.089: UC1.Y6 v1(121,88.02) UC1.AB6
  BOTTOM w0.127: v1(107.97,95.9) 107.14,96.73 RC136.1
CPVEE: length 3.9
  TOP w0.127: CA77.1 285.59,35.82 v2(286.14,35.27)
  TOP w0.203: CA77.1 CA49.1 285.34,37.01 285.34,37.59 284.68,38.24 UA1.25
CSIN_CHG: length 5.3
  TOP w0.203: v1(46.42,56.76) 46.33,56.67 PU700.14
  BOTTOM w0.127: v2(46.92,55.88) 46.89,55.88 46.42,56.35 v1(46.42,56.76)
  BOTTOM w0.254: v1(46.42,56.76) 46.42,57.21 47.04,57.82 PC719.2 PC726.1 47.06,58.89 PR702.2
CSIN_CHG_R: length 30
  IN4 w0.254: v1(53.42,83.38) 53.42,82.39 50.45,79.42 50.45,76.85 45.73,72.12 45.73,64.83 44.58,63.68 44.58,61.42 44.9,61.11 45.28,61.11 v1(45.45,60.94)
  BOTTOM w0.127: v2(44.91,61.08) 45.31,61.08 v1(45.45,60.94)
  BOTTOM w0.254: v1(53.42,83.38) 53.78,83.74 PR700.3 ; PR702.1 45.7,61.2 v1(45.45,60.94)
CSIP_CHG: length 5.2
  TOP w0.203: v1(45.79,56.7) 45.93,56.56 PU700.15
  BOTTOM w0.127: v2(45.5,55.95) 45.79,56.24 v1(45.79,56.7)
  BOTTOM w0.254: PR701.2 45.05,58.08 PC725.1 45.19,57.94 PC719.1 46.13,57.48 45.79,57.14 v1(45.79,56.7)
CSIP_CHG_R: length 31.2
  TOP w0.127: v1(44.96,60.6) 44.96,60.2 v2(45.08,60.09)
  IN4 w0.254: v1(53.58,84.22) 52.97,83.61 52.97,82.44 50.09,79.57 50.09,77 45.28,72.18 45.28,65.02 44.2,63.94 44.2,61.22 44.82,60.6 v1(44.96,60.6)
  BOTTOM w0.254: PR700.2 53.1,83.74 v1(53.58,84.22) ; PR701.1 44.11,59.73 44.96,60.59 v1(44.96,60.6)
CSON_CHG: length 7.2
  TOP w0.203: PU700.1 49.22,52.45 49.41,52.26 49.41,51.62 50.3,50.74 50.3,50.35 v2(50.72,49.93) 50.91,49.74 52.1,49.74 PC752.2
  TOP w0.254: PR734.1 53.19,48.34 PC753.1 52.71,49.12 52.71,49.13 PC752.2
CSON_CHG_R: length 182.2
  TOP w0.254: PR734.2 54.23,45.9 v2(55.77,45.9) 61.12,45.9 v1(62.36,47.14)
  IN2 w0.254: v1(204.96,46.16) 205.05,46.16 205.07,46.18 213,46.18 219.03,40.15 227.13,40.15 v1(227.23,40.05)
  IN3 w0.254: v1(204.96,46.16) 203.83,46.16 203.11,46.88 153.49,46.88 152.27,45.65 146.56,45.65 145.7,46.52 144.03,46.52 143.25,47.3 141.2,47.3 138.66,49.84 94.91,49.84 92.78,47.71 83.49,47.71 83.02,47.24 62.46,47.24 v1(62.36,47.14)
  BOTTOM w0.254: PR711.3 227.87,40.61 227.31,40.05 v1(227.23,40.05)
CSOP_CHG: length 6.2
  TOP w0.203: PR733.1 53.08,50.48 PC752.1 51.85,50.48 51.4,50.93 PC748.1 51.38,51.42 v2(50.34,51.42) 50.05,51.42 49.77,51.7 49.77,52.61 49.53,52.85 PU700.2
CSOP_CHG_R: length 181.5
  TOP w0.254: PR733.2 54.69,50.13 v2(57.62,47.2) 58.01,46.82 61.39,46.82 v1(61.71,47.14)
  IN2 w0.254: v1(204.45,46.67) 204.45,46.67 205.17,46.67 205.3,46.54 213.15,46.54 219.18,40.51 227.12,40.51 v1(227.23,40.62)
  IN3 w0.254: v1(204.45,46.67) 204.45,46.67 203.82,46.67 203.26,47.23 153.34,47.23 152.12,46.01 146.71,46.01 145.85,46.88 144.18,46.88 143.4,47.66 141.37,47.66 138.61,50.41 94.91,50.41 92.57,48.06 83.34,48.06 82.87,47.6 62.17,47.6 v1(61.71,47.14)
  BOTTOM w0.254: v1(227.23,40.62) 227.22,40.61 PR711.2
CV2_ON: length 111.4
  TOP w0.127: v1(288.29,98.81) 287.24,97.75 RE539.2 ; v1(272.92,31.57) v2(272.92,32.37)
  IN2 w0.122: v1(295.69,98.34) 294.34,99.69 289.17,99.69 v1(288.29,98.81)
  IN4 w0.084: v1(295.69,98.34) 295.3,97.96 295.3,86.7 298.15,83.85 298.15,74.43 296.95,73.22 296.95,68.23 296.63,67.92 296.63,67.2 297.46,66.37 298.62,66.37 298.98,66.01 298.98,60.82 298.28,60.12 298.28,57.75 297.69,57.16 297.69,56.12 295.28,53.71 293.8,53.71 291.78,51.69 289.96,51.69 289.71,51.93 282.21,51.93 281.65,51.37 280.59,51.37 279.55,50.33 276.83,50.33 276.3,49.8 276.26,49.8 276.26,49.79 272.72,49.79 272.45,50.07 270.61,50.07 270.14,49.6 270.14,43.45 268.03,41.34 268.03,40.37 268.93,39.47 268.93,37.89 271.47,35.35 271.47,33.02 272.91,31.57 v1(272.92,31.57)
  BOTTOM w0.127: v1(272.92,31.57) 272.93,31.58 JUSH1.24
CV2_ON_R: length 28.6
  TOP w0.127: RE810.2 RE539.1 286.67,95.03 286.58,95.12 286.58,97.47 287.5,98.38 v2(287.5,99) 287.16,99.34 v1(286.26,99.34) ; v1(278.62,83.76) UE1.H8
  IN3 w0.122: v1(278.62,83.76) 279.03,84.17 282.09,84.17 282.21,84.29 282.21,85.07 281.88,85.4 281.88,87.24 282.09,87.45 282.09,89.07 284.39,91.37 284.39,93.43 286.07,95.11 286.07,99.15 v1(286.26,99.34)
DAT_TP_SIO_I2C_CLK: length 130.4
  TOP w0.102: 273.44,87.79 273.84,87.39 273.84,86.94 UE1.C12
  TOP w0.127: RZ347.2 249.31,29.52 249.21,29.62 RZ22.2 ; RZ347.2 249,29.17 v1(248.8,29.37) ; RZ347.2 249.47,29.17 249.85,28.78 CZ80.1 250.08,28.3 250.34,28.05 v2(251.97,28.05) ; v1(269.09,88.51) 269.58,88.02 271.19,88.02 271.6,88.43 272.8,88.43 273.44,87.79
  IN1 w0.084: v1(290.41,89.07) 289.95,89.07 288.1,90.91 284.23,90.91 283.47,90.16 282.46,90.16 281.83,90.79 278.97,90.79 278.51,90.33 276.53,90.33 275.61,89.41 274.58,89.41 273.82,88.65 271.56,88.65 271.23,88.32 269.28,88.32 v1(269.09,88.51)
  IN3 w0.122: v1(248.8,29.37) 249.18,29.75 249.78,29.75 250.06,29.47 253.51,29.47 254,29.96 259.4,29.96 261.94,32.5 263.91,32.5 265.21,33.8 268.83,33.8 270.01,34.98 270.23,34.98 270.87,35.62 272.68,35.62 273.18,35.11 275.22,35.11 277.48,37.37 277.48,46.07 279.62,48.21 279.62,48.22 279.83,48.42 279.83,49.53 280.87,50.57 281.66,50.57 281.7,50.6 282.97,51.88 284.38,51.88 287.09,54.58 287.09,56.06 287.98,56.95 288.93,56.95 289.31,57.33 289.31,57.96 290.46,59.11 290.46,63.08 290.35,63.19 290.35,65.42 292.26,67.33 292.26,69.7 290.59,71.38 290.59,73.09 292.17,74.67 292.17,77.21 292.86,77.9 292.86,81.87 291.92,82.82 291.92,84.94 290.53,86.32 290.53,87.78 290.19,88.12 290.19,88.85 v1(290.41,89.07)
DAT_TP_SIO_R: length 4.8
  TOP w0.127: RZ22.1 249.28,30.56 249.59,30.26 249.59,29.88 249.8,29.66 RZ18.2 250.08,29.66 CZ88.1 251,31.47 v1(251.08,31.55)
  BOTTOM w0.127: v1(251.08,31.55) JKBTP1.13
DCIN1_EN: length 17.5
  TOP w0.102: UE1.L12 280.62,86.82 281.1,87.3 281.1,87.49 281.31,87.71 281.31,88.23 281.7,88.62 v1(281.7,89.5)
  TOP w0.127: RE600.2 284.96,96.48 v2(285.33,96.85) 285.63,97.15 v1(285.63,98.8)
  IN3 w0.122: v1(281.7,89.5) 281.7,91.63 282.2,92.13 282.2,92.65 284.18,94.63 284.18,97.35 v1(285.63,98.8)
DCIN1_EN_R: length 348.8
  TOP w0.127: v1(285.5,99.34) 285.24,99.08 v2(285.24,98.23) 285.24,97.87 RE600.1
  TOP w0.254: PR28.1 50.92,94.85 51.51,95.44 PQ8.3 52.15,95.44 52.53,95.83 52.53,96.35 52.61,96.53 52.61,96.99 51.67,97.93 v1(51.67,98.06)
  IN2 w0.122: v1(285.5,99.34) 285.5,99.5 284.89,100.11 278.59,100.11 277.73,99.25 273.79,99.25 273.08,99.96 265.96,99.96 v1(264.92,98.93)
  IN3 w0.122: v1(264.92,98.93) 264.92,92.14 264.44,91.66 264.44,88.22 264.23,88 264.23,86.11 264.56,85.77 264.56,83.92 264.99,83.48 264.99,75.58 265.91,74.66 268.43,74.66 269.5,73.59 269.5,72.13 268.83,71.46 268.83,70.12 268.56,69.85 268.56,67.43 267.75,66.62 267.75,65.25 267.4,64.9 267.4,63.07 267.74,62.74 267.74,61.56 266.88,60.7 266.88,56.78 264.23,54.13 264.23,53.61 262.17,51.55 260.43,51.55 259.14,50.27 256.85,50.27 255.31,48.73 254.48,48.73 252.7,46.95 251.64,46.95 248.76,44.06 245.51,44.06 244.2,42.76 243.01,42.76 242.16,41.9 235.01,41.9 234.6,41.49 230.39,41.49 228.52,43.36 218.27,43.36 208.05,53.58 195.92,53.58 189.98,59.51 189.98,73.93 186.78,77.13 186.78,78.99 183.64,82.13 183.64,83.31 183.36,83.6 183.36,84.61 180.76,87.21 180.76,91.97 178.65,94.08 178.65,94.78 177.71,95.72 177.71,98.85 173.22,103.35 172.9,103.35 171.19,105.06 161.95,105.06 160.89,106.11 155.48,106.11 154.19,104.83 152.39,104.83 152,104.43 146.05,104.43 145.27,105.21 142.75,105.21 142.27,104.73 141.07,104.73 140.53,104.19 138.28,104.19 137.78,103.69 130.86,103.69 130.32,103.15 121.85,103.15 120.86,102.17 113.61,102.17 113.32,102.45 103.81,102.45 103.23,103.03 95.89,103.03 91.3,98.44 88.53,98.44 87.73,97.63 80.46,97.63 79.24,98.85 74.5,98.85 74.44,98.91 71.23,98.91 70.58,98.26 65.56,98.26 65.06,98.77 57.63,98.77 56.71,99.69 52.79,99.69 51.67,98.57 v1(51.67,98.06)
DCIN2_EN: length 10.6
  TOP w0.127: UE1.K4 279.82,80.07 v1(280.21,79.68) ; v2(286.01,74.62) v1(286.01,75.53) 285.73,75.81 RE601.1
  IN4 w0.084: v1(286.01,75.53) 286.01,75.94 284.36,77.59 282.26,77.59 281.57,78.29 281.57,78.86 281.05,79.37 280.52,79.37 v1(280.21,79.68)
DCIN2_EN_R: length 318.4
  TOP w0.127: RE601.2 285.2,74.59 v1(285.03,74.42) ; v2(43.97,101.11) 43.74,101.34 v1(43.5,101.34) 43.2,101.64 PR821.1 42.37,101.64 42.08,101.94 PQ807.3
  IN1 w0.084: v1(285.03,74.42) 284.49,74.42 284.1,74.03 284.1,73.61 283.44,72.95 280.35,72.95 280.04,72.64 277.62,72.64 277.29,72.31 271.95,72.31 271.38,71.74 270.71,71.74 269.08,73.38 268.49,73.38 268.24,73.13 267.53,72.42 267.53,71.76 v1(267.02,71.26)
  IN3 w0.122: v1(267.02,71.26) 267.28,71 267.28,70.86 267.89,70.25 267.89,68.05 265.94,66.1 265.94,62.9 265.42,62.37 265.42,60.5 266.21,59.7 266.21,57.16 263.56,54.5 263.56,53.89 261.89,52.22 260.15,52.22 259.59,51.67 257.3,51.67 255.03,49.4 254.2,49.4 252.73,47.93 250.56,47.93 247.37,44.73 245.23,44.73 243.92,43.43 242.74,43.43 241.88,42.57 234.73,42.57 234.32,42.16 230.67,42.16 228.8,44.03 218.55,44.03 208.33,54.25 196.24,54.25 195.29,55.2 195.29,57.66 190.65,62.29 190.65,74.21 187.46,77.41 187.46,79.26 185.13,81.59 185.13,82.93 184.03,84.03 184.03,85.64 181.43,88.24 181.43,92.33 179.96,93.8 179.96,94.67 178.45,96.19 178.45,99.07 173.49,104.02 173.17,104.02 171.47,105.73 162.22,105.73 161.17,106.78 153.58,106.78 152.81,106.01 148.15,106.01 147.02,107.14 141.47,107.14 140.4,106.08 135.67,106.08 135,105.41 122.1,105.41 122.1,105.4 115.65,105.4 114.62,104.37 113.76,104.37 113.53,104.13 104.08,104.13 103.91,104.31 94.03,104.31 90.86,101.14 81.77,101.14 80.36,102.56 67.39,102.56 67,102.17 51.12,102.17 50.84,101.88 46.52,101.88 45.57,102.83 44,102.83 43.47,102.3 43.47,101.37 v1(43.5,101.34)
DCIN_CHG: length 4.4
  TOP w0.203: v1(44.75,55.82) 44.53,55.82 44.33,55.62 44.33,55.41 44.49,55.25 PU700.17
  BOTTOM w0.508: v1(44.75,55.82) 44.19,55.82 v3(43.52,56.49) 42.61,57.4 v1(42.61,57.72)
DCPRTC: length 2.1
  TOP w0.089: 142.04,76.45 142.04,76.43 v1(141.74,76.12)
  TOP w0.127: v1(141.74,76.12) 141.21,76.65 CC76.1 ; 142.04,76.45 142.07,76.47 v2(142.07,76.54)
  BOTTOM w0.2: UC1.BP24 v1(141.74,76.12)
DDR_A_ACT#: length 65
  IN4 w0.102: v1(83.26,34.41) 82.51,35.16 82.51,37.93 83.06,38.48 83.63,38.48 83.73,38.58 83.73,41.73 85.69,43.69 85.83,43.69 86.03,43.49 86.17,43.49 86.32,43.63 86.32,43.78 86.12,43.97 86.12,44.12 86.26,44.26 86.41,44.26 86.6,44.06 86.75,44.06 86.89,44.21 86.89,44.35 86.69,44.55 86.69,44.69 91.79,49.79 106.06,49.79 115.86,59.6 115.86,63.09 v1(117.74,64.97)
  BOTTOM w0.076: UC1.V35 119.04,69.51 118.95,69.41 118.78,68.95 118.78,68.77 118.82,68.65 118.82,67.54 118.67,67.38 118.59,67.31 118.59,66.26 117.9,65.56 v1(117.74,64.97)
  BOTTOM w0.15: v1(83.26,34.41) 85.7,31.96 JDIMM1.114
DDR_A_ALERT#: length 61.1
  IN4 w0.089: v1(117.74,62.52) 116.65,61.43 116.65,58.82 114.76,56.93
  IN4 w0.102: 114.76,56.93 106.52,48.69 92.25,48.69 88.64,45.08 88.64,44.58 88.32,44.26 88.32,43.96 85.87,41.51 85.58,41.51 85,40.94 85,33.41 85.52,32.89 85.59,32.89 v1(85.89,32.59)
  BOTTOM w0.076: 118.4,65.14 118.4,65.14 119.58,66.32 119.58,66.76 119.75,66.93 119.75,67.51 119.6,67.67 119.6,68.44 UC1.W37
  BOTTOM w0.089: 118.4,65.14 118.4,63.17 v1(117.74,62.52)
  BOTTOM w0.15: v1(85.89,32.59) 86.21,32.27 JDIMM1.116
DDR_A_BA0: length 61.9
  IN4 w0.089: v1(119.34,71.32) 119.33,70.06 122.3,67.1 123.25,64.77 123.25,58.69 122.6,58.04 122.6,57.56
  IN4 w0.102: v1(95.77,32.39) 94.07,34.09 94.07,37.36 97.23,40.52 97.23,40.9 98.41,42.09 109.25,42.09 121.6,54.43 121.6,55.64 122.6,56.65 122.6,57.56
  BOTTOM w0.089: UC1.W32 v1(119.34,71.32)
  BOTTOM w0.15: JDIMM1.150 96.71,31.8 96.11,32.39 v1(95.77,32.39)
DDR_A_BA1: length 64
  IN4 w0.089: 124.23,57.95 124.23,59.73 125.01,60.51 125.01,66.79 120.81,70.99 120.81,71.61 v1(121.15,71.95)
  IN4 w0.102: 124.23,57.95 124.08,57.8 124.08,56.03 123.07,55.03 123.07,53.22 121.11,51.26 120.97,51.26 120.81,51.42 120.67,51.42 120.52,51.27 120.52,51.13 120.68,50.97 120.68,50.83 120.54,50.68 120.39,50.68 120.23,50.84 120.09,50.84 119.95,50.7 119.95,50.55 120.11,50.4 120.11,50.25 119.96,50.11 119.82,50.11 119.66,50.27 119.52,50.27 119.37,50.12 119.37,49.98 119.53,49.82 119.53,49.68 119.39,49.53 119.24,49.53 119.08,49.69 118.94,49.69 118.8,49.55 118.8,49.4 118.96,49.25 118.96,49.1 118.81,48.96 118.67,48.96 118.51,49.12 118.37,49.12 118.22,48.97 118.22,48.83 118.38,48.67 118.38,48.53 118.24,48.38 118.09,48.38 117.93,48.54 117.79,48.54 117.65,48.4 117.65,48.26 117.8,48.11 117.8,47.95 117.66,47.81 117.52,47.81 117.38,47.95 117.2,47.95 117.05,47.8 117.05,47.66 117.21,47.5 117.21,47.36 117.07,47.21 116.92,47.21 116.76,47.37 116.62,47.37 109.31,40.06 99.14,40.06 96.78,37.69 96.78,36.57 96.66,36.45 96.37,36.45 96.27,36.55 96.27,36.82 96.13,36.96 v1(95.77,36.96)
  BOTTOM w0.089: UC1.AB31 v1(121.15,71.95)
  BOTTOM w0.15: v1(95.77,36.96) 95.45,37.28 JDIMM1.145
DDR_A_BG0: length 64.9
  IN4 w0.089: v1(119.02,66.57) 118.28,65.82 118.28,64.16 116.05,61.93 116.05,59.26
  IN4 w0.102: v1(83.26,35.93) 82.88,36.31 82.88,37.78 83.19,38.09 83.83,38.09 84.1,38.36 84.1,41.58 85.03,42.51 85.17,42.51 85.43,42.25 85.57,42.25 85.71,42.39 85.71,42.54 85.46,42.79 85.46,42.94 85.6,43.08 85.75,43.08 86,42.83 86.14,42.83 87.59,44.27 87.59,44.41 87.33,44.67 87.33,44.81 91.94,49.42 106.21,49.42 116.05,59.26
  BOTTOM w0.076: v1(119.02,66.57) 119.25,66.79 119.25,66.9 119.42,67.07 119.42,67.38 119.27,67.54 119.27,68.65 119.31,68.77 119.31,68.95 119.27,69.07 119.27,69.3 119.31,69.42 119.31,69.9 119.04,70.16 UC1.V34
  BOTTOM w0.15: v1(83.26,35.93) 83.66,35.93 85.96,38.22 JDIMM1.115
DDR_A_BG1: length 64.5
  IN4 w0.089: v1(117.74,63.11) 116.48,61.84 116.48,59.17 115.2,57.89
  IN4 w0.102: v1(83.26,37.46) 83.85,37.46 83.95,37.35 83.95,35.4 84.05,35.3 84.53,35.3 84.63,35.4 84.63,41.09 85.42,41.88 85.72,41.88 87.95,44.11 87.95,44.41 88.28,44.74 88.28,45.23 92.1,49.05 106.36,49.05 115.2,57.89
  BOTTOM w0.076: UC1.W35 119.6,69.74 119.43,69.28 119.43,69.09 119.47,68.98 119.47,68.74 119.43,68.63 119.43,67.6 119.59,67.45 119.59,67 119.42,66.83 119.42,66.39 118.2,65.17 118.2,64.98
  BOTTOM w0.089: 118.2,64.98 118.2,63.56 v1(117.74,63.11)
  BOTTOM w0.15: v1(83.26,37.46) 84.59,37.46 85.45,38.32 JDIMM1.113
DDR_A_CKE0: length 66
  IN4 w0.089: v1(115.3,60.78) 115.3,60.68 113.04,58.42
  IN4 w0.102: v1(81.21,36.33) 81.67,36.33 81.77,36.43 81.77,38.84 81.92,38.98 82.49,38.98 82.59,39.08 82.59,39.29 82.49,39.39 81.9,39.39 81.79,39.49 81.79,39.69 81.9,39.8 82.49,39.8 82.59,39.9 82.59,40.1 82.49,40.2 81.9,40.2 81.79,40.3 81.79,40.51 81.9,40.61 82.49,40.61 82.59,40.71 82.59,40.91 82.49,41.01 81.9,41.01 81.79,41.12 81.79,41.32 81.9,41.42 82.49,41.42 82.59,41.52 82.59,41.64 91.48,50.53 105.15,50.53 113.04,58.42
  BOTTOM w0.076: 116.82,65.4 118.1,66.68 118.1,67.5 118.33,67.73 118.33,68.18 118.13,68.38 118.13,68.65 118.39,69.13 UC1.U36
  BOTTOM w0.089: v1(115.3,60.78) 116.24,61.73 116.24,64.82 116.82,65.4
  BOTTOM w0.15: v1(81.21,36.33) 82.99,38.11 84.07,38.11 84.45,38.5 JDIMM1.109
DDR_A_CKE1: length 66.3
  IN4 w0.102: v1(115.3,60.15) 115.29,60.15 105.3,50.16 91.64,50.16 82.96,41.48 82.96,38.91 82.14,38.09 82.14,35.96 82.04,35.86 81.77,35.86 81.67,35.76 81.67,35.56 81.77,35.45 82.04,35.45 82.14,35.35 82.14,35.15 82.04,35.05 81.77,35.05 81.67,34.95 81.67,34.74 81.77,34.64 82.04,34.64 82.14,34.54 82.14,34.34 82.04,34.24 81.77,34.24 81.67,34.13 81.67,33.93 81.77,33.83 82.04,33.83 82.14,33.73 82.14,33.38 82.04,33.28 v1(81.21,33.28)
  BOTTOM w0.076: 117.02,65.32 118.26,66.56 118.26,67.44 118.49,67.67 118.49,68.44 UC1.U37
  BOTTOM w0.089: 117.02,65.32 116.47,64.76 116.47,61.32 v1(115.3,60.15)
  BOTTOM w0.15: JDIMM1.110 84.7,31.96 84.55,32.11 82.68,32.11 81.51,33.28 v1(81.21,33.28)
DDR_A_CKE2: length 14.1
  TOP w0.15: T351.1 114.77,59.03 v1(114.79,59.04)
  BOTTOM w0.076: 117.24,65.23 118.43,66.42 118.43,67.37 118.66,67.6 118.66,68.63 118.62,68.74 118.62,68.98 118.66,69.09 118.66,70.22 UC1.U34
  BOTTOM w0.089: 117.24,65.23 116.69,64.68 116.69,60.41 115.3,59.04 v1(114.79,59.04)
DDR_A_CKE3: length 9.9
  TOP w0.15: T350.1 114.97,61.7 v1(115.32,62.05)
  BOTTOM w0.076: 116.63,65.47 117.93,66.77 117.93,67.57 118.01,67.64 118.16,67.8 118.16,68.12 117.97,68.31 117.97,68.69 118.08,68.89 118.08,69.52 UC1.U35
  BOTTOM w0.089: v1(115.32,62.05) 115.32,62.08 116.04,62.8 116.04,64.88 116.63,65.47
DDR_A_CLK0: length 64.7
  IN4 w0.094: v1(92.37,36) 93.16,36 93.41,36.25 93.41,37.27 93.1,37.59 93.1,38.26 93.61,38.78 93.75,38.78 94.04,38.48 94.33,38.48 94.63,38.79 94.63,39.07 94.34,39.37 94.34,39.5 94.54,39.7 94.67,39.7 94.97,39.41 95.25,39.41 95.56,39.71 95.56,40 95.26,40.29 95.26,40.43 95.99,41.16 96.13,41.16 96.23,41.05 96.52,41.05 96.82,41.36 96.82,41.64 96.72,41.75 96.72,41.88 97.53,42.69 109,42.69 120.99,54.69 120.99,55.89 122.35,57.25 122.35,65.33 118.97,68.71 118.97,71.39 v1(118.41,71.95)
  BOTTOM w0.089: UC1.V31 v1(118.41,71.95)
  BOTTOM w0.104: v1(92.37,36) 91.67,36 91.46,36.22 91.46,38.27 91.45,38.27 JDIMM1.137
DDR_A_CLK1: length 63.9
  IN4 w0.094: v1(117.5,71.95) 118.05,71.4 118.05,70.9 118.33,70.62 118.33,68.73 121.99,65.08 121.99,58 120.21,56.22 120.21,55.01 108.68,43.48 97.2,43.48 92,38.27 92,37.58 91.78,37.36 91.78,34.57 91.88,34.47 v1(92.37,34.47)
  BOTTOM w0.089: UC1.T31 v1(117.5,71.95)
  BOTTOM w0.104: v1(92.37,34.47) 92.09,34.2 91.7,34.2 91.48,33.98 91.48,32.57 91.84,32.21 91.84,31.99 91.71,31.85 JDIMM1.138
DDR_A_CLK#0: length 64.7
  IN4 w0.094: v1(92.37,36.76) 92.62,36.76 92.72,36.67 92.72,36.28 92.81,36.18 93.08,36.18 93.23,36.32 93.23,37.2 92.91,37.51 92.91,38.34 93.54,38.96 93.82,38.96 94.12,38.66 94.25,38.66 94.45,38.87 94.45,39 94.16,39.29 94.16,39.58 94.46,39.88 94.75,39.88 95.04,39.59 95.17,39.59 95.38,39.79 95.38,39.92 95.08,40.22 95.08,40.5 95.92,41.34 96.2,41.34 96.31,41.23 96.44,41.23 96.64,41.44 96.64,41.57 96.54,41.67 96.54,41.96 97.45,42.88 108.93,42.88 120.81,54.76 120.81,55.97 122.17,57.33 122.17,65.26 118.79,68.64 118.79,71.32 118.67,71.43 118.54,71.43 v1(118.42,71.31)
  BOTTOM w0.076: UC1.V32 118.63,71.53 v1(118.42,71.31)
  BOTTOM w0.104: JDIMM1.139 91.96,38.22 91.65,37.91 91.65,36.3 91.75,36.19 91.98,36.19 92.08,36.3 92.08,36.66 92.19,36.76 v1(92.37,36.76)
DDR_A_CLK#1: length 63.8
  IN4 w0.094: v1(92.37,33.71) 92.37,33.94 92.02,34.29 91.8,34.29 91.6,34.49 91.6,37.44 91.82,37.66 91.82,38.35 97.13,43.66 108.6,43.66 120.03,55.09 120.03,56.3 121.8,58.07 121.8,65 118.15,68.65 118.15,70.55 117.87,70.83 117.87,71.31 117.76,71.42 117.62,71.42 v1(117.51,71.31)
  BOTTOM w0.089: v1(117.51,71.31) UC1.T32
  BOTTOM w0.104: v1(92.37,33.71) 92.08,34 91.78,34 91.68,33.9 91.68,32.65 92.04,32.29 92.04,31.99 92.21,31.82 JDIMM1.140
DDR_A_CS#0: length 67.6
  IN4 w0.089: v1(123,71.31) 125.46,68.85 125.72,68.85 126.14,68.42 126.14,67.42 125.95,67.23 125.95,60.18 125.24,59.48
  IN4 w0.102: v1(98.09,35.7) 98.56,36.18 98.56,37.39 99.75,38.58 110.76,38.58 111.91,39.74 112.72,39.74 116.44,43.46 116.44,43.6 116.08,43.95 116.08,44.15 120.74,48.8 120.89,48.8 121.24,48.45 121.38,48.45 121.53,48.59 121.53,48.74 121.17,49.09 121.17,49.23 121.32,49.38 121.46,49.38 121.81,49.02 121.96,49.02 122.1,49.17 122.1,49.31 121.75,49.67 121.75,49.81 121.89,49.95 122.04,49.95 122.39,49.6 122.53,49.6 122.68,49.74 122.68,49.89 122.32,50.24 122.32,50.38 122.47,50.53 122.61,50.53 122.96,50.17 123.11,50.17 123.25,50.32 123.25,50.46 122.9,50.82 122.9,50.96 123.04,51.1 123.19,51.1 123.54,50.75 123.68,50.75 123.83,50.89 123.83,51.04 123.47,51.39 123.47,51.54 123.62,51.68 123.76,51.68 124.11,51.33 124.26,51.33 124.4,51.47 124.4,51.61 124.05,51.97 124.05,52.11 124.55,52.61 124.55,54.42 125.24,55.12 125.24,59.48
  BOTTOM w0.089: v1(123,71.31) 123.42,71.52 UC1.AE32
  BOTTOM w0.15: v1(98.09,35.7) 96.45,37.34 JDIMM1.149
DDR_A_CS#1: length 68
  IN4 w0.089: v1(123.92,71.31) 123.92,71.08 125.18,69.82 125.45,69.82 126.79,68.48 126.79,67.96 127.24,67.51 127.24,66.83 126.85,66.43 126.85,60.41 125.98,59.54 125.98,58.68
  IN4 w0.102: 125.98,58.68 125.98,54.81 125.28,54.11 125.28,51.26 119.02,44.99 118.87,44.99 118.5,45.37 118.35,45.37 118.21,45.23 118.21,45.08 118.59,44.71 118.59,44.56 118.44,44.42 118.3,44.42 117.92,44.8 117.78,44.8 117.1,44.12 117.1,43.98 117.48,43.6 117.48,43.46 112.78,38.75 112.63,38.75 112.38,39 112.22,39 112.06,38.84 112.06,38.7 112.32,38.44 112.32,38.29 112.17,38.15 112.03,38.15 111.77,38.41 111.63,38.41 111.06,37.85 101.29,37.85 101.19,37.75 101.19,36.64 101.08,36.54 100.88,36.54 100.78,36.64 100.78,37.75 100.68,37.85 100.06,37.85 99.63,37.42 99.63,35.44 v1(100.17,34.9)
  BOTTOM w0.089: v1(123.92,71.31) 124.33,71.51 UC1.AF32
  BOTTOM w0.15: JDIMM1.157 98.45,38.27 99.05,37.67 99.05,36.02 v1(100.17,34.9)
DDR_A_D0: length 80
  IN4 w0.084: v1(104.44,75.9) 104.08,75.54 103.62,75.54 103.61,75.55 96.68,75.55 93.37,72.24 93.37,66 92.15,64.77 83.87,64.77 64.19,45.09 63.32,45.09 58.67,40.43 58.67,40.24 57.58,39.15 57.58,36.02 57.82,35.77 57.82,34.96 v1(58.24,34.55)
  BOTTOM w0.076: 104.89,75.44 104.98,75.35 106.93,75.35 107.18,75.6 108.2,75.6 108.45,75.35 109.22,75.35 109.31,75.45 UC1.A26
  BOTTOM w0.089: 104.89,75.44 v1(104.44,75.9)
  BOTTOM w0.127: v1(58.24,34.55) 57.75,34.06 57.75,32.47 58.21,32.01 JDIMM1.4
DDR_A_D1: length 79.9
  IN4 w0.084: v1(106.98,74.64) 105.74,73.4 103.99,73.4 102.75,72.16 100.67,72.16 100.18,72.65 98.32,72.65 96.26,70.6 96.26,64.62 93.52,61.88 86.2,61.88 66.52,42.2 65.55,42.2 65.14,41.79 65.03,41.79 64.81,42 64.69,42 64.51,41.82 64.51,41.7 64.72,41.49 64.72,41.37 64.6,41.25 64.49,41.25 64.27,41.46 64.15,41.46 64.03,41.34 64.03,41.23 64.25,41.01 64.25,40.89 64.13,40.77 64.01,40.77 63.8,40.99 63.68,40.99 63.25,40.56 63.25,40.38 63.43,40.2 63.43,40.08 63.14,39.79 63.14,38.72 62.61,38.19 62.61,34.45 62.32,34.16 62.03,34.16 v1(61.82,34.37)
  BOTTOM w0.076: UC1.D26 111.26,75.45 111.26,74.71 111.23,74.68 111.06,74.51 111.06,74.51 110.28,74.51 110.08,74.58 109.85,74.58 109.73,74.53 109.55,74.53 109.44,74.57 109.43,74.58 108.32,74.58 108.16,74.42 107.7,74.42 107.66,74.47
  BOTTOM w0.089: v1(106.98,74.64) 107.48,74.64 107.66,74.47
  BOTTOM w0.127: v1(61.82,34.37) 62.45,33.74 62.45,32.37 62.21,32.13 JDIMM1.20
DDR_A_D2: length 81.6
  IN4 w0.084: v1(58.24,33.02) 58.24,33.01 58.85,33.01 58.93,33.1 58.93,33.78 58.71,34 58.71,38.9 59.71,39.9 59.71,40.26 62.62,43.17 62.74,43.17 62.8,43.11 62.92,43.11 63.04,43.23 63.04,43.35 62.98,43.41 62.98,43.53 63.1,43.65 63.22,43.65 63.28,43.59 63.4,43.59 64.04,44.23 65.14,44.23 74.94,54.03 75.32,54.03 85.21,63.91 92.5,63.91 94.23,65.64 94.23,71.44 94.94,72.15 94.94,72.59 97.03,74.69 101.02,74.69 101.18,74.53 v1(101.65,74.53)
  BOTTOM w0.076: UC1.D28 111.26,74.15 110.61,73.83 110.51,73.83 110.5,73.83 110.26,73.83 109.67,73.83 109.47,73.72 109.09,73.72 108.9,73.92 108.58,73.92 108.39,73.73
  BOTTOM w0.089: 108.39,73.73 101.86,73.73 101.65,73.93 v1(101.65,74.53)
  BOTTOM w0.127: v1(58.24,33.02) 59.21,32.05 JDIMM1.8
DDR_A_D3: length 80
  IN4 w0.084: v1(61.82,37.41) 61.63,37.41 61.5,37.28 61.5,37.01 61.42,36.93 61.2,36.93 61.11,37.01 61.11,37.38 61.03,37.46 60.87,37.46 60.78,37.54 60.78,37.83 60.87,37.91 62.24,37.91 62.33,38 62.33,38.17 62.24,38.25 60.87,38.25 60.78,38.33 60.78,38.5 61.01,38.73 62.74,38.73 62.86,38.84 62.86,39.03 62.77,39.11 61.73,39.11 61.64,39.19 61.64,39.36 61.73,39.45 62.77,39.45 62.86,39.53 62.86,40.57 64.77,42.48 66.4,42.48 86.08,62.17 93.4,62.17 95.98,64.74 95.98,70.72 98.2,72.94 100.3,72.94 100.79,72.45 102.64,72.45 103.83,73.64 104.71,73.64 v1(105.71,74.64)
  BOTTOM w0.076: UC1.C28 110.58,74.15 110.39,74.34 110.25,74.34 110.06,74.41 109.87,74.41 109.76,74.37 109.52,74.37 109.41,74.41 108.38,74.41 108.23,74.26 106.09,74.26 v1(105.71,74.64)
  BOTTOM w0.127: v1(61.82,37.41) 61.46,37.78 JDIMM1.17
DDR_A_D4: length 78.2
  IN4 w0.084: v1(58.24,36.07) 57.86,36.44 57.86,39.03 59.13,40.3 59.13,40.5 63.44,44.81 64.31,44.81 83.99,64.49 92.26,64.49 93.66,65.88 93.66,72.12 96.8,75.26 101.32,75.26 101.36,75.3 104.48,75.3 v1(105.07,75.9)
  BOTTOM w0.076: 105.38,75.59 105.45,75.52 106.87,75.52 107.11,75.76 108.27,75.76 108.51,75.52 108.96,75.52 109.16,75.71 109.41,75.71 109.43,75.7 109.9,75.45 UC1.B26
  BOTTOM w0.089: 105.38,75.59 v1(105.07,75.9)
  BOTTOM w0.127: JDIMM1.3 57.96,38.29 57.75,38.08 57.75,36.56 v1(58.24,36.07)
DDR_A_D5: length 79
  IN4 w0.084: v1(106.34,75.9) 105.56,75.11 101.54,75.11 101.4,74.98 96.91,74.98 94.57,72.63 94.57,72.18 93.94,71.56 93.94,65.76 92.38,64.2 85.09,64.2 75.24,54.35 74.86,54.35 68.01,47.51 67.89,47.51 67.71,47.69 67.6,47.69 67.48,47.57 67.48,47.45 67.66,47.27 67.66,47.15 67.54,47.03 67.42,47.03 67.24,47.21 67.12,47.21 67,47.09 67,46.97 67.18,46.79 67.18,46.68 67.06,46.56 66.94,46.56 66.77,46.74 66.65,46.74 66.53,46.62 66.53,46.5 66.71,46.32 66.71,46.2 66.59,46.08 66.47,46.08 66.29,46.26 66.17,46.26 66.05,46.14 66.05,46.03 66.23,45.85 66.23,45.73 66.11,45.61 66,45.61 65.82,45.79 65.7,45.79 65.58,45.67 65.58,45.55 65.76,45.37 65.76,45.25 65.64,45.13 65.52,45.13 65.34,45.31 65.22,45.31 65.1,45.19 65.1,45.08 65.28,44.9 65.28,44.78 65.02,44.52 63.56,44.52 59.42,40.38 59.42,40.02 58.24,38.83 v1(58.24,37.59)
  BOTTOM w0.076: UC1.C26 110.32,75.75 109.68,75.75 109.51,75.84 109.45,75.88 109.09,75.88 108.9,75.68 108.61,75.68 108.43,75.86
  BOTTOM w0.089: 108.43,75.86 108.37,75.93 106.37,75.93 v1(106.34,75.9)
  BOTTOM w0.127: JDIMM1.7 58.96,38.31 v1(58.24,37.59)
DDR_A_D6: length 79.2
  IN4 w0.084: v1(61.82,32.84) 61.31,32.84 61.23,32.93 61.23,33.18 61.15,33.27 60.98,33.27 60.89,33.18 60.89,32.93 60.81,32.84 60.62,32.84 60.54,32.93 60.54,36.94 60.2,37.27 60.2,38.73 61.57,40.1 62.01,40.1 62.28,40.37 62.28,40.81 64.53,43.06 66.01,43.06 85.69,62.74 92.99,62.74 95.4,65.15 95.4,70.95 97.96,73.51 100.54,73.51 101.03,73.03 102.47,73.03 103.59,74.15 103.94,74.15 v1(104.44,74.64)
  BOTTOM w0.076: UC1.B28 109.96,74.15 109.91,74.15 109.43,73.88 109.16,73.88 108.96,74.08 108.51,74.08 108.33,73.9 108.23,73.9
  BOTTOM w0.089: v1(104.44,74.64) 105.18,73.9 108.23,73.9
  BOTTOM w0.127: JDIMM1.16 61.21,32.22 v1(61.82,32.84)
DDR_A_D7: length 78.8
  IN4 w0.084: v1(61.82,35.89) 61.3,35.89 61.22,35.81 61.22,34.33 61.14,34.25 60.91,34.25 60.83,34.33 60.83,37.05 60.49,37.39 60.49,38.61 61.69,39.81 62.13,39.81 62.57,40.25 62.57,40.69 64.65,42.77 66.13,42.77 85.81,62.45 93.11,62.45 95.69,65.03 95.69,70.83 98.08,73.23 100.42,73.23 100.91,72.74 102.49,72.74 103.65,73.89 104.32,73.89 v1(105.07,74.64)
  BOTTOM w0.076: 108.18,74.08 108.28,74.08 108.45,74.24 109.22,74.24 109.31,74.15 UC1.A28
  BOTTOM w0.089: v1(105.07,74.64) 105.64,74.08 108.18,74.08
  BOTTOM w0.127: JDIMM1.21 62.46,36.52 v1(61.82,35.89)
DDR_A_D8: length 73.4
  IN4 w0.084: v1(63.76,34.35) 63.39,34.73 63.39,37.61 63.92,38.14 63.92,39.47 65.87,41.42 66.84,41.42 86.52,61.1 98.82,61.1 102.91,65.19 102.91,70.33 102.81,70.43 102.81,71.58 103.58,72.36 104.83,72.36 v1(105.45,72.98)
  BOTTOM w0.076: UC1.B30 109.91,72.93 109.43,73.2 109.16,73.2 108.96,73 108.55,73 108.39,73.16 107.64,73.16 107.11,72.62 106.26,72.62
  BOTTOM w0.089: 106.26,72.62 105.82,72.62 v1(105.45,72.98)
  BOTTOM w0.127: JDIMM1.28 64.21,33.91 v1(63.76,34.35)
DDR_A_D9: length 73.8
  IN4 w0.084: v1(107.54,71.7) 107.54,66.29 106.96,65.71 106.96,64.61 100.56,58.21 87.32,58.21 70.33,41.22 70.33,40.32 69.29,39.28 69.06,39.28 68.38,38.6 68.38,34.82 68.3,34.74 68.21,34.74 68.13,34.66 68.13,34.47 68.21,34.39 68.63,34.39 68.71,34.3 68.71,34.14 68.63,34.05 68.21,34.05 68.13,33.97 68.13,33.8 68.21,33.72 68.63,33.72 68.71,33.63 68.71,33.47 68.63,33.38 68.21,33.38 68.13,33.3 68.13,33.13 68.21,33.05 68.63,33.05 68.71,32.96 68.71,32.8 68.63,32.71 v1(67.75,32.71)
  BOTTOM w0.076: UC1.D30 111.26,72.93 111.26,72.18 111.07,71.99 111.06,71.99 110.27,71.99 110.08,72.06 109.85,72.06 109.73,72.02 109.54,72.02 109.41,72.07 108.51,72.07 108.14,71.7
  BOTTOM w0.089: 108.14,71.7 v1(107.54,71.7)
  BOTTOM w0.127: v1(67.75,32.71) 67.24,32.71 66.7,32.18 JDIMM1.38
DDR_A_D10: length 73.5
  IN4 w0.084: v1(103.39,70.6) 103.39,70.47 103.48,70.38 103.48,64.54 99.46,60.53 86.76,60.53 65.42,39.19 65.42,39.07 65.73,38.77 65.73,38.65 65.61,38.53 65.49,38.53 65.35,38.67 65.23,38.67 64.98,38.43 64.98,36.7 64.9,36.62 64.22,36.62 64.14,36.53 64.14,36.37 64.22,36.28 64.9,36.28 64.98,36.2 64.98,35 64.9,34.92 64.61,34.92 64.52,35 64.52,35.79 64.44,35.88 v1(63.76,35.88)
  BOTTOM w0.076: UC1.B33 109.48,70.81 103.59,70.81 v1(103.39,70.6)
  BOTTOM w0.127: JDIMM1.25 63.46,38.45 63.08,38.08 63.08,36.56 v1(63.76,35.88)
DDR_A_D11: length 72.5
  IN4 w0.084: v1(105.31,71.74) 105.31,71.22 105.75,70.78 105.75,67.29 104.86,66.4 104.86,63.99 100.23,59.35 90.89,59.35 90.61,59.07 86.97,59.07 66.9,39.01 66.9,34.32 66.99,34.24 v1(67.75,34.24)
  BOTTOM w0.076: 109.01,70.97 109.75,71.31 110.61,71.31 UC1.D32
  BOTTOM w0.089: 109.01,70.97 105.56,70.97 105.31,71.22 v1(105.31,71.74)
  BOTTOM w0.127: v1(67.75,34.24) 68.16,33.83 68.16,32.49 67.7,32.04 JDIMM1.42
