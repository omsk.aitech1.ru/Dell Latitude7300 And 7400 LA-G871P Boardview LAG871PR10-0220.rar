# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_PTX_DRX_P4: length 157.6
  TOP w0.104: CZ150.1 239.71,43.19 239.13,43.19 238.88,43.44 v1(238.88,44.64)
  IN4 w0.094: v1(145.97,97.35) 144.92,97.35 144.3,96.72 142.99,96.72 142.5,97.21 142.5,103.31 144.09,104.9 145.56,104.9 146.34,105.68 149.42,105.68 149.76,106.02 154.65,106.02 156.22,107.59 161.92,107.59 162.53,108.2 165.38,108.2 170.76,102.82 173.15,102.82 174.1,101.88 174.76,101.88 178.95,97.69 178.95,97.03 180.61,95.36 180.61,94.31 181.64,93.29 181.64,89.54 185.02,86.16 185.78,86.16 186.21,85.73 186.21,83.73 186.45,83.5 187.43,83.5 189.74,81.19 190.42,81.19 198.37,73.24 198.37,64.25 215.28,47.34 217.04,47.34 219.91,44.48 223.18,44.48 223.6,44.06 231.58,44.06 232.48,43.15 238.14,43.15 239.08,44.09 239.08,44.44 v1(238.88,44.64)
  BOTTOM w0.076: UC1.BW1 144.59,91.26 144.62,91.3 144.62,92.39 145.12,92.89 145.12,94.09 145.42,94.4 145.42,95.35 146.31,96.24 146.31,96.51 146.36,96.57 146.51,96.57 146.59,96.64 146.59,96.77 146.52,96.83 146.37,96.83 146.29,96.91 146.29,97.07 146.37,97.15 146.51,97.15 146.59,97.23 146.59,97.72 146.48,97.82 146.32,97.82 146.25,97.74 146.25,97.45 146.15,97.35 v1(145.97,97.35)
USB20_N1: length 198.1
  TOP w0.104: v1(24.08,57.92) 24.24,57.76 24.69,57.76 RT401.1
  IN2 w0.119: v1(148.72,92.96) 148.87,92.81 149.15,92.81 149.29,92.96 149.29,96.2 147.77,97.73 147.77,102.76 148.39,103.38 148.39,106.56 145.34,109.61 141.34,109.61 140.87,110.09 137.2,110.09 136.25,111.03 112.5,111.03 112.02,110.55 106.52,110.55 104.21,112.86 88.24,112.86 86.24,110.86 81.53,110.86 81.41,110.74 79.28,110.74 78.13,111.88 52.97,111.88 49.22,108.13 49.22,107.17 49.71,106.68 49.96,106.68 51.12,105.52 51.12,104.53 48.71,102.11 46.7,102.11 45.6,101.01 44.49,101.01 38.92,95.43 38.04,95.43 37.22,94.61 37.22,91.35 37.98,90.59 37.98,86.71 40.71,83.98 40.71,78.09 39.19,76.56 39.19,73.91 36.84,71.56 36.84,69.68 34.72,67.56 33.62,67.56 30.65,64.59 29.74,64.59 28.14,62.99 28.14,62.56 25.46,59.89 25.46,57.3 24.29,56.13 23.78,56.13 23.44,56.47 23.44,57.49 23.68,57.73 23.89,57.73 v1(24.08,57.92)
  BOTTOM w0.076: v1(148.72,92.96) 148.36,92.61 148.36,92.2 148.17,92.02 148.17,91.47 148.32,91.32 148.32,91.07 148.29,90.98 148.29,90.7 148.32,90.61 148.32,90.42 148.14,90 148.1,89.91 UC1.CE3
USB20_N2: length 267.4
  TOP w0.104: v1(291.44,76.48) 291.54,76.38 291.76,76.38 291.93,76.56 UI3.2
  IN2 w0.119: v1(150.13,99.42) 149.21,99.42 148.96,99.67 148.96,102.87 154.81,108.72 156.57,108.72 158.69,110.84 164.1,110.84 169.79,105.15 169.79,101.13 170.57,100.34 170.57,99.46 169.4,98.29 169.4,97.04 170.1,96.33 176.91,96.33 177.64,95.6 177.64,93.35 178.55,92.44 180.26,92.44 181.99,90.71 181.99,90.11 183.17,88.93 188.1,88.93 192.4,84.63 192.4,82.64 192.87,82.17 194.44,82.17 202.02,74.58 202.02,71.98 202.61,71.39 202.61,70.36 204.35,65.76 204.35,62.62 215.07,51.9 215.68,51.9 221.72,45.87 236.19,45.87 236.36,46.03 241.56,46.03 242.19,46.66 243.65,46.66 244.31,47.32 247.55,47.32 250.66,50.43 253.61,50.43 262.76,59.58 262.76,72.8 262.97,73.02 262.97,73.45 263.03,73.51 263.03,84 263.22,84.19 263.22,88.27 264.01,89.06 264.01,91.85 266.86,94.71 286.96,94.71 287.42,95.17 289.83,95.17 290.48,95.81 v1(291.84,95.81)
  IN4 w0.094: v1(291.84,95.81) 292,95.65 292.29,95.65 292.55,95.39 292.55,91.02 292.04,90.51 292.04,84.7 292.86,83.88 293.59,83.88 294.71,82.76 294.71,78.6 293.32,77.21 290.99,77.21 290.9,77.11 290.9,76.58 291.03,76.45 291.4,76.45 v1(291.44,76.48)
  BOTTOM w0.076: 149.63,98.35 149.63,98.33 149.61,98.32 v4(149.61,96.88) 149.61,96.58 148.15,95.12 148.15,94.04 147.96,93.84 147.96,93.28 148.03,93.2 148.19,93.2 148.26,93.13 148.26,92.97 148.19,92.9 148.03,92.9 147.96,92.82 147.96,91.75 147.75,91.54 147.75,91.06 147.82,90.99 147.98,90.99 148.06,91.06 UC1.CE1
  BOTTOM w0.104: 149.63,98.35 149.63,99.64 149.74,99.75 149.9,99.75 150.13,99.52 v1(150.13,99.42)
USB20_N2_R: length 14.8
  TOP w0.104: v1(297.13,87.17) 296.91,87.39 296.7,87.39 296.3,87 DI5.2 295.66,87.36 295.52,87.36 295.41,87.25 295.41,86.85 295.71,86.54 296.06,86.54 296.36,86.24 v4(296.36,85.88) 296.36,85.63 296.09,85.36 295.15,85.36 294.69,85.81 294.21,85.81 LI7.3
  IN4 w0.094: JUSB1.2 301.11,83.04 301.01,83.14 300.8,83.14 298.46,85.48 298.46,87.28 298.37,87.38 297.33,87.38 v1(297.13,87.17)
USB20_N3: length 216.3
  IN2 w0.119: v1(148.72,94.87) 148.5,94.65 148.27,94.65 148.15,94.77 148.15,96.74 147.34,97.55 147.34,103.16 147.92,103.73 147.92,106.43 145.16,109.19 141,109.19 140.56,109.63 136.03,109.63 135.11,110.55 114.39,110.55 113.91,110.07 106.4,110.07 104.03,112.44 88.42,112.44 86.42,110.44 81.71,110.44 81.45,110.18 79.05,110.18 77.81,111.42 53.11,111.42 49.64,107.95 49.64,107.35 49.88,107.1 51.07,107.1 51.85,106.33 51.85,104.65 48.77,101.57 46.82,101.57 45.1,99.85 45.1,99.13 43.8,97.83 41.98,97.83 40.71,96.55 40.71,96.04 39.51,94.85 38.54,94.85 37.73,94.04 37.73,91.46 38.41,90.78 38.41,86.88 41.14,84.15 41.14,77.91 39.63,76.4 39.63,71.14 36.42,67.93 36.42,63.75 35.77,63.1 35.77,52.99 34.37,51.6 34.37,49.13 32.87,47.63 32.87,45.94 32.45,45.52 30.7,45.52 29.96,44.78 29.96,43.03 29.39,42.46 29.39,37.1 28.38,36.1 27.54,36.1 v1(27.35,36.28)
  BOTTOM w0.076: UC1.CG3 149.42,89.86 149.49,89.94 149.49,90.09 149.4,90.19 149.24,90.19 149.18,90.24 149.11,90.42 149.11,90.61 149.14,90.7 149.14,90.98 149.11,91.07 149.11,91.32 149.21,91.42 149.26,91.48 149.27,91.47 149.4,91.61 149.4,94.19 v1(148.72,94.87)
  BOTTOM w0.104: v1(27.35,36.28) 27.18,36.12 26.38,36.12 26.28,36.22 24.97,36.22 LI3.1
USB20_N3_R: length 12.6
  IN2 w0.119: v1(21.12,37.67) 20.93,37.49 20.11,37.49 18.62,38.97 18.62,40.1 16.87,41.85 16.47,41.85 16.36,41.97 JUSB2.2
  BOTTOM w0.104: v1(21.12,37.67) 21.31,37.48 21.49,37.48 21.91,37.9 DI2.3 22.26,37.64 22.38,37.52 22.64,37.52 23.01,37.14 23.01,36.85 23.64,36.22 24.06,36.22 LI3.2
USB20_N6: length 114.1
  TOP w0.104: v1(62.69,106.33) 62.69,105.56 62.34,105.21 60.39,105.21 60.14,105.46 LZ1.1
  IN2 w0.119: v1(62.69,106.33) 62.58,106.43 62.58,106.96 62.28,107.26 62.28,108.14 63.1,108.95 66.9,108.95 67.24,109.29 81.98,109.29 82.28,109.6 86.88,109.6 87.7,110.42 88.16,110.42 88.72,110.98 88.72,111.48 88.84,111.6 103.63,111.6 105.99,109.23 114.26,109.23 114.74,109.71 123.54,109.71 125.44,107.81 129.24,107.81 130.01,107.04 143.53,107.04 143.83,106.74 146.42,106.74 146.99,106.17 146.99,103.99 146.5,103.5 146.5,94.25 146.74,94.01 147.65,94.01 148,93.66 148,93.33 147.76,93.1 147,93.1 146.88,93.22 146.88,93.44 147,93.56 v1(147.33,93.56)
  BOTTOM w0.076: v1(147.33,93.56) 147.33,93.28 146.91,92.86 146.91,91.74 146.93,91.71 UC1.CC1
USB20_N6_R: length 6.9
  TOP w0.104: v1(61.74,110.38) 61.84,110.28 61.84,109.84 61.54,109.53 61.54,109.21 61.1,108.78 DV14.3 61.22,108.5 61.43,108.5 61.52,108.4 61.52,108.22 61.34,108.03 60.91,108.03 60.77,108.16 60.25,108.16 60.03,107.94 v4(60.03,107.68) 60.03,107.4 60.33,107.1 60.33,107.03 LZ1.2
  BOTTOM w0.104: JEDP1.12 61.83,110.95 61.93,110.85 61.93,110.58 v1(61.74,110.38)
USB20_N7: length 181.5
  TOP w0.104: v1(256.99,47.23) 257.73,47.23 v4(258.97,48.48) 259.8,49.31 262.74,49.31 263.14,49.71 266.31,49.71 267.69,51.08 271.13,51.08 271.34,51.3 271.34,51.79 271.67,52.12 271.67,52.4 271.67,52.6 LI8.4
  IN2 w0.089: 150.92,92.41 150.92,92.38 150.9,92.37 150.9,90.57 149.26,88.93 149.26,86.58 149.36,86.49 149.67,86.49 149.76,86.58 v1(149.76,86.85)
  IN2 w0.119: v1(256.99,47.23) 256.61,47.61 256.13,47.61 255.65,47.13 249.62,47.13 248.34,45.85 244.92,45.85 244.26,45.18 243.36,45.18 241.58,43.4 232.16,43.4 231.17,44.39 220.49,44.39 202.81,62.07 202.81,65.66 201.13,70.09 201.13,70.78 200.55,71.37 200.55,73.81 193.68,80.68 192.27,80.68 190.93,82.03 190.93,84.02 188.36,86.59 183.43,86.59 180.52,89.5 180.52,90.11 179.67,90.96 177.95,90.96 177.09,91.82 175.66,91.82 173.73,93.74 170.44,93.74 166.24,97.93 166.24,102.37 161.96,106.66 154.84,106.66 152.22,104.04 152.22,101.42 151.7,100.9 151.7,96.24 151.86,96.08 151.86,94.13 150.92,93.19 150.92,92.41
  BOTTOM w0.089: UC1.CG8 149.19,86.54 v1(149.76,86.85)
USB20_N7_L: length 4.9
  TOP w0.104: LI8.3 271.67,54.59 271.53,54.73 271.53,54.94 270.98,55.5 270.24,55.5 v1(269.99,55.75)
  BOTTOM w0.104: v1(269.99,55.75) 269.75,55.52 269.14,55.52 269.03,55.63 269.03,55.9 269.18,56.05 JNGFF2.9
USB20_N8: length 195.9
  IN2 w0.089: 152.34,92.41 152.34,92.38 152.36,92.37 152.36,89.6 151.85,89.1 151.85,85.93 151.66,85.74 149.44,85.74 149.33,85.84 148.02,85.84 147.94,85.77 147.64,85.77 147.43,85.97 147.43,86.28 147.24,86.48 147.16,86.48 v1(146.87,86.77)
  IN2 w0.119: 152.34,92.41 152.34,93.12 153.59,94.37 153.59,97.39 152.77,98.21 152.77,99.45 153.63,100.31 153.63,103.96 155.28,105.6 161.52,105.6 165.19,101.93 165.19,94.85 168.09,91.95 171.56,91.95 171.86,91.65 174.33,91.65 175.22,90.76 176.65,90.76 179.42,88 180.53,88 182.99,85.53 187.92,85.53 189.87,83.58 189.87,81.59 194.57,76.9 195.95,76.9 199.49,73.35 199.49,70.93 200.08,70.34 200.08,69.9 201.72,65.56 201.72,61.67 220.05,43.34 229.06,43.34 230.73,41.66 241.34,41.66 243.21,43.53 244.1,43.53 245.36,44.79 249.01,44.79 249.48,45.27 256.47,45.27 257.03,45.83 259.45,45.83 259.54,45.92 261.16,45.92 v1(261.56,45.52)
  BOTTOM w0.089: v1(146.87,86.77) 146.59,86.61 UC1.CB8
  BOTTOM w0.104: JUSH1.19 270.43,33.8 270.3,33.93 264.16,33.93 263.74,34.35 263.26,34.35 262.82,33.91 261.52,33.91 260.99,34.43 260.99,41.44 261.46,41.91 261.46,44.63 261.56,44.73 v1(261.56,45.52)
USB20_N9: length 267.6
  TOP w0.104: v1(313.05,98.8) 313.26,98.59 313.26,98.05 313.44,97.87 313.44,97.5 RZ1388.2
  IN2 w0.089: 151.71,92.41 151.72,92.39 151.72,90.52 150.95,89.74 150.95,88.46 150.86,88.37 150.72,88.37 150.57,88.53 v1(150.57,88.67)
  IN2 w0.119: v1(313.05,98.8) 313.43,98.43 313.43,97.48 312.74,96.79 304.2,96.79 302.98,95.56 294.82,95.56 294.31,95.05 293.19,95.05 292.55,94.42 292.55,93.77 292.05,93.27 291.08,93.27 290.53,93.81 288.92,93.81 288.82,93.71 287.86,93.71 287.5,94.07 281.96,94.07 281.35,93.47 279.6,93.47 279.01,94.06 267.1,94.06 264.64,91.59 264.64,87.82 263.85,87.03 263.85,83.93 263.85,83.92 263.85,82.43 264.04,82.24 264.04,73.62 263.61,73.19 263.61,65.54 264.17,64.97 264.17,62.8 263.39,62.02 263.39,59.31 260.65,56.57 260.65,54.62 258.69,52.66 258.69,48.38 256.21,45.9 248.99,45.9 248.52,45.43 245.1,45.43 244.33,44.65 243.43,44.65 241.26,42.48 230.81,42.48 229.32,43.97 220.31,43.97 202.39,61.89 202.39,65.58 200.71,70.01 200.71,70.6 200.12,71.19 200.12,73.61 196.14,77.6 195.89,77.6 193.22,80.26 192.1,80.26 190.5,81.85 190.5,83.84 188.18,86.17 183.25,86.17 180.09,89.33 180.09,89.93 179.49,90.53 177.77,90.53 176.91,91.39 175.48,91.39 174.59,92.28 172.12,92.28 171.82,92.58 168.35,92.58 166.33,94.6 166.33,95.04 166.99,95.69 166.99,96.54 165.82,97.71 165.82,102.2 161.78,106.24 155.01,106.24 152.64,103.87 152.64,101.24 152.14,100.74 152.14,97.89 152.96,97.07 152.96,94.63 151.71,93.38 151.71,92.41
  BOTTOM w0.089: v1(150.57,88.67) UC1.CH5
USB20_N9_FP: length 10.9
  TOP w0.104: v1(313.24,95.99) 313.43,96.19 313.43,96.47 RZ1388.1
  BOTTOM w0.104: RZ350.1 313.5,94.84 313.5,95.92 313.43,95.99 v1(313.24,95.99) 313.16,96.07 313.16,96.26 DZ11.2 313.68,97.11 314.04,97.47 v4(314.04,97.94) 314.04,99.22 313.69,99.58 313.69,99.59 313.22,100.07 312.8,100.07 312.13,100.74 312.13,101.4 312.45,101.72 312.74,101.72 312.82,101.8 JFPBTN1.6
USB20_N9_USH: length 101.7
  IN1 w0.094: v1(272.48,31.22) 272.1,31.61 272.1,32.05 272.37,32.32 272.83,32.32 274.07,33.57 274.07,33.76 275.16,34.86 275.28,34.86 276.98,36.55 276.98,43.68 278.33,45.03 278.33,46.1 278.78,46.55 279.47,46.55 280.87,47.95 280.87,49.71 282.27,51.12 284.84,51.12 285.16,50.81 289.35,50.81 289.52,50.63 294.86,50.63 297.94,53.71 297.94,55.16 296.87,56.23 296.87,57.42 295.96,58.33 295.96,61.51 296.64,62.18 296.64,67.67 296.97,68.01 296.97,71 297.19,71.21 297.19,76.77 296.62,77.33 296.62,88.96 299.79,92.14 299.94,92.14 300.78,92.98 307.99,92.98 308.67,93.66 310.88,93.66 311.82,92.72 312.12,92.72 v1(312.41,92.42)
  BOTTOM w0.104: JUSH1.23 272.43,31.88 272.23,31.68 272.23,31.47 v1(272.48,31.22) ; RZ350.2 313.5,93.84 313.5,93.69 313.37,93.57 312.4,93.57 312.11,93.28 312.11,92.95 312.41,92.65 v1(312.41,92.42)
USB20_N10: length 160.5
  IN2 w0.119: v1(251.62,49.21) 251.44,49.39 250.87,49.39 247.97,46.48 244.66,46.48 244,45.82 242.53,45.82 241.91,45.19 240.87,45.19 239.71,44.04 232.6,44.04 231.61,45.03 221.37,45.03 215.4,50.99 214.79,50.99 203.51,62.27 203.51,65.6 201.77,70.21 201.77,71.04 201.18,71.63 201.18,74.24 194.09,81.33 192.52,81.33 191.56,82.29 191.56,84.28 188.62,87.22 183.69,87.22 181.15,89.76 181.15,90.37 179.93,91.59 178.21,91.59 177.14,92.66 176.31,92.66 175.33,93.64 175.33,94.76 174.82,95.26 169.81,95.26 166.88,98.2 166.88,102.64 162.1,107.42 158.31,107.42 158.19,107.29 154.58,107.29 151.53,104.25 151.53,102.27 150.81,101.54 150.35,101.54 v1(150.13,101.33)
  BOTTOM w0.076: 149.02,97.2 149.02,97.19 149.02,96.96 147.05,95 147.05,93.97 146.67,93.59 146.67,91.27 146.67,91.26 146.67,91.19 146.67,91.19 146.67,91.07 146.7,90.98 146.7,90.7 146.67,90.61 146.67,90.42 146.73,90.27 146.8,90.2 147.03,90.2 147.21,90.02 147.21,89.66 147.13,89.58 147.03,89.58 146.93,89.68 UC1.CC3
  BOTTOM w0.104: 149.02,97.2 v4(149.02,98.63) 149.02,100.9 149.65,101.53 149.93,101.53 v1(150.13,101.33) ; v1(251.62,49.21) 251.81,49.41 252.5,49.41 LI9.1
USB20_N10_R: length 4.9
  BOTTOM w0.104: LI9.2 254.54,51.45 254.54,51.89 254.67,52.01 v4(254.67,52.29) 254.66,52.3 254.66,52.47 254.67,52.48 254.67,53.25 255,53.59 255.95,53.59 256.15,53.38 JNGFF1.5
USB20_P1: length 198.2
  TOP w0.104: v1(24.08,57.34) 24.32,57.57 24.69,57.57 RT400.1
  IN2 w0.119: v1(24.08,57.34) 23.89,57.52 23.77,57.52 23.65,57.4 23.65,56.55 23.86,56.34 24.2,56.34 25.25,57.39 25.25,59.97 27.93,62.65 27.93,63.07 29.65,64.79 30.56,64.79 33.53,67.77 34.63,67.77 36.63,69.76 36.63,71.65 38.98,74 38.98,76.65 40.5,78.17 40.5,83.89 37.77,86.62 37.77,90.5 37.01,91.26 37.01,94.7 37.96,95.64 38.84,95.64 44.41,101.22 45.51,101.22 46.62,102.32 48.62,102.32 50.92,104.62 50.92,105.43 49.88,106.47 49.62,106.47 49.01,107.08 49.01,108.21 52.88,112.09 78.22,112.09 79.36,110.95 81.32,110.95 81.45,111.07 86.16,111.07 88.16,113.07 104.29,113.07 106.61,110.76 111.93,110.76 112.42,111.24 136.34,111.24 137.28,110.29 140.95,110.29 141.42,109.82 145.42,109.82 148.6,106.65 148.6,103.3 147.97,102.68 147.97,97.81 149.5,96.28 149.5,92.87 149.23,92.6 148.99,92.6 v1(148.72,92.33)
  BOTTOM w0.076: UC1.CE4 148.06,89.47 148.34,89.75 148.34,90.04 148.49,90.38 148.49,90.63 148.45,90.73 148.45,90.95 148.49,91.05 148.49,91.39 148.34,91.54 148.34,91.95 v1(148.72,92.33)
USB20_P2: length 267.3
  TOP w0.104: v1(291.43,75.92) 291.64,76.13 291.86,76.13 291.93,76.06 UI3.3
  IN2 w0.119: v1(291.84,95.23) 291.46,95.6 290.56,95.6 289.92,94.96 287.5,94.96 287.04,94.5 266.95,94.5 264.22,91.77 264.22,88.97 263.43,88.18 263.43,84.11 263.24,83.92 263.24,73.42 263.18,73.36 263.18,72.93 262.96,72.72 262.96,59.49 253.7,50.22 250.74,50.22 247.64,47.11 244.4,47.11 243.73,46.45 242.27,46.45 241.65,45.82 236.44,45.82 236.28,45.66 221.63,45.66 215.6,51.69 214.98,51.69 204.14,62.53 204.14,65.72 202.4,70.32 202.4,71.3 201.81,71.89 201.81,74.5 194.35,81.96 192.79,81.96 192.19,82.55 192.19,84.54 188.01,88.72 183.08,88.72 181.78,90.02 181.78,90.63 180.18,92.23 178.46,92.23 177.43,93.26 177.43,95.51 176.83,96.12 170.02,96.12 169.19,96.95 169.19,98.37 170.36,99.54 170.36,100.26 169.58,101.04 169.58,105.06 164.01,110.63 158.78,110.63 156.66,108.51 154.9,108.51 149.17,102.78 149.17,99.76 149.29,99.64 149.56,99.64 149.68,99.76 149.68,99.94 149.79,100.06 v1(150.13,100.06)
  IN4 w0.094: v1(291.84,95.23) 292.08,95.47 292.21,95.47 292.37,95.32 292.37,91.09 291.86,90.58 291.86,84.62 292.78,83.7 293.52,83.7 294.53,82.68 294.53,78.68 293.24,77.39 290.92,77.39 290.72,77.19 290.72,76.5 290.95,76.27 291.09,76.27 v1(291.43,75.92)
  BOTTOM w0.076: UC1.CE2 147.58,90.99 147.58,91.6 147.79,91.82 147.79,93.91 147.99,94.11 147.99,95.19 149.4,96.6 149.4,97.18 149.45,97.23 149.45,98.32 149.43,98.33 149.43,98.35
  BOTTOM w0.104: 149.43,98.35 149.43,99.72 149.66,99.95 150.02,99.95 v1(150.13,100.06)
USB20_P2_R: length 14.8
  TOP w0.104: LI7.2 294.21,86.01 294.79,86.01 v4(295,85.8) 295.25,85.55 296.01,85.55 296.16,85.7 296.16,86.17 295.98,86.35 295.63,86.35 295.22,86.77 295.22,87.33 295.44,87.55 295.58,87.55 DI5.3 296.29,88 296.71,87.58 296.95,87.58 v1(297.13,87.76)
  IN4 w0.094: v1(297.13,87.76) 297.32,87.56 298.45,87.56 298.65,87.36 298.65,85.55 300.88,83.32 301.01,83.32 301.11,83.42 JUSB1.3
USB20_P3: length 216.3
  IN2 w0.119: v1(27.35,35.7) 27.54,35.89 28.47,35.89 29.6,37.01 29.6,42.37 30.17,42.94 30.17,44.7 30.79,45.32 32.54,45.32 33.08,45.85 33.08,47.54 34.58,49.04 34.58,51.51 35.97,52.91 35.97,63.01 36.62,63.66 36.62,67.85 39.83,71.06 39.83,76.31 41.34,77.83 41.34,84.24 38.61,86.97 38.61,90.86 37.93,91.54 37.93,93.95 38.63,94.64 39.6,94.64 40.92,95.96 40.92,96.47 42.07,97.62 43.88,97.62 45.31,99.04 45.31,99.77 46.91,101.37 48.85,101.37 52.06,104.57 52.06,106.42 51.16,107.31 49.97,107.31 49.85,107.43 49.85,107.86 53.2,111.22 77.72,111.22 78.96,109.98 81.54,109.98 81.8,110.23 86.5,110.23 88.5,112.23 103.95,112.23 106.31,109.86 114,109.86 114.47,110.34 135.03,110.34 135.94,109.42 140.47,109.42 140.92,108.98 145.07,108.98 147.71,106.35 147.71,103.82 147.13,103.24 147.13,97.46 147.94,96.65 147.94,94.69 148.18,94.44 148.5,94.44 v1(148.72,94.23)
  BOTTOM w0.076: UC1.CG4 149.09,89.73 149.09,90.04 148.95,90.38 148.95,90.63 148.98,90.73 148.98,90.95 148.95,91.05 148.95,91.39 149.15,91.59 149.15,91.59 149.23,91.67 149.23,94.12 149.12,94.23 v1(148.72,94.23)
  BOTTOM w0.104: LI3.4 24.97,36.03 26.2,36.03 26.3,35.93 27.12,35.93 v1(27.35,35.7)
USB20_P3_R: length 12.6
  IN2 w0.119: JUSB2.3 16.36,41.53 16.47,41.65 16.78,41.65 18.42,40.01 18.42,38.88 20.02,37.28 20.93,37.28 v1(21.12,37.09)
  BOTTOM w0.104: v1(21.12,37.09) 21.31,37.28 21.46,37.28 21.84,36.9 DI2.2 22.26,37.23 22.36,37.32 22.56,37.32 22.82,37.06 22.82,36.77 23.56,36.03 24.06,36.03 LI3.3
USB20_P6: length 114.1
  TOP w0.104: v1(62.1,106.33) 62.1,106.02 62.21,105.91 62.39,105.91 62.49,105.81 62.49,105.64 62.26,105.41 60.47,105.41 60.35,105.53 60.35,105.68 60.46,105.78 60.71,105.78 60.81,105.89 60.81,106.08 LZ1.4
  IN2 w0.119: v1(147.33,92.71) 147.51,92.89 147.85,92.89 148.21,93.24 148.21,93.75 147.74,94.22 146.83,94.22 146.71,94.34 146.71,103.42 147.2,103.91 147.2,106.26 146.51,106.95 143.92,106.95 143.62,107.25 130.09,107.25 129.32,108.02 125.52,108.02 123.63,109.91 114.65,109.91 114.17,109.44 106.08,109.44 103.71,111.81 88.76,111.81 88.51,111.57 88.51,111.07 88.08,110.63 87.61,110.63 86.79,109.81 82.2,109.81 81.89,109.5 67.16,109.5 66.81,109.16 63.01,109.16 62.08,108.22 62.08,107.17 62.37,106.88 62.37,106.6 v1(62.1,106.33)
  BOTTOM w0.076: v1(147.33,92.71) 147.15,92.71 147.07,92.63 147.07,91.81 147.18,91.7 147.18,91.02 146.93,90.77 UC1.CC2
USB20_P6_R: length 6.9
  TOP w0.104: LZ1.3 60.52,106.97 60.52,107.18 60.23,107.47 60.23,107.87 60.33,107.97 60.69,107.97 60.83,107.83 61.42,107.83 61.72,108.14 61.72,108.43 61.8,108.51 62,108.51 DV14.2 62.1,108.85 61.73,109.22 61.73,109.45 62.04,109.76 62.04,110.1 v1(62.32,110.38)
  BOTTOM w0.104: v1(62.32,110.38) 62.13,110.58 62.13,110.82 62.23,110.92 JEDP1.13
USB20_P7: length 181.5
  TOP w0.104: v1(256.99,47.81) 257.38,47.42 257.65,47.42 258.65,48.42 258.65,48.44 259.01,48.81 259.03,48.81 259.72,49.5 262.66,49.5 263.06,49.9 266.23,49.9 267.61,51.27 271.05,51.27 271.15,51.38 271.15,51.87 271.48,52.2 271.48,52.37 271.17,52.68 LI8.1
  IN2 w0.089: 150.71,92.41 150.71,92.38 150.72,92.37 150.72,90.64 149.09,89.01 149.09,86.51 149.28,86.31 149.38,86.31 v1(149.59,86.1)
  IN2 w0.119: v1(256.99,47.81) 256.04,47.81 255.57,47.34 249.53,47.34 248.25,46.06 244.84,46.06 244.17,45.39 243.28,45.39 241.5,43.61 232.25,43.61 231.26,44.6 220.58,44.6 203.02,62.16 203.02,65.69 201.34,70.13 201.34,70.87 200.76,71.45 200.76,73.9 193.76,80.89 192.36,80.89 191.14,82.12 191.14,84.11 188.44,86.8 183.51,86.8 180.72,89.59 180.72,90.19 179.75,91.17 178.03,91.17 177.18,92.02 175.74,92.02 173.82,93.95 170.52,93.95 166.45,98.02 166.45,102.46 162.04,106.87 154.75,106.87 152.01,104.13 152.01,101.5 151.5,100.99 151.5,96.15 151.65,96 151.65,94.22 150.71,93.28 150.71,92.41
  BOTTOM w0.076: UC1.CG9 149.18,86.02 149.26,86.1 v1(149.59,86.1)
USB20_P7_L: length 4.9
  TOP w0.104: v1(269.99,55.07) 270.21,55.29 v4(270.55,55.29) 270.91,55.29 271.34,54.86 271.34,54.75 271.17,54.59 LI8.2
  BOTTOM w0.104: JNGFF2.7 268.68,56.07 268.83,55.92 268.83,55.55 269.06,55.32 269.73,55.32 v1(269.99,55.07)
USB20_P8: length 195.8
  IN2 w0.089: 152.55,92.41 152.55,92.38 152.53,92.37 152.53,89.53 152.03,89.03 152.03,85.85 151.74,85.56 149.37,85.56 149.26,85.67 148.09,85.67 148.02,85.59 147.57,85.59 147.26,85.9 147.26,86.21 147.17,86.3 147.04,86.3 v1(146.87,86.13)
  IN2 w0.119: v1(261.07,45.05) 261.17,45.15 261.17,45.61 261.07,45.71 259.63,45.71 259.54,45.62 257.12,45.62 256.56,45.06 249.57,45.06 249.09,44.58 245.45,44.58 244.19,43.32 243.29,43.32 241.42,41.46 230.64,41.46 228.97,43.13 219.97,43.13 201.51,61.58 201.51,65.52 199.87,69.86 199.87,70.26 199.28,70.84 199.28,73.26 195.86,76.69 194.48,76.69 189.66,81.51 189.66,83.49 187.83,85.33 182.9,85.33 180.44,87.79 179.33,87.79 176.57,90.55 175.13,90.55 174.24,91.44 171.77,91.44 171.47,91.74 168,91.74 164.98,94.77 164.98,101.85 161.43,105.4 155.36,105.4 153.84,103.87 153.84,100.22 152.98,99.36 152.98,98.29 153.8,97.47 153.8,94.28 152.55,93.03 152.55,92.41
  BOTTOM w0.089: UC1.CB9 146.59,85.97 v1(146.87,86.13)
  BOTTOM w0.104: JUSH1.18 269.93,33.26 270,33.33 270.13,33.33 270.24,33.44 270.24,33.63 270.13,33.74 264.08,33.74 263.66,34.16 263.34,34.16 262.9,33.71 261.44,33.71 260.8,34.35 260.8,41.52 261.27,41.99 261.27,44.71 261.37,44.81 261.37,44.95 261.27,45.05 v1(261.07,45.05)
USB20_P9: length 267.6
  TOP w0.104: RZ1389.2 313.63,97.49 313.63,97.95 313.45,98.13 313.45,98.62 v1(313.64,98.8)
  IN2 w0.089: 151.92,92.41 151.9,92.39 151.9,90.45 151.12,89.67 151.12,88.39 150.93,88.2 150.73,88.2 v1(150.57,88.04)
  IN2 w0.119: 151.92,92.41 151.92,93.3 153.17,94.54 153.17,97.15 152.35,97.97 152.35,100.65 152.85,101.15 152.85,103.78 155.1,106.03 161.69,106.03 165.61,102.11 165.61,97.62 166.78,96.45 166.78,95.78 166.12,95.12 166.12,94.52 168.27,92.37 171.73,92.37 172.03,92.08 174.5,92.08 175.39,91.18 176.83,91.18 177.69,90.33 179.4,90.33 179.88,89.84 179.88,89.24 183.17,85.96 188.09,85.96 190.3,83.76 190.3,81.77 192.01,80.05 193.14,80.05 195.8,77.39 196.05,77.39 199.92,73.53 199.92,71.1 200.5,70.52 200.5,69.98 202.18,65.54 202.18,61.81 220.23,43.76 229.23,43.76 230.72,42.27 241.34,42.27 243.52,44.44 244.41,44.44 245.18,45.22 248.6,45.22 249.08,45.69 256.3,45.69 258.9,48.29 258.9,52.57 260.86,54.53 260.86,56.49 263.6,59.23 263.6,61.93 264.38,62.72 264.38,65.05 263.82,65.62 263.82,73.1 264.25,73.53 264.25,82.32 264.06,82.51 264.06,83.84 264.06,83.84 264.06,86.95 264.85,87.73 264.85,91.51 267.19,93.85 278.92,93.85 279.51,93.26 281.44,93.26 282.05,93.87 287.41,93.87 287.77,93.5 288.9,93.5 289,93.6 290.45,93.6 290.99,93.06 292.14,93.06 292.76,93.68 292.76,94.33 293.27,94.85 294.44,94.85 294.95,95.36 303.07,95.36 304.29,96.58 312.82,96.58 313.64,97.39 v1(313.64,98.8)
  BOTTOM w0.089: v1(150.57,88.04) UC1.CH6
USB20_P9_FP: length 10.8
  TOP w0.104: v1(313.82,96.15) 313.63,96.34 313.63,96.47 RZ1389.1
  BOTTOM w0.104: RZ351.1 313.69,94.84 313.69,96.01 v1(313.82,96.15) 314.1,96.15 314.68,96.72 DZ11.3 314.68,97.35 314.61,97.42 314.32,97.42 314.25,97.49 314.25,98.2 314.24,98.21 314.24,99.32 v4(314.02,99.54) 313.3,100.26 312.88,100.26 312.32,100.82 312.32,101.32 312.53,101.53 312.66,101.53 312.89,101.3 JFPBTN1.4
USB20_P9_USH: length 101.7
  IN1 w0.094: v1(271.9,31.22) 271.91,31.24 271.91,32.12 272.29,32.51 272.75,32.51 273.89,33.64 273.89,33.84 275.09,35.04 275.21,35.04 276.8,36.63 276.8,43.75 278.14,45.1 278.14,46.17 278.7,46.73 279.4,46.73 280.68,48.02 280.68,49.79 282.2,51.3 284.92,51.3 285.23,50.99 289.42,50.99 289.6,50.81 294.78,50.81 297.75,53.78 297.75,55.08 296.69,56.15 296.69,57.34 295.78,58.25 295.78,61.59 296.46,62.26 296.46,67.75 296.79,68.08 296.79,71.08 297,71.29 297,76.69 296.44,77.26 296.44,89.04 299.72,92.32 299.86,92.32 300.7,93.16 307.91,93.16 308.59,93.84 310.95,93.84 311.89,92.9 v1(312.71,92.9)
  BOTTOM w0.104: v1(312.71,92.9) 312.43,92.9 312.3,93.03 312.3,93.2 312.48,93.38 313.45,93.38 313.69,93.61 313.69,93.84 RZ351.2 ; v1(271.9,31.22) 272.04,31.36 272.04,31.74 271.93,31.85 JUSH1.22
USB20_P10: length 160.5
  IN2 w0.119: v1(150.13,101.96) 150.35,101.75 150.72,101.75 151.33,102.36 151.33,104.34 154.49,107.5 158.1,107.5 158.23,107.63 162.18,107.63 167.08,102.73 167.08,98.28 169.89,95.47 174.91,95.47 175.54,94.84 175.54,93.73 176.4,92.87 177.23,92.87 178.3,91.8 180.01,91.8 181.36,90.45 181.36,89.85 183.78,87.43 188.7,87.43 191.77,84.37 191.77,82.38 192.61,81.54 194.18,81.54 201.39,74.32 201.39,71.72 201.98,71.13 201.98,70.25 203.72,65.64 203.72,62.36 214.87,51.2 215.49,51.2 221.45,45.23 231.69,45.23 232.68,44.25 239.63,44.25 240.78,45.4 241.82,45.4 242.45,46.03 243.91,46.03 244.57,46.69 247.88,46.69 250.79,49.6 251.42,49.6 v1(251.62,49.8)
  BOTTOM w0.076: UC1.CC4 146.93,89.43 146.65,89.71 146.65,90.04 146.5,90.38 146.5,90.63 146.54,90.73 146.54,90.95 146.5,91.05 146.5,91.19 146.5,91.2 146.5,93.66 146.88,94.04 146.88,95.06 148.85,97.03 148.85,97.12 148.85,97.13 148.85,97.18 148.83,97.19 148.83,97.2
  BOTTOM w0.104: 148.83,97.2 148.83,98.34 148.82,98.35 148.82,98.92 148.83,98.93 148.83,100.98 149.57,101.72 149.89,101.72 v1(150.13,101.96) ; v1(251.62,49.8) 251.81,49.6 252.41,49.6 252.57,49.75 252.57,50.19 253.01,50.63
USB20_P10_R: length 4.9
  BOTTOM w0.104: LI9.3 254.46,52.08 254.46,52.55 254.47,52.56 254.47,53.35 v4(254.7,53.57) 254.9,53.78 256.04,53.78 256.14,53.88 JNGFF1.3
USB_OC0#: length 220
  TOP w0.127: v1(294.15,78.83) 294.15,78.83 294.59,78.39 UI3.13 ; RC758.1 173.2,93.32 v1(173.55,93.32) 174.09,93.32 RC837.2 v2(174.36,94.76)
  IN2 w0.122: v1(294.15,78.83) 294.15,79.1 292.55,80.7 291.6,80.7 291.41,80.51 291.41,80.4 291.06,80.05 290.7,80.05 289.85,79.21 289.85,78.77 290.9,77.72 290.9,75.56 291.08,75.38 291.08,74.08 289.16,72.15 288.42,72.15 287.97,71.7 287.97,70.44 288.96,69.45 288.96,68.35 289.48,67.83 289.48,65.79 289.31,65.62 289.31,63.62 290.14,62.8 290.14,58.29 289.49,57.64 v1(288.61,57.64)
  IN4 w0.076: 158.24,92.06 157.74,91.56 153.88,91.56 151.13,88.82 151.13,88.52 151.14,88.52 151.14,88.37 151.47,88.04 v1(151.49,88.04)
  IN4 w0.084: v1(288.61,57.64) 287.14,57.64 286.32,56.83 282.39,56.83 281.78,56.22 277.59,56.22 277.34,55.96 277.34,55.46 276.66,54.78 271.82,54.78 271.27,54.23 267.43,54.23 266.28,53.08 265.86,53.08 263.25,50.48 261.59,50.48 257.63,46.52 257.63,43.1 256.5,41.98 251.65,41.98 250.89,41.21 247.28,41.21 245.71,39.64 240.67,39.64 239.92,38.88 228.93,38.88 228.44,38.4 226.61,38.4 225.41,39.6 222.02,39.6 221.41,40.21 218.14,40.21 215.3,43.04 213.54,43.04 199.51,57.08 197.11,57.08 192.73,61.46 192.73,66.53 191.52,67.74 191.52,69.07 190.25,70.33 190.25,73.88 187.4,76.73 186.12,76.73 184.96,77.89 184.55,77.89 180.62,81.83 180.62,82.99 178.44,85.16 178.44,86.18 176.45,88.17 176.45,91.08 174.2,93.32 v1(173.55,93.32) ; 166.79,94.74 161.49,94.74 160.82,94.07 160.58,94.07 158.57,92.06 158.24,92.06
  IN4 w0.102: 166.79,94.74 168.56,92.97 172.8,92.97 173.15,93.32 v1(173.55,93.32)
  BOTTOM w0.089: UC1.CK6 v1(151.49,88.04)
USB_OC1#: length 256.6
  TOP w0.127: v1(27.54,44.08) v2(28.26,44.08) ; RC839.2 v1(173.62,92.77) RC759.1
  IN2 w0.122: v1(193.85,58.2) 193.85,57.68 195.08,56.45 195.08,55.55 191.22,51.69 189.75,51.69 188.92,50.86 188.92,50.08 183.87,45.03 159.78,45.03 157.61,42.86 137.83,42.86 134.47,46.22 119.83,46.22 119.7,46.35 85.17,46.35 81.62,42.8 67.96,42.8 67.34,42.18 54.75,42.18 53.39,40.82 45.47,40.82 44.96,41.33 44.96,41.64 40.95,45.65 40.32,45.65 v1(40.2,45.53)
  IN4 w0.084: v1(173.62,92.77) 174.49,92.77 175.27,91.99 175.27,88.39 175.75,87.9 176.45,87.9 176.92,87.43 178.23,86.12 178.23,85.07 180.43,82.88 180.43,81.75 184.47,77.71 184.88,77.71 186.05,76.55 187.32,76.55 190.06,73.8 190.06,70.26 191.33,68.99 191.33,67.66 192.54,66.46 192.54,61.34 193.85,60.03 v1(193.85,58.2) ; v1(27.54,44.08) 35.65,44.08 36.65,45.08 36.65,45.11 36.87,45.33 39.68,45.33 39.73,45.37 40.05,45.37 v1(40.2,45.53)
  IN4 w0.102: v1(173.62,92.77) 168.47,92.77 166.7,94.54 162.12,94.54 159.17,91.59 158.03,91.59 157.64,91.2 154.97,91.2 153.31,89.54 152.36,89.54 v1(151.49,88.67)
  BOTTOM w0.089: v1(151.49,88.67) UC1.CK5
  BOTTOM w0.127: v1(27.54,44.08) 27.32,43.86 UI1.3
USB_OC2#: length 29.5
  TOP w0.127: RC838.2 v1(173.68,91.05) RC760.1
  IN4 w0.084: v1(151.49,86.77) 154.44,89.71 158.06,89.71 162.7,94.35 166.62,94.35 169.14,91.82 172.91,91.82 v1(173.68,91.05)
  BOTTOM w0.089: v1(151.49,86.77) UC1.CK8
  BOTTOM w0.127: v1(173.68,91.05) v2(173.68,91.85)
USB_OC3#: length 28.9
  TOP w0.127: RC757.1 v1(173.68,90.23) RC836.2
  IN4 w0.084: v1(151.48,86.11) 151.84,86.47 151.94,86.47 154.96,89.48 158.38,89.48 162.86,93.96 166.46,93.96 168.98,91.43 172.47,91.43 v1(173.68,90.23)
  BOTTOM w0.076: v1(151.48,86.11) UC1.CK9
USB_POWERSHARE_EN#: length 19.9
  TOP w0.127: UE1.J3 279.02,79.29 v1(279.41,78.9) ; v1(286.47,76.19) 286.84,75.83 RE807.1 ; v1(292.87,73.59) 293.31,73.59 v2(293.36,73.64) 293.59,73.87 UI3.6
  IN1 w0.084: v1(286.47,76.19) 286.14,76.19 285.72,76.61 285.72,77.12 283.66,79.18 283.35,79.18 283.18,79.01 281.72,79.01 281.2,78.5 279.81,78.5 v1(279.41,78.9)
  BOTTOM w0.127: v1(292.87,73.59) 292.87,73.7 292.41,74.16 290.96,74.16 290.79,73.98 289.32,73.98 288.53,74.77 287.7,74.77 286.45,76.02 286.45,76.18 v1(286.47,76.19)
USB_POWERSHARE_VBUS_EN: length 20.2
  TOP w0.102: RE809.1 281.44,73.54 281.64,73.75 v1(281.64,73.78) 281.63,73.78 281.25,74.16 281.25,74.68 281.26,74.7 281.26,75.79 281.25,75.8 281.25,75.85 279.42,77.68 279.42,78.16 UE1.J2
  TOP w0.127: UI3.5 293.09,74.29 292.96,74.16 292.03,74.16 291.19,73.32 289.63,73.32 289.46,73.49 v2(288.47,73.49) 288.38,73.49 288.23,73.34 v1(287.93,73.34)
  IN1 w0.084: v1(281.64,73.78) 282.86,73.78 284.06,74.99 285.26,74.99 285.84,74.41 286.59,74.41 287.65,73.34 v1(287.93,73.34)
USB_PWR_EN1#: length 316.4
  TOP w0.127: v1(29.43,43.2) v2(30.04,43.8) ; UE1.K3 280.19,78.99 280.19,78.96 280.22,78.93 v1(280.22,78.88) ; v1(286.59,73.87) 287.08,74.36 RE808.1
  IN1 w0.084: v1(286.59,73.87) 286.24,74.22 285.76,74.22 285.18,74.8 284.61,74.8 283.91,74.11 283.91,73.69 283.63,73.41 280.92,73.41 v1(280.55,73.78)
  IN3 w0.122: v1(29.43,43.2) 32.1,43.2 34.87,45.97 41.78,45.97 44.09,43.65 68.05,43.65 68.56,44.16 93.72,44.16 95.46,45.9 120.09,45.9 120.3,46.11 136.88,46.11 140.58,42.41 204.63,42.41 208.08,38.96 210.42,38.96 214.22,35.17 218.53,35.17 220.76,32.94 224.84,32.94 225.57,32.2 238.5,32.2 240.54,30.16 244.09,30.16 246.44,32.51 254.99,32.51 256.98,34.5 258.7,34.5 259.45,35.25 260.23,35.25 261.9,36.92 263.43,36.92 263.88,37.36 268.54,37.36 272.51,41.34 273.51,41.34 275.04,42.88 275.04,44.29 275.46,44.71 275.46,45.9 274.85,46.51 274.85,47.18 275.27,47.59 275.27,49.07 275.77,49.57 276.31,49.57 278.07,51.33 278.07,51.46 278.98,52.36 280.93,52.36 282.23,53.66 283.3,53.66 283.54,53.9 283.54,55.75 285.42,57.64 285.42,58.16 285.87,58.61 285.87,61.03 285.32,61.58 285.32,62.55 285.55,62.78 285.55,65.62 285.01,66.16 285.01,69.78 286.07,70.83 286.07,73.29 286.59,73.81 v1(286.59,73.87)
  BOTTOM w0.127: v1(29.43,43.2) 29.2,43.43 UI1.4 ; v1(280.55,73.78) 279.77,74.56 279.77,76.87 280.63,77.73 280.63,78.47 v1(280.22,78.88)
USB_PWR_EN2#: length 15.6
  TOP w0.127: RE806.1 278.47,70.17 v1(278.58,70.28) 278.96,70.28 v2(279.33,70.64) ; UE1.G5 277.06,80.59 277.05,80.59 v1(277.02,80.56)
  BOTTOM w0.127: v1(278.58,70.28) 278.58,70.27 278.23,69.92 277.42,69.92 277.25,70.1 277.25,71.74 276.87,72.12 276.87,73.77 278.35,75.25 278.35,76.53 278.13,76.75 278.13,79.64 277.21,80.56 v1(277.02,80.56)
USBCOMP: length 11.7
  TOP w0.381: RC47.1 152.14,97.91 v1(152.14,97.31)
  IN4 w0.2: v1(147.79,88.67) 147.79,90.06 149.49,91.76 149.49,93 149.5,94.94 151.87,97.31 v1(152.14,97.31)
  BOTTOM w0.2: v1(147.79,88.67) UC1.CC5
USH_DET#: length 168.2
  TOP w0.102: UE1.C13 274.2,87.36 273.46,88.1
  TOP w0.127: 273.46,88.1 272.85,88.7 271.41,88.7 271.04,88.34 269.87,88.34 267.63,90.58 RE526.1 267.63,90.96 268.1,91.43 268.1,97.97 268.74,98.61 v1(268.74,98.93) ; v2(271.95,35.24) 272.34,34.85 v1(272.34,34.62)
  IN2 w0.122: v1(295.67,97.72) 294.65,98.75 291.55,98.75 290.97,98.16 283.91,98.16 283.67,98.41 278.27,98.41 278.11,98.58 273.04,98.58 272.1,99.52 269.33,99.52 v1(268.74,98.93)
  IN4 w0.084: v1(295.67,97.72) 295.67,97.72 295.67,86.59 298.34,83.92 298.34,74.35 297.13,73.15 297.13,68.16 296.81,67.84 296.81,67.28 297.54,66.55 298.7,66.55 299.17,66.08 299.17,60.74 298.47,60.04 298.47,57.67 297.87,57.08 297.87,56.05 295.35,53.52 293.88,53.52 291.4,51.05 287.65,51.05 287.59,50.98 285.44,50.98 284.68,51.75 282.29,51.75 281.72,51.17 280.66,51.17 279.63,50.14 276.91,50.14 276.37,49.61 276.33,49.61 276.33,49.61 272.64,49.61 272.37,49.88 270.69,49.88 270.32,49.52 270.32,43.37 268.21,41.26 268.21,40.45 269.11,39.55 269.11,38.1 272.34,34.88 v1(272.34,34.62)
  BOTTOM w0.127: JUSH1.1 261.43,31.57 263.67,29.33 264.3,29.33 264.93,28.7 266.52,28.7 267.15,29.33 268.23,29.33 268.61,29.71 273.71,29.71 275.18,31.19 277.86,31.19 278.2,31.53 278.2,32.25 277.58,32.87 277.01,32.87 275.74,34.14 275.74,34.38 275.5,34.62 v1(272.34,34.62)
USH_EXPANDER_SMBCLK: length 102.6
  TOP w0.127: UE1.B3 v1(273,78.94) ; RZ8.2 270.94,30.34 CZ62.1 269.82,30.34 v2(269.12,31.05) 268.93,31.23 v1(268.93,31.57)
  IN4 w0.084: v1(268.93,31.57) 268.93,31.96 269.09,32.12 269.63,32.12 271.18,33.68 271.18,35.37 268.54,38.01 268.54,38.69 268.33,38.91 268.04,38.91 267.53,39.42 267.53,41.11 269.95,43.53 269.95,49.68 270.53,50.25 272.54,50.25 272.81,49.98 276.22,49.98 276.75,50.52 279.48,50.52 280.52,51.56 281.57,51.56 282.14,52.12 289.79,52.12 290.03,51.87 291.7,51.87 293.73,53.9 295.14,53.9 296.81,55.56 296.81,58.29 297.15,58.64 297.15,59.08 297.88,59.81 297.88,61.44 298.8,62.35 298.8,65.93 298.55,66.18 297.39,66.18 296.37,67.2 v1(296.37,68.69) ; v1(286.62,69.55) 286.62,70.07 285.39,71.31 283.85,71.31 283.36,71.79 282.09,71.79 281.54,72.35 278.44,72.35 276.37,74.42 276.37,77.77 275.85,78.29 273.64,78.29 v1(273,78.94)
  BOTTOM w0.127: JUSH1.16 v1(268.93,31.57) ; v1(296.37,68.69) 296.21,68.84 293.73,68.84 291.9,70.67 289.69,70.67 288.97,69.94 287.02,69.94 v1(286.62,69.55)
USH_EXPANDER_SMBDAT: length 102.3
  TOP w0.127: RZ9.2 271.01,29.48 CZ63.1 269.47,29.48 v2(269.26,29.69) 268.55,30.4 268.55,31.09 v1(268.42,31.22) ; UE1.E5 v1(275.42,80.56)
  IN4 w0.084: v1(275.42,80.56) 275.84,80.13 276.53,80.13 276.63,80.03 276.63,78.4 276.93,78.1 276.93,74.65 277.9,73.68 280.1,73.68 280.37,73.41 283.03,73.41 283.76,72.68 285.06,72.68 285.64,72.1 285.64,71.58 287,70.22 287.24,70.22 v1(287.92,69.55) ; v1(295.95,68.28) 295.95,67.35 296.5,66.81 297.31,65.99 298.47,65.99 298.61,65.85 298.61,62.43 295.84,59.65 295.84,56.42 295.84,56.27 291.63,52.06 290.11,52.06 289.87,52.3 282.06,52.3 281.5,51.75 280.33,51.75 279.28,50.7 276.68,50.7 276.14,50.17 272.89,50.17 272.62,50.44 270.45,50.44 269.77,49.75 269.77,49.66 269.75,49.65 269.75,45.19 267.35,42.78 267.35,38.03 267.86,37.51 268.72,37.51 271,35.23 271,33.76 269.55,32.31 269.01,32.31 268.42,31.72 v1(268.42,31.22)
  BOTTOM w0.127: v1(295.95,68.28) 293.97,68.28 291.81,70.44 289.97,70.44 289.08,69.55 v1(287.92,69.55) ; v1(268.42,31.22) 268.43,31.23 JUSH1.15
USH_PWR_STATE#: length 70
  TOP w0.127: v1(281.02,71.09) 280.83,71.09 280.36,71.56 RE608.1 ; v2(270.01,33.22) RZ10.2 270.97,33.85 271.33,34.21 v1(271.94,34.21)
  IN2 w0.122: v1(271.94,34.21) 271.94,35.09 272.82,35.98 272.82,37.06 273.4,37.64 273.4,40.06 274.39,41.05 274.39,44.41 275.09,45.1 275.09,45.71 274.14,46.67 274.14,48.43 275.74,50.03 276.07,50.03 277.24,51.2 279.68,51.2 281.42,52.94 284.95,52.94 286.45,54.45 286.45,57.78 287.17,58.49 287.17,61.26 287.78,61.88 287.78,63.69 286.44,65.04 286.44,66.39 v1(287.52,67.48)
  IN3 w0.122: v1(263.44,31.06) 263.44,31.93 263.56,32.05 264.48,32.05 265.37,32.95 269.42,32.95 270.68,34.21 v1(271.94,34.21)
  IN4 w0.084: v1(287.52,67.48) 287.52,68.12 285.2,70.45 282.93,70.45 282.29,71.09 v1(281.02,71.09)
  BOTTOM w0.127: v1(263.44,31.06) 263.44,31.6 263.44,31.61 263.44,31.83 263.43,31.84 JUSH1.5
USH_PWR_STATE#_R: length 6.7
  TOP w0.127: RE608.2 280.36,73.29 279.99,73.65 v2(279.99,73.84) 280.14,74 280.14,74.54 280.42,74.82 280.42,75.56 278.64,77.34 278.64,78.13 UE1.H2
UV24_SET: length 3.1
  BOTTOM w0.127: UV24.5 100.81,98.23 RV102.1 100.67,96.99 v2(101.07,96.59)
VCI_IN1#: length 5.8
  TOP w0.127: UE1.B5 273.19,80.96 272.73,80.5 272.42,80.5 272.05,80.13 271.34,80.13 270.9,79.69 269.73,79.69 v2(269.6,79.82) 268.98,80.44 RE507.1
VCI_IN2#: length 14.1
  TOP w0.127: UE1.D4 v1(274.62,79.76) ; RE508.1 269.5,71.42 269.57,71.42 269.57,71.42 v1(269.86,71.42) 270.19,71.09 v2(270.19,70.59)
  BOTTOM w0.127: v1(274.62,79.76) 274.62,79.78 274.25,80.15 273.59,80.15 273.38,79.94 273.38,79.58 273.15,79.35 272.59,79.35 271.48,78.23 271.48,73.66 269.86,72.04 v1(269.86,71.42)
VCI_IN3#: length 17.5
  TOP w0.127: RE822.1 v2(263.58,80.78) 262.96,81.4 v1(262.58,81.4) ; v1(275.43,79.76) 275.82,80.15 UE1.E4
  IN1 w0.084: v1(275.43,79.76) 275.05,80.13 273.5,80.13 272.99,80.64 272.68,80.64 272.19,81.13 272.19,81.25 271.81,81.63 271,81.63 270.71,81.34 266.96,81.34 266.64,81.65 262.83,81.65 v1(262.58,81.4)
VGA_IDENTIFY: length 13
  TOP w0.127: UE1.L9 281.04,84.58 v1(281.09,84.58) ; v2(276.46,92.44) 276.46,90.61 276.87,90.2 RE85.1 RE84.1 277.9,90.14 277.9,89.25 v1(277.35,88.7)
  IN3 w0.122: v1(281.09,84.58) 280.71,84.96 278,84.96 277.82,85.14 277.82,87.7 277.37,88.15 277.37,88.68 v1(277.35,88.7)
VID0_1V_PRIM_CORE: length 6
  TOP w0.254: PR418.2 182.95,30.97 182.67,31.25 PR420.1 182,31.25 v2(181.43,30.68) 181.43,29.46 180.87,28.9 PR408.2 181.09,28.28 PU402.9
VID0_1VS_VCCIO: length 7.1
  TOP w0.127: PR416.1 v2(91.97,24.49)
  TOP w0.254: PR416.1 PR414.2 90.28,25.79 87.4,25.79 87.13,26.07 87.13,26.43 86.87,26.68 PU401.9
VID1_1V_PRIM_CORE: length 5.4
  TOP w0.127: v2(186.72,31.86) 186,31.14 PR411.2
  TOP w0.254: PU402.8 182.91,29.55 184.15,30.79 PR417.2 184.97,31.14 PR419.1 185.76,31.13 PR411.2
VID1_1VS_VCCIO: length 3.6
  TOP w0.254: PU401.8 85.61,25.58 85.79,25.39 86.15,25.39 86.47,25.71 86.98,25.71 87.44,25.25 PR413.2 PR415.1
VIDALERT_N: length 156.2
  TOP w0.127: v2(117.29,105.61) 116.74,105.06 v1(116.74,104.13) ; PR604.2 v1(58.46,59.9) PR625.1
  IN2 w0.127: v1(58.46,59.9) 58.05,59.9 56.68,58.53 56.68,55.86 56.18,55.37 54.85,55.37 53.93,54.45 52.19,52.71 52.19,51.63 50.21,49.65 46.17,49.65 45.35,48.83 43.29,48.83 41.12,51 41.12,54.17 40.21,55.07 40.21,56.75 41.31,57.85 41.31,67.05 41.93,67.67 41.93,73.78 44.96,76.82 44.96,78.53 47.96,81.53 47.96,87.03 48.66,87.73 48.66,92.91 48.32,93.24 48.32,95.94 49.96,97.58 49.96,98.62 54.82,103.47 55.16,103.47 56.45,104.76 60.07,104.76 60.41,104.43 61.04,104.43 62.1,103.36 65.26,103.36 67.57,105.67 82.58,105.67 83.64,106.73 88.26,106.73 88.75,107.22 89.89,107.22 91.28,108.61 102.26,108.61 104.09,106.79 111.06,106.79 112.76,105.08 113.24,105.08 113.55,104.77 116.1,104.77 v1(116.74,104.13)
  BOTTOM w0.127: RC154.2 116.74,104.95 v1(116.74,104.13) 116.74,104.1 117.33,103.51 RC155.2
VIDSCLK: length 157.6
  TOP w0.127: PR601.2 v1(58.43,59.04) PR618.1
  IN2 w0.127: v1(117.86,104.13) 116.72,105.27 113.66,105.27 113.42,105.51 112.94,105.51 111.24,107.22 104.27,107.22 102.44,109.05 91.1,109.05 89.75,107.69 88.5,107.69 87.97,107.16 83.46,107.16 82.4,106.1 67.39,106.1 65.08,103.8 62.28,103.8 61.22,104.86 60.59,104.86 60.25,105.19 56.27,105.19 54.98,103.91 54.64,103.91 49.53,98.8 49.53,97.76 47.89,96.12 47.89,92.96 48.23,92.63 48.23,87.91 47.53,87.21 47.53,81.71 44.53,78.71 44.53,77 41.49,73.96 41.49,67.85 40.87,67.23 40.87,58.02 39.78,56.93 39.78,54.77 40.68,53.87 40.68,50.82 43.11,48.39 45.68,48.39 46.49,49.21 50.43,49.21 52.65,51.43 52.65,52.51 55.06,54.92 56.35,54.92 57.11,55.69 57.11,58.18 57.97,59.04 v1(58.43,59.04)
  BOTTOM w0.127: RC159.2 v2(118.46,104.07) 118.4,104.13 v1(117.86,104.13) 117.86,104.14 117.55,104.45 117.55,104.75 RC158.2
VIDSCLK_R: length 12.6
  BOTTOM w0.076: UC1.AA1 121.21,91.4 121.3,91.49 121.3,93.62 121.16,93.76
  BOTTOM w0.127: 121.16,93.76 121.16,95.75 120.02,96.9 120.02,98.55 119.18,99.38 v2(119.18,99.55) 119.18,100.81 118.46,101.53 RC159.1
VIDSOUT: length 155.2
  TOP w0.127: v2(115.88,105.62) 116.15,105.35 v1(116.15,104.08) ; PR605.2 v1(58.43,60.75) 58.43,61.18 58.55,61.3 58.92,61.3 59.02,61.2 PR626.1
  IN2 w0.127: v1(116.15,104.08) 115.91,104.32 113.39,104.32 113.06,104.65 112.58,104.65 110.88,106.35 103.91,106.35 102.08,108.18 91.46,108.18 90.02,106.74 89.03,106.74 88.59,106.3 87.55,106.3 87.55,106.29 83.82,106.29 82.76,105.24 67.75,105.24 65.44,102.93 61.92,102.93 60.86,103.99 60.23,103.99 59.89,104.33 56.63,104.33 55.34,103.04 55,103.04 50.4,98.44 50.4,97.4 48.76,95.76 48.76,93.42 49.09,93.09 49.09,87.55 48.39,86.85 48.39,81.35 45.39,78.35 45.39,76.64 42.36,73.61 42.36,67.49 41.74,66.87 41.74,57.67 40.64,56.57 40.64,55.25 41.55,54.34 41.55,51.22 43.5,49.27 45.14,49.27 46.03,50.16 50.11,50.16 51.76,51.81 51.76,52.89 53.75,54.88 54.68,55.81 55.95,55.81 56.25,56.11 56.25,58.79 58.21,60.75 v1(58.43,60.75)
  BOTTOM w0.127: RC156.2 116.04,104.19 v1(116.15,104.08) 116.62,103.62 RC157.2
VIDSOUT_R: length 14
  BOTTOM w0.076: UC1.AA2 120.78,90.94 120.78,91.62 120.85,91.69 120.85,93.21 120.47,93.59
  BOTTOM w0.127: RC157.1 116.62,102.15 118.32,100.45 118.32,99.1 119.32,98.1 v2(119.32,97.77) 119.32,96.64 120.47,95.5 120.47,93.59
VOUT_2.5V_MEM: length 1.8
  TOP w0.127: PR515.1 117.25,26.87 v2(116.52,26.13)
VR_ENABLE_CPU_CORE: length 4.6
  TOP w0.203: PR616.2 60.56,55.61 61.66,56.72 v2(62.08,56.72) 62.94,56.72 63.44,57.21 PU602.40
VR_HOT#_CPU_CORE: length 5
  TOP w0.203: v1(60.54,56.5) 60.41,56.37 PR678.2 ; PU602.38 62.6,58.01 v2(62.54,57.95) 62.23,57.64 v1(61.05,57.64)
  IN2 w0.203: v1(60.54,56.5) 60.54,57.13 v1(61.05,57.64)
VR_LPM_R#: length 90.6
  TOP w0.254: v1(181.28,25.09) 181.28,24.55 v2(180.57,23.84) 180.52,23.79 PR430.1
  IN1 w0.084: v1(197.35,43.41) 199.49,41.26 199.49,38.53 199.8,38.22 199.8,33.22 198.45,31.86 192.21,31.86 189.68,29.34 189.68,29.27 186.7,26.28 182.47,26.28 v1(181.28,25.09)
  IN2 w0.122: v1(193.87,52.21) 193.87,48.56 197.35,45.09 v1(197.35,43.41)
  IN3 w0.122: v1(179.5,82.31) 179.91,81.9 179.91,80.07 181.55,78.43 182.22,78.43 182.99,77.66 182.99,77.04 184.64,75.39 184.64,72.09 185.31,71.41 185.31,58.03 187.05,56.29 188.31,56.29 192.39,52.21 v1(193.87,52.21)
  BOTTOM w0.127: RC867.2 176.79,82.9 UC9.4 178.1,82.4 178.1,82.86 RC660.2 179.25,83.46 179.5,83.21 v1(179.5,82.31)
VR_READY_CPU_CORE: length 5.1
  TOP w0.203: PR614.2 60.45,57.32 60.64,57.13 v2(60.84,57.13) 62.59,57.13 63.07,57.61 PU602.39
  TOP w0.254: PR612.2 PR614.2
VRALERT#: length 9.8
  TOP w0.127: RC73.1 151.04,62.78 150.29,62.78 v1(149.93,63.13) 149.41,62.61 v2(149.41,62.08)
  BOTTOM w0.076: UC1.CC36 147.38,69.13 147.65,68.65 147.65,68.38 147.47,68.21 147.47,67.72 149.1,66.1 149.1,63.97 v1(149.93,63.13)
VSET_5105: length 9.2
  TOP w0.127: RE77.1 CE38.1 v2(273.88,90.43) 273.88,89.83 v1(274.05,89.66) ; v1(273.8,84.6) 273.8,84.6 274.22,84.19 UE1.C9
  BOTTOM w0.127: v1(273.8,84.6) 273.76,84.6 273.39,84.97 273.39,86.48 274.05,87.13 v1(274.05,89.66)
VSYS_CHG: length 4
  TOP w0.203: PR721.1 51.31,53.25 v1(50.6,53.25) PU700.3
  TOP w0.254: PR721.1 PC745.1
  BOTTOM w0.127: v2(51.12,52.79) 50.66,53.25 v1(50.6,53.25)
VTTREF_DDR: length 2.1
  TOP w0.254: PU200.3 224.1,28.2 224.43,27.87 PC218.1 224.83,27.77 224.83,27.57 PC227.1
WIGIG_32KHZ: length 4.7
  TOP w0.127: v1(262.71,41.4) 262.71,42.2 v2(262.3,42.6) RZ56.2
  BOTTOM w0.127: JNGFF1.50 263.53,42.13 262.79,41.4 v1(262.71,41.4)
WLAN_COEX1: length 28.5
  TOP w0.127: RZ130.2 281.14,58.43 281.41,58.16 281.41,57.69 280.99,57.27 280.99,55.55 v2(280.77,55.33) 280.57,55.13 v1(279.93,55.13)
  IN3 w0.122: v1(268.16,42.87) 268.24,42.79 268.79,42.79 268.96,42.96 269.21,42.96 269.55,43.29 269.55,43.79 271.83,46.07 271.83,48.2 272.04,48.41 272.04,49.42 274.19,51.58 274.19,52.92 274.53,53.26 274.75,53.26 275.07,53.58 276.71,53.58 277.97,54.83 279.63,54.83 v1(279.93,55.13)
  BOTTOM w0.127: JNGFF1.48 265.27,42.63 265.54,42.89 268.14,42.89 v1(268.16,42.87)
WLAN_COEX2: length 30.3
  TOP w0.127: RZ129.2 v1(280.63,60.6) ; v1(268.63,43.18) 269.07,43.18 v2(269.4,43.5)
  IN3 w0.122: v1(268.63,43.18) 268.99,43.18 269.32,43.51 269.32,43.88 271.24,45.8 271.24,49.05 271.51,49.32 271.51,49.63 272.9,51.02 272.9,51.94 274.44,53.48 274.66,53.48 274.98,53.8 276.62,53.8 277.52,54.7 277.52,55.13 277.52,56.17 278.58,57.23 279.13,57.23 279.72,57.82 279.72,59.16 280.45,59.89 280.45,60.42 v1(280.63,60.6)
  BOTTOM w0.127: v1(268.63,43.18) 268.21,43.6 268,43.6 267.91,43.68 266.2,43.68 265.65,43.13 JNGFF1.46
WLAN_COEX3: length 30.3
  TOP w0.127: RZ128.2 278.66,60.9 278.66,59.73 278.42,59.5 277.56,59.5 277.45,59.4 275.02,59.4 274.51,58.89 272.92,58.89 271.79,57.75 271.79,57.05 v2(271.22,56.48) v1(271.22,55.81)
  IN2 w0.122: v1(271.22,55.81) 271.22,54.92 269.64,53.35 269.64,53.18 269.4,52.94 269.4,51.83 268.45,50.88 268.45,47.61 269.39,46.68 269.39,45.75 269.01,45.37 269.01,43.83 v1(268.87,43.68)
  BOTTOM w0.127: JNGFF1.44 265.82,43.63 266.1,43.91 268.64,43.91 v1(268.87,43.68)
WLAN_PWR_EN: length 22.9
  TOP w0.127: v1(253.17,41.02) v2(253.17,41.74) ; UZ47.5 v1(266.14,45.02) 266.14,45.52 RZ38.2
  IN3 w0.122: v1(266.14,45.02) 264.74,45.02 263.85,45.91 261.37,45.91 258.58,43.11 257.01,43.11 256.12,42.22 253.78,42.22 253.17,41.61 v1(253.17,41.02)
  BOTTOM w0.127: v1(253.17,41.02) 252.36,41.02 252.23,40.89 RZ71.2 252.23,40.25 253.2,39.29 DZ9.1 253.2,38.13 RZ70.2
WLAN_WIGIG60GHZ_DIS#: length 61.1
  TOP w0.102: v1(281.16,89.66) 281.16,88.37 281.11,88.32 281.11,87.85 UE1.L13
  TOP w0.127: v1(286.87,89.48) 286.87,92.4 287.24,92.77 287.72,92.77 287.97,93.01 RE8.1 ; v1(273.13,55.15) 272.87,54.89 v2(272.87,52.18) 272.87,51.28 273.22,50.92 DZ1.1
  IN1 w0.084: v1(281.16,89.66) 281.16,89.48 281.64,89.01 282.53,89.01 282.68,88.86 285.07,88.86 285.69,89.48 v1(286.87,89.48)
  IN3 w0.122: v1(273.13,55.15) 272.73,55.56 272.73,56.18 273.31,56.76 274.47,56.76 275.74,58.03 275.74,58.84 276.25,59.34 276.25,64.28 277.31,65.35 277.31,66.31 278.08,67.08 278.08,68.52 279.32,69.76 279.32,72.08 280.17,72.93 280.17,73.25 279.93,73.49 279.93,74.37 281.24,75.68 281.24,76.52 280.81,76.95 280.81,77.34 281.83,78.36 281.83,80.2 283.05,81.42 283.05,82.92 283.81,83.69 283.81,84.11 283.41,84.51 283.41,85.55 286.87,89.01 v1(286.87,89.48)
WLAN_WIGIG60GHZ_DIS#_R: length 16.7
  TOP w0.127: v1(270.75,43.35) 270.34,43.35 270.07,43.62 v2(270.07,44.91) 270.07,50.03 270.56,50.52 271.55,50.52 DZ1.2
  BOTTOM w0.127: JNGFF1.56 268.04,40.63 270.75,43.34 v1(270.75,43.35)
WP_GPU_SMCLK: length 322.7
  TOP w0.127: RE525.1 286.91,84.6 286.53,84.98 v1(286.32,84.98) 285.82,84.98 RE818.2
  TOP w0.254: v1(39.88,42.03) 40.07,42.03 40.46,41.65 40.46,40.96 41.5,39.92 PD901.3 42.1,39.92 42.53,40.34 v2(42.53,40.6) 42.53,40.63 42.78,40.89 v1(43,40.89)
  IN3 w0.122: v1(286.32,84.98) 286.75,85.41 290.82,85.41 291.44,84.78 291.44,82.64 292.42,81.66 292.42,78.56 291.58,77.72 291.09,77.72 290.39,78.41 286.01,78.41 285.7,78.11 285.7,76.6 286.08,76.22 286.08,76.03 287.28,74.83 287.28,73.21 286.51,72.44 286.51,70.65 285.76,69.9 285.76,69.2 286.46,68.51 286.46,65.52 288.11,63.87 288.11,61.72 287.25,60.86 287.25,59.09 286.32,58.15 286.32,57.9 285.42,57 285.42,54.81 283.83,53.22 282.42,53.22 281.12,51.91 280.32,51.91 279.2,50.79 278.26,50.79 276.33,48.86 276.33,47.72 276.13,47.52 276.13,40.93 274.95,39.74 274.12,39.74 273.2,38.83 273.2,38.03 272.41,37.24 269.41,37.24 268.11,35.94 267.52,35.94 267,36.47 262.09,36.47 260.54,34.92 260.54,34.53 260.06,34.05 257.45,34.05 255.36,31.95 247.31,31.95 245.07,29.71 240.36,29.71 238.61,31.46 231.49,31.46 231.25,31.7 225.45,31.7 224.7,32.44 220.62,32.44 218.34,34.72 213.75,34.72 209.96,38.52 207.9,38.52 204.49,41.92 139.61,41.92 136,45.53 121.65,45.53 121.13,45.02 95.49,45.02 94.19,43.72 68.75,43.72 68.2,43.17 44.39,43.17 43.92,42.7 43.92,41.81 v1(43,40.89)
  BOTTOM w0.254: v1(39.88,42.03) 40.14,42.28 41.03,42.28 41.28,42.03 PR953.2
WP_GPU_SMCLK_R: length 11
  TOP w0.102: UE1.F7 v1(276.26,82.2)
  TOP w0.127: v1(284,84.85) 284.34,85.2 RE818.1
  IN4 w0.084: v1(276.26,82.2) 277.03,82.2 277.46,82.63 281.55,82.63 282.28,83.35 282.28,84.15 282.98,84.85 v1(284,84.85)
WP_GPU_SMDAT: length 323.4
  TOP w0.127: RE524.1 286.68,83.36 286.35,83.69 286.35,84.35 286.32,84.38 v1(286.32,84.41) 286.29,84.41 285.98,84.72 285.75,84.72 RE817.2
  TOP w0.254: v1(43,40.32) 43,39.73 v2(42.5,39.24) 42.47,39.21 40.85,39.21 40.55,39.52 PD901.2 40.55,40.31 39.88,40.98 v1(39.88,41.41)
  IN3 w0.122: v1(43,40.32) 42.6,40.71 42.6,41.14 42.78,41.32 43.03,41.32 43.63,41.92 43.63,42.79 44.23,43.4 68.11,43.4 68.65,43.94 93.91,43.94 95.3,45.33 119.83,45.33 120.39,45.89 136.74,45.89 140.47,42.16 204.57,42.16 207.99,38.74 210.12,38.74 213.91,34.94 218.43,34.94 220.68,32.7 224.76,32.7 225.54,31.92 231.35,31.92 231.51,31.76 238.63,31.76 240.45,29.94 244.98,29.94 247.29,32.25 255.34,32.25 257.36,34.27 259.97,34.27 260.32,34.63 260.32,35.02 261.99,36.69 267.09,36.69 267.62,36.17 268.02,36.17 269.32,37.46 272.32,37.46 272.98,38.12 272.98,38.92 273.67,39.62 273.67,41.19 275.27,42.78 275.27,44.2 275.68,44.62 275.68,45.99 275.08,46.6 275.08,47.08 275.37,47.38 275.63,47.38 276.05,47.8 276.05,48.99 278.26,51.2 278.92,51.2 279.15,51.43 279.15,52.02 279.27,52.14 281.02,52.14 282.33,53.44 283.67,53.44 283.84,53.62 283.84,55.74 285.65,57.54 285.65,58.06 286.1,58.51 286.1,60.04 287.88,61.82 287.88,63.77 285.24,66.41 285.24,69.68 286.29,70.74 286.29,72.54 287.06,73.3 287.06,74.41 286.54,74.93 286.06,74.93 285.62,75.37 285.62,76.37 285.48,76.51 285.48,78.2 285.91,78.64 291.07,78.64 291.61,79.18 292.07,79.18 292.19,79.3 292.19,81.57 291.21,82.55 291.21,84.69 290.72,85.18 287.09,85.18 v1(286.32,84.41)
  BOTTOM w0.254: v1(39.88,41.41) 40.2,41.41 PR954.2
WP_GPU_SMDAT_R: length 16.4
  TOP w0.102: UE1.B6 273.33,81.76 v1(272.97,81.4)
  TOP w0.127: v1(284.49,84.6) 284.53,84.56 RE817.1 285.01,84.32 285.6,83.73 v2(285.96,83.73)
  IN4 w0.084: v1(272.97,81.4) 273.43,80.94 276.55,80.94 276.99,81.39 276.99,81.53 277.32,81.86 281.16,81.86 282.46,83.16 282.46,84.07 282.78,84.39 284.28,84.39 v1(284.49,84.6)
