# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D12: length 72.7
  IN4 w0.084: v1(63.76,32.83) 63.1,33.49 63.1,37.82 63.63,38.35 63.63,39.58 65.76,41.71 66.72,41.71 86.4,61.39 98.05,61.39 102.62,65.95 102.62,71.64 103.57,72.59 103.97,72.59 103.97,72.6 104.43,72.6 v1(104.82,72.98)
  BOTTOM w0.076: UC1.A30 109.22,72.84 108.48,72.84 108.33,72.99 107.71,72.99 107.17,72.45 105.42,72.45 104.89,72.98
  BOTTOM w0.089: 104.89,72.98 v1(104.82,72.98)
  BOTTOM w0.127: JDIMM1.24 63.21,32.27 v1(63.76,32.83)
DDR_A_D13: length 72.8
  IN4 w0.084: v1(106.72,72.98) 105.86,72.12 104.91,72.12 104.91,72.11 104.6,72.11 104.6,72.12 104.28,72.12 104.27,72.11 103.58,72.11 102.98,71.51 102.98,70.5 103.19,70.29 103.19,64.66 99.35,60.81 86.64,60.81 66.44,40.61 66.32,40.61 65.95,40.98 65.84,40.98 65.72,40.86 65.72,40.74 66.08,40.37 66.08,40.26 65.67,39.85 65.55,39.85 65.19,40.21 65.07,40.21 64.95,40.09 64.95,39.97 65.32,39.61 65.32,39.49 65.19,39.36 65.07,39.36 64.7,39.72 64.59,39.72 64.47,39.6 64.47,39.49 64.83,39.12 64.83,39.01 64.7,38.87 64.7,37.89 64.21,37.4 v1(63.76,37.4)
  BOTTOM w0.076: 108.32,73.33 108.45,73.33 108.61,73.16 108.9,73.16 109.09,73.36 109.47,73.36 109.67,73.25 110.3,73.25 110.61,72.93 UC1.C30
  BOTTOM w0.089: v1(106.72,72.98) 107.07,73.33 108.32,73.33
  BOTTOM w0.127: JDIMM1.29 64.46,37.68 64.17,37.4 v1(63.76,37.4)
DDR_A_D14: length 71.6
  IN4 w0.084: v1(67.75,35.76) 67.27,35.76 67.19,35.84 67.19,38.22 67.52,38.56 67.52,38.68 67.31,38.89 67.31,39.01 67.43,39.13 67.55,39.13 67.76,38.91 67.88,38.91 68,39.03 68,39.15 67.78,39.37 67.78,39.49 67.9,39.6 68.02,39.6 68.24,39.39 68.35,39.39 68.47,39.51 68.47,39.63 68.26,39.84 68.26,39.96 68.38,40.08 68.49,40.08 68.71,39.86 68.83,39.86 69.3,40.33 69.3,41 87.08,58.79 90.72,58.79 91,59.07 100.35,59.07 105.25,63.96 105.25,66.15 106.77,67.67 106.77,70.34 106.44,70.67 106.39,70.67 105.87,71.19 v1(105.87,71.7)
  BOTTOM w0.089: v1(105.87,71.7) 106.4,71.17 109.02,71.17 109.61,71.44 109.8,71.63 UC1.B32
  BOTTOM w0.127: JDIMM1.37 66.46,37.05 v1(67.75,35.76)
DDR_A_D15: length 71.7
  IN4 w0.084: v1(67.75,37.28) 68.01,37.28 68.09,37.37 68.09,37.66 68.01,37.74 67.56,37.74 67.48,37.82 67.48,37.99 67.56,38.07 68.01,38.07 68.09,38.16 68.09,38.72 68.94,39.56 69.17,39.56 69.58,39.98 69.58,40.8 69.67,40.89 69.96,40.89 70.04,40.97 70.04,41.34 87.2,58.5 91.21,58.5 91.29,58.58 91.29,58.7 91.38,58.78 91.55,58.78 91.63,58.7 91.63,58.58 91.71,58.5 91.88,58.5 91.96,58.58 91.96,58.7 92.05,58.78 92.22,58.78 92.3,58.7 92.3,58.58 92.38,58.5 92.55,58.5 92.64,58.58 92.64,58.7 92.72,58.78 92.89,58.78 92.97,58.7 92.97,58.58 93.05,58.5 93.22,58.5 93.31,58.58 93.31,58.7 93.39,58.78 93.56,58.78 93.64,58.7 93.64,58.58 93.72,58.5 93.89,58.5 93.98,58.58 93.98,58.7 94.06,58.78 94.23,58.78 94.31,58.7 94.31,58.58 94.4,58.5 94.56,58.5 94.65,58.58 94.65,58.7 94.73,58.78 94.9,58.78 94.98,58.7 94.98,58.58 95.07,58.5 95.23,58.5 95.32,58.58 95.32,58.7 95.4,58.78 95.57,58.78 95.65,58.7 95.65,58.58 95.74,58.5 95.9,58.5 95.99,58.58 95.99,58.7 96.07,58.78 96.24,58.78 96.32,58.7 96.32,58.58 96.41,58.5 96.57,58.5 96.66,58.58 96.66,58.7 96.74,58.78 96.91,58.78 96.99,58.7 96.99,58.58 97.08,58.5 97.25,58.5 97.33,58.58 97.33,58.7 97.41,58.78 97.58,58.78 97.66,58.7 97.66,58.58 97.75,58.5 97.92,58.5 98,58.58 98,58.7 98.08,58.78 98.25,58.78 98.33,58.7 98.33,58.58 98.42,58.5 98.59,58.5 98.67,58.58 98.67,58.7 98.75,58.78 98.92,58.78 99.01,58.7 99.01,58.58 99.09,58.5 99.26,58.5 99.34,58.58 99.34,58.7 99.42,58.78 99.59,58.78 99.68,58.7 99.68,58.58 99.76,58.5 100.44,58.5 101.41,59.47 105.75,63.81 105.75,66.11 107.02,67.38 107.02,70.72 106.43,71.32 v1(106.43,71.73)
  BOTTOM w0.076: UC1.C32 110.42,71.63 110.21,71.84 110.06,71.9 109.87,71.9 109.76,71.86 109.51,71.86 109.37,71.91 108.69,71.91 108.12,71.34 106.81,71.34 v1(106.43,71.73)
  BOTTOM w0.127: JDIMM1.41 67.46,37.58 v1(67.75,37.28)
DDR_A_D16: length 56.8
  IN1 w0.084: v1(114.1,77.34) 113.56,77.87 112.65,77.87 112.45,78.08 111.27,78.08 108.48,75.29 107.94,75.29 107.65,74.99 107.65,72.13 107.9,71.88 107.9,71.55 107.3,70.95 106.49,70.95 105.8,70.26 105.8,70.13 105.43,69.76 104.96,69.76 104.43,69.23 104.43,66.59 103.69,65.86 103.69,44.49 104.55,43.63 104.55,39.82 106.14,38.23 106.14,33.76 107.44,32.46 v1(107.44,32.46)
  BOTTOM w0.089: v1(114.1,77.34) UC1.J22
  BOTTOM w0.127: JDIMM1.194 107.71,32.19 v1(107.44,32.46)
DDR_A_D17: length 59.5
  IN1 w0.084: v1(113.46,75.3) 112.93,75.83 111.97,75.83 111.92,75.78 111.4,75.78 109.7,74.08 109.7,71.28 106.79,68.37 106.79,65.7 105.73,64.65 105.73,45.34 107.49,43.58 107.49,43.15 107.58,43.06 108.29,43.06 108.37,42.98 108.37,42.81 108.29,42.73 107.58,42.73 107.49,42.64 107.49,42.46 107.58,42.37 108.6,42.37 108.69,42.29 108.69,42.12 108.6,42.04 107.58,42.04 107.49,41.95 107.49,41.79 107.58,41.7 108.6,41.7 108.69,41.62 108.69,41.45 108.6,41.37 107.58,41.37 107.49,41.28 107.49,41.1 107.58,41.01 109.49,41.01 109.57,40.93 109.57,39.26 109.16,38.85 109.16,35.66 109.31,35.51 v1(110.34,35.51)
  BOTTOM w0.089: v1(113.46,75.3) UC1.H25
  BOTTOM w0.127: JDIMM1.203 109.96,38.42 109.69,38.15 109.69,36.15 v1(110.34,35.51)
DDR_A_D18: length 56.1
  IN1 w0.084: v1(107.44,35.51) 106.84,35.51 106.72,35.63 106.72,36.31 106.8,36.39 106.98,36.39 107.06,36.47 107.06,36.64 106.98,36.73 106.8,36.73 106.72,36.81 106.72,36.98 106.8,37.06 106.98,37.06 107.06,37.15 107.06,37.31 106.98,37.4 106.8,37.4 106.72,37.48 106.72,37.67 106.84,37.79 107.07,37.79 107.15,37.87 107.15,38.04 107.07,38.12 106.8,38.12 106.72,38.21 106.72,38.39 106.8,38.47 107.07,38.47 107.15,38.56 107.15,38.87 107.07,38.95 106.23,38.95 105.27,39.92 105.27,43.72 104.27,44.72 104.27,65.62 105,66.35 105,68.99 105.42,69.42 106.26,69.42 108.25,71.41 108.25,71.72 108.54,72.01 108.54,73.07 108.34,73.27 108.34,74.2 110.11,75.98 110.11,76.33 111.49,77.71 112.35,77.71 112.72,77.34 112.83,77.34 v1(112.83,77.34)
  BOTTOM w0.089: v1(112.83,77.34) 112.83,77.34 UC1.G22
  BOTTOM w0.127: v1(107.44,35.51) 107.04,35.9 107.04,38.19 106.96,38.28 JDIMM1.191
DDR_A_D19: length 55.4
  IN1 w0.084: v1(107.44,33.98) 106.43,34.99 106.43,38.35 104.9,39.87 104.9,43.68 103.98,44.6 103.98,65.74 104.71,66.47 104.71,69.11 105.19,69.59 106.19,69.59 108.07,71.48 108.07,71.79 108.37,72.08 108.37,72.86 108.07,73.16 108.07,74.19 109.8,75.92 109.8,76.37 111.34,77.9 112.38,77.9 112.57,77.71 113.09,77.71 v1(113.46,77.34)
  BOTTOM w0.089: v1(113.46,77.34) UC1.H22
  BOTTOM w0.127: JDIMM1.190 106.71,33.25 v1(107.44,33.98)
DDR_A_D20: length 59.3
  IN1 w0.084: v1(110.34,33.98) 110.78,34.42 110.78,41.38 106.72,45.44 106.72,47.07 106.64,47.15 106.39,47.15 106.3,47.24 106.3,47.41 106.39,47.49 106.64,47.49 106.72,47.57 106.72,47.74 106.64,47.83 106.39,47.83 106.3,47.91 106.3,48.08 106.39,48.16 106.64,48.16 106.72,48.24 106.72,48.41 106.64,48.5 106.39,48.5 106.31,48.58 106.31,48.75 106.39,48.83 106.64,48.83 106.72,48.91 106.72,49.08 106.64,49.17 106.39,49.17 106.31,49.25 106.31,49.42 106.39,49.5 106.64,49.5 106.72,49.59 106.72,49.75 106.64,49.84 106.39,49.84 106.31,49.92 106.31,50.09 106.39,50.17 106.64,50.17 106.72,50.26 106.72,50.42 106.64,50.51 106.39,50.51 106.31,50.59 106.31,50.76 106.39,50.84 106.64,50.84 106.72,50.93 106.72,51.11 106.64,51.2 106.39,51.2 106.3,51.28 106.3,51.45 106.39,51.53 106.64,51.53 106.72,51.61 106.72,51.78 106.64,51.87 106.39,51.87 106.3,51.95 106.3,52.12 106.39,52.2 106.64,52.2 106.72,52.29 106.72,52.45 106.64,52.54 106.39,52.54 106.3,52.62 106.3,52.79 106.39,52.87 106.64,52.87 106.72,52.96 106.72,53.12 106.64,53.21 106.39,53.21 106.3,53.29 106.3,53.46 106.39,53.54 106.64,53.54 106.72,53.63 106.72,53.79 106.64,53.88 106.39,53.88 106.3,53.96 106.3,54.13 106.39,54.21 106.64,54.21 106.72,54.3 106.72,54.46 106.64,54.55 106.39,54.55 106.3,54.63 106.3,54.8 106.39,54.88 106.64,54.88 106.72,54.97 106.72,55.14 106.64,55.22 106.39,55.22 106.3,55.3 106.3,55.47 106.39,55.55 106.64,55.55 106.72,55.64 106.72,55.81 106.64,55.89 106.39,55.89 106.3,55.97 106.3,56.14 106.39,56.22 106.64,56.22 106.72,56.31 106.72,56.48 106.64,56.56 106.39,56.56 106.3,56.64 106.3,64.17 106.39,64.26 106.64,64.26 106.72,64.34 106.72,64.75 107.32,65.35 107.32,68.41 110.05,71.14 110.05,73.88 111.47,75.3 v1(112.19,75.3)
  BOTTOM w0.089: v1(112.19,75.3) UC1.F25
  BOTTOM w0.127: v1(110.34,33.98) 111.21,33.11 JDIMM1.208
DDR_A_D21: length 57.1
  IN1 w0.084: v1(110.34,32.46) 110.71,32.46 111.14,32.89 111.14,41.44 107.01,45.56 107.01,56.84 106.92,56.93 106.67,56.93 106.59,57.01 106.59,57.18 106.67,57.26 106.92,57.26 107.01,57.35 107.01,57.51 106.92,57.6 106.67,57.6 106.59,57.68 106.59,57.85 106.67,57.93 106.92,57.93 107.01,58.02 107.01,58.18 106.92,58.27 106.67,58.27 106.59,58.35 106.59,58.52 106.67,58.6 106.92,58.6 107.01,58.69 107.01,58.85 106.92,58.94 106.67,58.94 106.59,59.02 106.59,59.19 106.67,59.27 106.92,59.27 107.01,59.36 107.01,59.53 106.92,59.61 106.67,59.61 106.59,59.69 106.59,59.86 106.67,59.94 106.92,59.94 107.01,60.03 107.01,60.2 106.92,60.28 106.67,60.28 106.59,60.36 106.59,60.53 106.67,60.62 106.92,60.62 107.01,60.7 107.01,60.87 106.92,60.95 106.67,60.95 106.59,61.03 106.59,61.2 106.67,61.29 106.92,61.29 107.01,61.37 107.01,61.54 106.92,61.62 106.67,61.62 106.59,61.7 106.59,61.87 106.67,61.96 106.92,61.96 107.01,62.04 107.01,62.21 106.92,62.29 106.67,62.29 106.59,62.38 106.59,62.54 106.67,62.63 106.92,62.63 107.01,62.71 107.01,64.7 107.54,65.24 107.54,68.39 110.28,71.12 110.28,73.79 111.35,74.86 113.66,74.86 v1(114.1,75.3)
  BOTTOM w0.089: v1(114.1,75.3) UC1.J25
  BOTTOM w0.127: JDIMM1.204 110.21,32.33 v1(110.34,32.46)
DDR_A_D22: length 56.1
  IN1 w0.084: v1(110.34,37.03) 109.94,37.03 109.86,36.95 109.86,35.88 109.78,35.79 109.53,35.79 109.45,35.88 109.45,37.35 109.53,37.43 109.9,37.43 109.99,37.52 109.99,37.69 109.9,37.77 109.53,37.77 109.45,37.85 109.45,38.02 109.53,38.1 110.03,38.1 110.12,38.19 110.12,38.36 110.03,38.44 109.53,38.44 109.45,38.52 109.45,38.73 109.57,38.86 109.77,38.86 109.86,38.94 109.86,41.22 109.77,41.3 109.06,41.3 108.97,41.39 108.97,41.57 109.06,41.65 109.77,41.65 109.85,41.74 109.85,41.91 109.77,41.99 109.06,41.99 108.97,42.07 108.97,42.79 108.41,43.35 108.13,43.35 106.43,45.05 106.43,45.36 106.35,45.44 106.1,45.44 106.02,45.53 106.02,45.69 106.1,45.78 106.35,45.78 106.43,45.86 106.43,46.03 106.35,46.11 106.1,46.11 106.02,46.2 106.02,46.36 106.1,46.45 106.35,46.45 106.43,46.53 106.43,46.7 106.35,46.78 106.1,46.78 106.02,46.87 106.02,64.45 107.07,65.5 107.07,68.4 109.88,71.21 109.88,74 111.5,75.62 111.99,75.62 112.04,75.67 112.46,75.67 v1(112.83,75.3)
  BOTTOM w0.089: v1(112.83,75.3) UC1.G25
  BOTTOM w0.127: v1(110.34,37.03) 110.96,37.65 JDIMM1.207
DDR_A_D23: length 55.2
  IN1 w0.084: v1(112.19,77.34) 111.45,77.34 110.46,76.35 110.46,75.97 109.13,74.64 109.13,72.36 108.42,71.64 108.42,71.34 106.17,69.08 106.09,69.08 105.75,68.74 105.75,66.7 104.56,65.5 104.56,44.84 105.55,43.84 105.55,43.26 105.64,43.17 106.22,43.17 106.32,43.08 106.32,42.88 106.24,42.79 105.64,42.79 105.55,42.71 105.55,42.54 105.64,42.46 106.24,42.46 106.32,42.37 106.32,42.2 106.24,42.12 105.64,42.12 105.55,42.04 105.55,41.87 105.64,41.79 106.24,41.79 106.32,41.7 106.32,41.53 106.24,41.45 105.64,41.45 105.55,41.37 105.55,41.2 105.64,41.11 106.24,41.11 106.32,41.03 106.32,40.85 106.24,40.76 105.64,40.76 105.55,40.68 105.55,40.51 105.64,40.43 106.24,40.43 106.32,40.34 106.32,40.16 106.24,40.07 105.85,40.07 105.77,39.99 105.77,39.82 105.85,39.74 106.24,39.74 106.32,39.65 106.32,39.32 106.4,39.24 107.35,39.24 107.44,39.15 v1(107.44,37.03)
  BOTTOM w0.076: v1(112.19,77.34) UC1.F22
  BOTTOM w0.127: v1(107.44,37.03) 107.96,37.55 JDIMM1.195
DDR_A_D24: length 64.7
  IN1 w0.084: v1(102.29,37.02) 102.29,37.23 100.55,38.98 100.55,40.74 100.8,40.99 100.8,50.24 100.72,50.32 100.42,50.32 100.34,50.4 100.34,50.57 100.42,50.66 100.72,50.66 100.8,50.74 100.8,50.91 100.72,50.99 99.99,50.99 99.9,51.08 99.9,51.24 99.99,51.33 100.72,51.33 100.8,51.41 100.8,51.58 100.72,51.66 99.99,51.66 99.9,51.75 99.9,51.91 99.99,52 100.72,52 100.8,52.08 100.8,52.23 100.7,52.33 100.1,52.33 99.9,52.53 99.9,53.16 95.04,58.02 95.04,72.73 100.42,78.1 101.64,78.1 101.75,78.22 106.84,78.22 v1(107.2,78.57)
  BOTTOM w0.076: UC1.D22 111.26,77.97 110.61,78.29 110.51,78.29 110.5,78.28 110.26,78.28 110.26,78.29 109.67,78.29 109.47,78.39 109.09,78.39 108.9,78.2 108.58,78.2 108.35,78.43
  BOTTOM w0.089: v1(107.2,78.57) 108.2,78.57 108.35,78.43
  BOTTOM w0.127: v1(102.29,37.02) 101.45,37.85 JDIMM1.169
DDR_A_D25: length 65
  IN1 w0.084: v1(104.03,78.57) 103.84,78.39 100.3,78.39 94.76,72.85 94.76,57.9 99.61,53.04 99.61,50.77 99.7,50.68 99.97,50.68 100.05,50.6 100.05,50.43 99.97,50.35 99.7,50.35 99.61,50.26 99.61,50.1 99.7,50.01 100.43,50.01 100.51,49.93 100.51,41.63 99.61,40.73 99.61,39.5 101.88,37.23 101.88,35.9 v1(102.29,35.49)
  BOTTOM w0.076: UC1.C22 110.58,77.97 110.46,77.85 110.06,77.7 109.87,77.7 109.76,77.74 109.52,77.74 109.41,77.7 108.39,77.7 108.22,77.87 106.15,77.87 106.08,77.94
  BOTTOM w0.089: v1(104.03,78.57) 104.66,77.94 106.07,77.94 106.08,77.94
  BOTTOM w0.127: JDIMM1.173 102.45,38.18 102.73,37.9 102.73,35.93 v1(102.29,35.49)
DDR_A_D26: length 64.3
  IN1 w0.084: v1(105.65,32.42) 104.55,33.52 104.55,36.67 102.41,38.81 102.41,40.68 102.34,40.76 102.34,41.03 102.26,41.11 102.06,41.11 101.97,41.19 101.97,41.36 102.06,41.45 102.26,41.45 102.34,41.53 102.34,41.7 102.26,41.78 102.06,41.78 101.97,41.87 101.97,42.03 102.06,42.12 102.26,42.12 102.34,42.2 102.34,42.37 102.26,42.45 102.06,42.45 101.97,42.54 101.97,42.7 102.06,42.79 102.26,42.79 102.34,42.87 102.34,43.04 102.26,43.12 102.06,43.12 101.97,43.21 101.97,43.37 102.06,43.46 102.26,43.46 102.34,43.54 102.34,43.71 102.26,43.79 102.06,43.79 101.97,43.88 101.97,44.04 102.06,44.13 102.26,44.13 102.34,44.21 102.34,44.38 102.26,44.46 102.06,44.46 101.97,44.55 101.97,44.71 102.06,44.8 102.26,44.8 102.34,44.88 102.34,45.05 102.26,45.13 102.06,45.13 101.97,45.22 101.97,45.39 102.06,45.47 102.26,45.47 102.34,45.55 102.34,45.72 102.26,45.8 102.06,45.8 101.97,45.89 101.97,46.06 102.06,46.14 102.26,46.14 102.34,46.22 102.34,46.39 102.26,46.48 102.06,46.48 101.97,46.56 101.97,46.73 102.06,46.81 102.26,46.81 102.34,46.89 102.34,47.06 102.26,47.15 102.06,47.15 101.97,47.23 101.97,52.75 101.82,52.91 101.82,64.1 102.34,64.62 102.34,66.42 103.07,67.15 103.07,69.67 102.48,70.26 102.48,72.51 100.83,74.16 100.83,76.27 101.63,77.07 102.68,77.07 v1(102.93,77.32)
  BOTTOM w0.076: 106.89,76.28 106.89,76.28 108.42,76.28 108.56,76.41 108.92,76.41 109.09,76.24 109.47,76.24 109.67,76.35 110.3,76.35 110.61,76.67 UC1.C24
  BOTTOM w0.089: 106.89,76.28 103.96,76.28 v1(102.93,77.32)
  BOTTOM w0.127: v1(105.65,32.42) 105.71,32.37 JDIMM1.186
DDR_A_D27: length 64.6
  IN1 w0.084: v1(105.65,36.99) 104.98,37.66 104.98,37.78 105.38,38.18 105.38,38.3 105.21,38.47 105.09,38.47 104.59,37.97 104.47,37.97 104.35,38.09 104.35,38.21 104.85,38.71 104.85,38.83 104.73,38.95 104.61,38.95 104.11,38.45 104,38.45 103.88,38.57 103.88,38.68 104.38,39.18 104.38,39.3 104.24,39.44 103.36,39.44 103.27,39.52 103.27,39.69 103.36,39.77 103.98,39.77 104.06,39.86 104.06,40.04 103.98,40.13 103.46,40.13 103.36,40.22 103.36,40.42 103.45,40.51 103.64,40.51 103.73,40.6 103.73,40.8 103.64,40.89 103.36,40.89 103.27,40.97 103.27,41.19 103.36,41.27 103.98,41.27 104.06,41.36 104.06,41.52 103.98,41.61 103.29,41.61 103.2,41.69 103.2,41.88 103.29,41.96 103.98,41.96 104.06,42.04 104.06,42.21 103.98,42.3 103.29,42.3 103.2,42.38 103.2,42.55 103.29,42.63 103.98,42.63 104.06,42.72 104.06,42.88 103.98,42.97 103.29,42.97 103.2,43.05 103.2,43.22 103.29,43.3 103.85,43.3 103.93,43.39 103.93,43.55 103.85,43.64 103.29,43.64 103.2,43.72 103.2,66.06 103.94,66.79 103.94,69.54 103,70.48 103,74.03 102.81,74.23 102.81,75.41 103.75,76.35 104.5,76.35 v1(105.47,77.32)
  BOTTOM w0.076: UC1.D24 111.26,76.67 111.26,77.4 111.23,77.44 111.06,77.61 110.82,77.61 110.27,77.61 110.08,77.54 109.85,77.54 109.73,77.58 109.55,77.58 109.44,77.54 109.43,77.54 108.32,77.54 108.16,77.7 105.85,77.7
  BOTTOM w0.089: 105.85,77.7 v1(105.47,77.32)
  BOTTOM w0.127: v1(105.65,36.99) 104.96,37.69 JDIMM1.183
DDR_A_D28: length 63.8
  IN1 w0.084: v1(102.29,33.97) 101.53,34.73 101.53,37.18 99.33,39.38 99.33,52.91 94.47,57.77 94.47,72.97 100.19,78.69 103.04,78.69 103.32,78.96 104.91,78.96 v1(105.3,78.57)
  BOTTOM w0.076: UC1.A22 109.31,77.97 109.22,77.87 108.45,77.87 108.29,78.03 106.23,78.03 106.16,78.1
  BOTTOM w0.089: v1(105.3,78.57) 105.68,78.19 106.07,78.19 106.16,78.1
  BOTTOM w0.127: v1(102.29,33.97) 101.65,33.97 101.52,33.84 101.52,32.79 101.71,32.6 JDIMM1.170
DDR_A_D29: length 64.5
  IN1 w0.084: v1(105.93,78.57) 105.36,79.14 103.15,79.14 102.99,78.98 100.07,78.98 94.18,73.08 94.18,57.63 99.01,52.81 99.01,39.3 101.13,37.18 101.13,33.61 v1(102.29,32.44)
  BOTTOM w0.076: UC1.B22 109.91,77.97 109.43,78.23 109.16,78.23 108.96,78.03 108.51,78.03 108.35,78.2 106.31,78.2 v1(105.93,78.57)
  BOTTOM w0.127: v1(102.29,32.44) 102.71,32.03 JDIMM1.174
DDR_A_D30: length 64.4
  IN1 w0.084: v1(105.65,35.47) 105.22,35.9 105.22,36.82 102.99,39.05 102.99,40.93 102.92,41 102.92,53.11 102.83,53.19 102.52,53.19 102.43,53.27 102.43,53.44 102.52,53.53 102.83,53.53 102.92,53.61 102.92,53.78 102.83,53.86 102.52,53.86 102.43,53.94 102.43,54.11 102.52,54.2 102.83,54.2 102.92,54.28 102.92,54.45 102.83,54.53 102.52,54.53 102.43,54.62 102.43,54.78 102.52,54.87 102.83,54.87 102.92,54.95 102.92,55.12 102.83,55.2 102.52,55.2 102.43,55.29 102.43,55.45 102.52,55.54 102.83,55.54 102.92,55.62 102.92,55.79 102.83,55.87 102.52,55.87 102.43,55.96 102.43,56.12 102.52,56.21 102.83,56.21 102.92,56.29 102.92,56.46 102.83,56.54 102.52,56.54 102.43,56.63 102.43,56.79 102.52,56.88 102.83,56.88 102.92,56.96 102.92,57.13 102.83,57.21 102.52,57.21 102.43,57.3 102.43,57.46 102.52,57.55 102.83,57.55 102.92,57.63 102.92,57.8 102.83,57.88 102.52,57.88 102.43,57.97 102.43,58.14 102.52,58.22 102.83,58.22 102.92,58.3 102.92,58.49 102.83,58.57 102.47,58.57 102.39,58.66 102.39,58.82 102.47,58.91 102.83,58.91 102.92,58.99 102.92,59.16 102.83,59.24 102.47,59.24 102.39,59.33 102.39,59.49 102.47,59.58 102.83,59.58 102.92,59.66 102.92,59.83 102.83,59.91 102.47,59.91 102.39,60 102.39,60.16 102.47,60.25 102.83,60.25 102.92,60.33 102.92,66.18 103.65,66.91 103.65,69.59 102.83,70.4 102.83,72.81 101.29,74.35 101.29,74.68 101.98,75.37 102.06,75.37 103.32,76.63 104.14,76.63 v1(104.83,77.32)
  BOTTOM w0.076: UC1.A24 109.31,76.67 109.24,76.74 108.43,76.74 108.3,76.61 107.07,76.61 107,76.68
  BOTTOM w0.089: 107,76.68 106.74,76.93 105.22,76.93 v1(104.83,77.32)
  BOTTOM w0.127: JDIMM1.187 105.96,38.08 106.41,37.63 106.41,35.82 106.06,35.47 v1(105.65,35.47)
DDR_A_D31: length 64.9
  IN1 w0.084: v1(104.2,77.32) 103.71,76.83 101.8,76.83 101.12,76.15 101.12,74.28 102.66,72.74 102.66,70.33 103.36,69.63 103.36,67.03 102.63,66.3 102.63,64.09 102.55,64 102.19,64 102.1,63.92 102.1,63.74 102.19,63.65 102.55,63.65 102.63,63.57 102.63,63.4 102.55,63.32 102.19,63.32 102.1,63.24 102.1,63.05 102.19,62.97 102.54,62.97 102.62,62.88 102.62,62.72 102.54,62.63 102.19,62.63 102.1,62.55 102.1,62.38 102.19,62.3 102.54,62.3 102.62,62.21 102.62,62.04 102.54,61.96 102.19,61.96 102.1,61.88 102.1,61.71 102.19,61.63 102.54,61.63 102.62,61.54 102.62,61.37 102.54,61.29 102.19,61.29 102.1,61.21 102.1,61.04 102.19,60.95 102.54,60.95 102.62,60.87 102.62,60.7 102.54,60.62 102.19,60.62 102.1,60.54 102.1,53.03 102.63,52.5 102.63,40.88 102.7,40.81 102.7,38.93 104.84,36.79 104.84,35.39 104.92,35.3 105.21,35.3 105.29,35.22 105.29,35.05 105.21,34.97 104.92,34.97 104.84,34.88 104.84,34.72 104.92,34.63 105.21,34.63 105.29,34.55 105.29,34.38 105.21,34.3 104.92,34.3 104.84,34.21 104.84,34.03 104.92,33.94 v1(105.65,33.94)
  BOTTOM w0.076: UC1.B24 109.91,76.67 109.43,76.4 109.16,76.4 108.99,76.57 108.49,76.57 108.36,76.44 106.98,76.44 106.91,76.51
  BOTTOM w0.089: v1(104.2,77.32) 104.91,76.61 106.81,76.61 106.91,76.51
  BOTTOM w0.127: JDIMM1.182 104.71,32.59 104.86,32.74 104.86,33.76 105.04,33.94 v1(105.65,33.94)
DDR_A_D32: length 65.6
  IN4 w0.084: v1(69.28,34.26) 69.87,34.26 70.16,34.55 70.16,37.38 70.65,37.88 70.65,38.79 72.2,40.34 72.2,40.82 72.46,41.08 72.46,41.85 87.76,57.15 101.23,57.15 v1(108.72,64.63)
  BOTTOM w0.076: UC1.H37 113.46,68.44 113.46,67.66 113.04,67.25 111.75,67.25 110.7,66.2
  BOTTOM w0.089: 110.7,66.2 109.76,66.2 109.37,65.81 109.37,65.29 v1(108.72,64.63)
  BOTTOM w0.127: v1(69.28,34.26) 69.7,33.83 JDIMM1.50
DDR_A_D33: length 67.3
  IN4 w0.084: v1(108.72,66.47) 107.56,65.31 107.56,64.52 100.77,57.72 87.53,57.72 70.82,41.01 70.82,39.77 70.45,39.4 70.1,39.4 69.49,38.79 69.26,38.79 68.87,38.4 68.87,35.87 68.95,35.78 v1(69.28,35.78)
  BOTTOM w0.076: UC1.H34 113.08,69.91 113.08,68.96 112.93,68.69 112.93,68.31 113.13,68.12 113.13,67.8 112.91,67.58 111.6,67.58 110.57,66.55
  BOTTOM w0.089: 110.57,66.55 108.8,66.55 v1(108.72,66.47)
  BOTTOM w0.127: JDIMM1.45 68.46,36.61 v1(69.28,35.78)
DDR_A_D34: length 69.1
  IN4 w0.084: v1(110.02,65.66) 110.47,65.22 110.47,63.06 110.17,62.76 109.78,62.76 102.7,55.69 88.37,55.69 84.26,51.57 84.26,51.46 84.6,51.11 84.6,50.99 84.49,50.87 84.37,50.87 84.02,51.22 83.9,51.22 73.92,41.24 73.92,39.99 72.11,38.18 72.11,33 v1(72.78,32.33)
  BOTTOM w0.076: UC1.K34 113.93,70.48 113.89,70.45 113.89,70.45 113.72,70.27 113.72,69.5 113.79,69.3 113.79,69.07 113.75,68.95 113.75,68.77 113.79,68.65 113.79,67.53 113.18,66.92 111.96,66.92 110.7,65.66
  BOTTOM w0.089: 110.7,65.66 v1(110.02,65.66)
  BOTTOM w0.127: JDIMM1.62 72.7,32.25 v1(72.78,32.33)
DDR_A_D35: length 68.5
  IN4 w0.084: v1(111.33,63.26) 111.33,62.71 103.45,54.83 89.66,54.83 89.33,54.5 89.21,54.5 88.88,54.83 88.76,54.83 88.64,54.71 88.64,54.59 88.98,54.26 88.98,54.14 88.86,54.02 88.74,54.02 88.4,54.36 88.28,54.36 88.16,54.25 88.16,54.13 88.5,53.79 88.5,53.67 88.38,53.55 88.26,53.55 88.18,53.63 88.06,53.63 87.94,53.51 87.94,53.4 88.03,53.31 88.03,53.19 76.21,41.37 75.79,41.37 75.29,40.87 75.29,40.14 73.57,38.42 73.57,36.16 v1(72.78,35.38)
  BOTTOM w0.076: 112.25,65.76 112.25,65.86 112.48,66.09 114.36,66.09 115.05,66.78 115.05,67.68 114.91,67.81 114.91,68.14 115.09,68.31 115.09,68.69 114.98,68.89 114.98,69.52 UC1.K35
  BOTTOM w0.089: v1(111.33,63.26) 112.25,64.18 112.25,65.76
  BOTTOM w0.127: JDIMM1.63 72.96,38.24 73.38,37.81 73.38,37.73 73.38,35.98 v1(72.78,35.38)
DDR_A_D36: length 66.1
  IN4 w0.084: v1(108.72,65.27) 100.89,57.44 87.65,57.44 72.17,41.97 72.17,41.23 72.09,41.14 71.35,41.14 71.27,41.06 71.27,40.84 71.35,40.76 71.83,40.76 71.91,40.68 71.91,40.46 71.73,40.28 71.21,40.28 71.1,40.17 71.1,39.65 70.57,39.11 70.22,39.11 69.86,38.75 69.86,38.56 70.33,38.08 70.33,37.97 70.15,37.79 70.03,37.79 69.41,38.41 69.29,38.41 69.16,38.28 69.16,38.16 69.87,37.45 69.87,37.16 69.71,37 69.59,37 v1(69.28,37.31)
  BOTTOM w0.076: UC1.H36 113.36,69.13 113.1,68.65 113.1,68.38 113.29,68.18 113.29,67.73 113.22,67.66 112.98,67.41 111.68,67.41 110.64,66.37
  BOTTOM w0.089: v1(108.72,65.27) 109.1,65.65 109.1,65.79 109.68,66.37 110.64,66.37
  BOTTOM w0.127: v1(69.28,37.31) 69.46,37.48 JDIMM1.49
DDR_A_D37: length 67.2
  IN4 w0.084: v1(108.72,63.36) 102.22,56.86 87.88,56.86 72.75,41.73 72.75,40.91 72.49,40.65 72.49,40.22 70.94,38.67 70.94,37.76 70.44,37.26 70.44,33.89 v1(69.28,32.73)
  BOTTOM w0.076: 110.76,66.03 111.82,67.08 113.11,67.08 113.62,67.6 113.62,68.63 113.58,68.74 113.58,68.98 113.62,69.09 113.62,69.28 113.46,69.74 UC1.H35
  BOTTOM w0.089: v1(108.72,63.36) 109.64,64.28 109.64,65.82 109.84,66.03 110.76,66.03
  BOTTOM w0.127: v1(69.28,32.73) 68.7,32.16 JDIMM1.46
DDR_A_D38: length 67.3
  IN4 w0.084: v1(111.33,64.53) 110.91,64.12 110.91,62.7 103.33,55.11 88.62,55.11 87.26,53.75 87.26,53.63 87.6,53.29 87.6,53.17 87.48,53.06 87.36,53.06 87.02,53.4 86.9,53.4 86.79,53.28 86.79,53.16 87.13,52.82 87.13,52.7 87.01,52.58 86.89,52.58 86.55,52.92 86.43,52.92 86.3,52.79 86.3,52.67 86.64,52.33 86.64,52.21 86.52,52.09 86.4,52.09 86.06,52.44 85.94,52.44 85.82,52.32 85.82,52.2 86.17,51.86 86.17,51.74 86.05,51.62 85.93,51.62 85.59,51.96 85.47,51.96 85.33,51.82 85.33,51.7 85.67,51.36 85.67,51.24 76.09,41.66 75.67,41.66 75,40.99 75,40.26 73.59,38.85 73.21,38.47 73.21,37.33 v1(72.78,36.9)
  BOTTOM w0.076: 112.07,65.82 112.07,65.92 112.41,66.26 114.29,66.26 114.88,66.85 114.88,67.61 114.75,67.74 114.75,68.21 114.93,68.38 114.93,68.65 114.66,69.13 UC1.K36
  BOTTOM w0.089: v1(111.33,64.53) 112.07,65.27 112.07,65.82
  BOTTOM w0.127: JDIMM1.59 71.96,38.35 72.73,37.57 72.73,36.95 v1(72.78,36.9)
DDR_A_D39: length 66.6
  IN4 w0.084: v1(111.33,65.17) 110.68,64.52 110.68,62.87 103.21,55.4 88.49,55.4 84.86,51.77 84.86,51.65 85.2,51.3 85.2,51.18 84.01,49.99 83.89,49.99 83.55,50.34 83.43,50.34 74.21,41.12 74.21,39.87 72.4,38.06 72.4,34.24 v1(72.78,33.85)
  BOTTOM w0.076: UC1.K37 114.59,68.46 114.59,67.68 114.72,67.55 114.72,66.92 114.22,66.42 112.34,66.42 111.33,65.41 v1(111.33,65.17)
  BOTTOM w0.127: JDIMM1.58 71.7,32.78 v1(72.78,33.85)
DDR_A_D40: length 66.8
  IN4 w0.084: v1(74.94,34.3) 74.43,34.3 74.34,34.38 74.34,37.64 74.43,37.72 75.21,37.72 75.29,37.8 75.29,37.99 75.21,38.07 74.77,38.07 74.68,38.16 74.68,38.32 74.77,38.41 75.21,38.41 75.29,38.49 75.29,39.04 76.81,40.56 76.81,40.88 76.96,41.03 77.33,41.03 77.41,41.11 77.41,41.48 89.67,53.74 103.46,53.74 111.98,62.26 111.98,63.79 v1(112.64,64.45)
  BOTTOM w0.076: 113.53,65.63 113.6,65.7 114.52,65.7 115.65,66.83 115.65,67.58 115.81,67.73 115.81,68.18 115.61,68.38 115.61,68.65 115.88,69.13 UC1.N36
  BOTTOM w0.089: v1(112.64,64.45) 113.02,64.83 113.02,65.12 113.39,65.49 113.53,65.63
  BOTTOM w0.127: v1(74.94,34.3) 73.7,33.07 JDIMM1.66
DDR_A_D41: length 66.8
  IN4 w0.084: v1(74.94,32.77) 74.06,33.66 74.06,38.21 75.78,39.94 75.78,40.66 76,40.88 76.41,40.88 89.55,54.02 103.34,54.02 111.72,62.4 111.72,64.8 v1(112.64,65.72)
  BOTTOM w0.076: UC1.N34 115.56,69.83 115.56,69.73 115.56,69.72 115.56,69.48 115.56,69.48 115.56,68.89 115.45,68.69 115.45,68.31 115.65,68.12 115.65,67.8 115.49,67.64 115.49,66.9 114.46,65.87 113.51,65.87 113.44,65.8
  BOTTOM w0.102: v1(112.64,65.72) 113.35,65.72 113.44,65.8
  BOTTOM w0.127: v1(74.94,32.77) 74.75,32.77 74.64,32.66 74.64,32.02 74.7,31.95 JDIMM1.70
DDR_A_D42: length 66.5
  IN4 w0.084: v1(78.38,36.3) 78.38,36.45 78.01,36.82 78.01,38.03 78.17,38.2 79.53,38.2 79.64,38.09 79.64,35.67 79.72,35.59 79.99,35.59 80.08,35.67 80.08,41.26 90.51,51.7 104.3,51.7 114.54,61.94 114.54,63.87 115.25,64.58 v1(115.25,64.64)
  BOTTOM w0.076: v1(115.25,64.64) 115.25,64.94 117.24,66.93 117.24,67.51 117.08,67.67 117.08,68.44 UC1.R37
  BOTTOM w0.127: JDIMM1.79 76.96,38.41 77.17,38.19 77.17,37.51 v1(78.38,36.3)
DDR_A_D43: length 66.8
  IN4 w0.084: v1(78.38,34.78) 77.98,35.18 77.98,36.36 77.73,36.62 77.73,38.15 78.05,38.48 79.71,38.48 79.79,38.57 79.79,41.38 90.4,51.99 104.18,51.99 114.37,62.17 114.37,64.57 v1(113.94,64.99)
  BOTTOM w0.076: 114.62,65.2 114.72,65.2 116.15,66.63 116.15,67.38 116.31,67.54 116.31,68.65 116.26,68.77 116.26,68.95 116.31,69.07 116.31,69.3 116.22,69.53 116.22,70.26 116.24,70.28 116.41,70.45 116.44,70.48 UC1.R34
  BOTTOM w0.089: 114.62,65.2 114.15,65.2 v1(113.94,64.99)
  BOTTOM w0.127: v1(78.38,34.78) 78.91,34.25 78.91,32.7 78.21,32 JDIMM1.84
DDR_A_D44: length 65.8
  IN4 w0.084: v1(74.94,37.35) 75.49,37.35 75.58,37.43 75.58,38.92 75.66,39.01 75.83,39.01 75.91,38.92 75.91,37.39 76,37.31 76.18,37.31 76.26,37.4 76.26,38.76 76.4,38.89 76.4,39.01 76.09,39.32 76.09,39.44 76.21,39.55 76.33,39.55 76.63,39.25 76.75,39.25 76.87,39.37 76.87,39.48 76.56,39.79 76.56,39.91 76.68,40.03 76.8,40.03 77.11,39.72 77.23,39.72 77.48,39.97 77.48,40.31 77.39,40.4 77.18,40.4 77.1,40.48 77.1,40.65 77.18,40.73 77.62,40.73 77.7,40.82 77.7,41.36 89.79,53.45 103.58,53.45 112.22,62.09 112.22,63.39 v1(112.64,63.81)
  BOTTOM w0.076: 113.62,65.47 113.69,65.54 114.59,65.54 115.82,66.76 115.82,67.51 115.97,67.67 115.97,68.44 UC1.N37
  BOTTOM w0.089: v1(112.64,63.81) 113.29,64.46 113.29,65.14 113.62,65.47
  BOTTOM w0.127: JDIMM1.67 73.96,38.33 v1(74.94,37.35)
DDR_A_D45: length 66.5
  IN4 w0.084: v1(74.94,35.82) 74.95,35.81 75.38,35.81 75.44,35.76 75.44,34.88 75.53,34.79 75.87,34.79 75.95,34.88 75.95,36.68 76.55,37.28 76.55,38.64 77.99,40.08 77.99,41.24 89.91,53.16 103.7,53.16 112.64,62.1 v1(112.64,62.54)
  BOTTOM w0.076: 113.7,65.3 113.78,65.37 114.66,65.37 115.98,66.7 115.98,67.45 116.14,67.6 116.14,68.63 116.1,68.74 116.1,68.98 116.14,69.09 116.14,69.28 115.97,69.74 UC1.N35
  BOTTOM w0.089: v1(112.64,62.54) 113.56,63.46 113.56,65.15 113.64,65.24 113.7,65.3
  BOTTOM w0.127: v1(74.94,35.82) 75.3,35.82 75.67,36.19 75.67,37.56 74.96,38.27 JDIMM1.71
DDR_A_D46: length 66.7
  IN4 w0.084: v1(78.38,37.82) 78.79,37.82 78.87,37.74 78.87,37.56 78.96,37.47 79.26,37.47 79.35,37.39 79.35,37.22 79.26,37.14 78.96,37.14 78.87,37.05 78.87,36.88 78.96,36.8 79.26,36.8 79.35,36.72 79.35,36.55 79.26,36.47 78.96,36.47 78.87,36.38 78.87,36.16 78.96,36.07 79.26,36.07 79.35,35.99 79.35,35.82 79.26,35.74 78.96,35.74 78.87,35.65 78.87,34.92 79,34.79 80.27,34.79 80.36,34.89 80.36,41.15 90.63,51.41 104.42,51.41 114.75,61.74 114.75,63.5 v1(115.25,64.01)
  BOTTOM w0.076: 115.63,65 115.63,65.1 117.4,66.86 117.4,67.58 117.25,67.73 117.25,68.18 117.44,68.38 117.44,68.65 117.18,69.13 UC1.R36
  BOTTOM w0.089: v1(115.25,64.01) 115.63,64.39 115.63,65
  BOTTOM w0.127: v1(78.38,37.82) 77.96,38.25 JDIMM1.83
DDR_A_D47: length 66.6
  IN4 w0.084: v1(115.25,62.74) 114.92,62.41 114.92,61.51 104.54,51.13 90.75,51.13 80.65,41.03 80.65,33.34 80.57,33.25 80.28,33.25 80.19,33.34 80.19,33.57 80.11,33.65 79.94,33.65 79.86,33.57 79.86,33.34 79.77,33.25 79.6,33.25 79.52,33.34 79.52,33.69 79.44,33.78 79.27,33.78 79.19,33.69 79.19,33.34 79.1,33.25 v1(78.38,33.25)
  BOTTOM w0.076: UC1.R35 117.5,69.52 117.5,68.89 117.61,68.69 117.61,68.31 117.41,68.12 117.41,67.8 117.57,67.64 117.57,66.8 115.81,65.04 115.81,64.94
  BOTTOM w0.089: 115.81,64.94 115.81,63.3 115.7,63.18 v1(115.25,62.74)
  BOTTOM w0.127: v1(78.38,33.25) 77.21,32.07 JDIMM1.80
DDR_A_D48: length 47.8
  IN1 w0.084: v1(112.03,71.95) 111.55,71.46 111.55,71.01 109.84,69.31 109.84,68.23 109.04,67.42 108.64,67.42 108.12,66.9 108.12,64.65 108.07,64.61 108.07,46.65 108.39,46.32 108.39,46.21 108.19,46 108.19,45.89 108.31,45.77 108.43,45.77 108.63,45.97 108.75,45.97 108.87,45.85 108.87,45.73 108.67,45.53 108.67,45.41 108.78,45.29 108.9,45.29 109.1,45.49 109.22,45.49 109.34,45.38 109.34,45.26 109.14,45.05 109.14,44.94 109.26,44.82 109.38,44.82 109.58,45.02 109.7,45.02 109.82,44.9 109.82,44.78 109.61,44.58 109.61,44.46 109.73,44.34 109.85,44.34 110.05,44.54 110.17,44.54 110.29,44.43 110.29,44.31 110.09,44.11 110.09,43.99 110.21,43.87 110.33,43.87 110.53,44.07 110.65,44.07 110.78,43.94 110.78,43.82 110.58,43.62 110.58,43.5 110.7,43.38 110.81,43.38 111.02,43.58 111.13,43.58 111.25,43.46 111.25,43.35 111.05,43.14 111.05,43.03 111.17,42.91 111.29,42.91 111.49,43.11 111.61,43.11 111.73,42.99 111.73,42.87 111.53,42.67 111.53,42.55 111.64,42.43 111.76,42.43 111.96,42.63 112.08,42.63 112.2,42.52 112.2,42.4 112,42.19 112,42.08 112.87,41.21 112.87,40.23 112.62,39.98 v1(112.62,36.99)
  BOTTOM w0.089: UC1.G31 v1(112.03,71.95)
  BOTTOM w0.127: JDIMM1.211 111.96,37.65 v1(112.62,36.99)
DDR_A_D49: length 49.7
  IN1 w0.084: v1(112.62,35.47) 112.93,35.47 113.02,35.56 113.02,38.82 113.11,38.91 113.75,38.91 113.83,39 113.83,39.18 113.75,39.27 112.99,39.27 112.91,39.35 112.91,39.52 112.99,39.6 113.75,39.6 113.83,39.69 113.83,39.85 113.75,39.94 113.25,39.94 113.16,40.02 113.16,40.19 113.25,40.27 113.75,40.27 113.83,40.36 113.83,40.54 113.75,40.63 113.24,40.63 113.15,40.71 113.15,40.88 113.24,40.96 113.75,40.96 113.83,41.04 113.83,41.19 113.75,41.27 113.24,41.27 113.15,41.35 113.15,41.97 108.36,46.76 108.36,66.79 108.74,67.17 109.06,67.17 110.09,68.2 110.09,69.31 111.15,70.37 111.24,70.37 111.93,71.06 111.93,71.25 v1(112.03,71.35)
  BOTTOM w0.089: UC1.G32 v1(112.03,71.35)
  BOTTOM w0.127: JDIMM1.215 112.96,37.96 113.05,37.87 113.05,35.9 v1(112.62,35.47)
DDR_A_D50: length 48.5
  IN1 w0.084: v1(115.92,36.9) 115.92,40.09 116.11,40.28 116.11,40.7 115.61,41.2 115.61,41.69 116.02,42.1 116.02,42.22 115.83,42.41 115.71,42.41 115.51,42.21 115.39,42.21 115.27,42.32 115.27,42.44 115.59,42.76 115.59,42.88 115.47,43 115.35,43 115.03,42.68 114.92,42.68 114.8,42.8 114.8,42.92 115.11,43.23 115.11,43.35 114.99,43.47 114.88,43.47 114.56,43.15 114.44,43.15 114.32,43.27 114.32,43.39 114.64,43.71 114.64,43.83 114.52,43.94 114.4,43.94 114.09,43.63 113.97,43.63 113.85,43.75 113.85,43.87 114.16,44.18 114.16,44.3 114.04,44.42 113.93,44.42 113.61,44.1 113.49,44.1 113.37,44.22 113.37,44.34 113.69,44.66 113.69,44.77 110.48,47.98 110.48,62.46 110.67,62.65 110.67,67.11 113.24,69.69 113.24,70.8 113.49,71.05 113.49,71.57 113.33,71.73 113.33,72.84 v1(112.95,73.22)
  BOTTOM w0.089: UC1.H29 v1(112.95,73.22)
  BOTTOM w0.127: v1(115.92,36.9) 115.45,37.37 JDIMM1.225
DDR_A_D51: length 48.9
  IN1 w0.084: v1(112.95,73.85) 113.49,73.31 113.49,71.79 113.65,71.64 113.65,70.96 113.43,70.74 113.43,69.63 110.92,67.12 110.92,62.39 110.77,62.24 110.77,48.1 116.72,42.15 116.72,41.65 116.64,41.57 116.29,41.57 116.21,41.48 116.21,41.32 116.29,41.23 116.91,41.23 116.99,41.15 116.99,40.62 116.53,40.17 116.53,35.46 116.45,35.38 v1(115.92,35.38)
  BOTTOM w0.089: UC1.H28 v1(112.95,73.85)
  BOTTOM w0.127: v1(115.92,35.38) 116.45,35.91 JDIMM1.229
DDR_A_D52: length 47.6
  IN1 w0.084: v1(112.04,73.85) 110.45,72.27 110.45,71.05 107.72,68.32 107.72,65.16 107.5,64.94 107.5,45.77 111.63,41.64 111.63,33.41 v1(112.62,32.42)
  BOTTOM w0.089: UC1.G28 v1(112.04,73.85)
  BOTTOM w0.127: JDIMM1.216 113.21,31.83 v1(112.62,32.42)
DDR_A_D53: length 48.8
  IN1 w0.084: v1(112.04,73.22) 110.81,71.99 110.81,71.35 110.63,71.17 110.63,70.34 109.67,69.38 109.67,69.18 108.67,68.18 108.67,67.7 107.92,66.94 107.92,64.88 107.78,64.75 107.78,45.89 111.91,41.76 111.91,40.17 112,40.09 112.25,40.09 112.33,40.01 112.33,39.84 112.25,39.76 112,39.76 111.91,39.67 111.91,39.5 112,39.42 112.25,39.42 112.33,39.34 112.33,39.17 112.25,39.08 112,39.08 111.91,39 111.91,38.83 112,38.75 112.25,38.75 112.33,38.67 112.33,38.5 112.25,38.41 112,38.41 111.91,38.33 111.91,38.16 112,38.08 112.16,38.08 112.25,38 112.25,34.03 112.33,33.94 v1(112.62,33.94)
  BOTTOM w0.089: UC1.G29 v1(112.04,73.22)
  BOTTOM w0.127: v1(112.62,33.94) 112.21,33.53 JDIMM1.212
DDR_A_D54: length 48.9
  IN1 w0.084: v1(115.92,33.85) 115.33,34.45 115.33,41.86 112.91,44.28 112.91,44.4 113.22,44.72 113.22,44.83 113.1,44.95 112.97,44.95 112.66,44.64 112.55,44.64 112.43,44.76 112.43,44.88 112.75,45.19 112.75,45.31 112.63,45.43 112.51,45.43 112.2,45.11 112.08,45.11 111.96,45.23 111.96,45.35 112.27,45.67 112.27,45.78 112.16,45.9 112.04,45.9 111.72,45.59 111.6,45.59 111.48,45.71 111.48,45.82 111.8,46.14 111.8,46.26 110.19,47.86 110.19,62.63 110.42,62.85 110.42,67.11 113.07,69.76 113.07,70.86 113.33,71.12 113.33,71.5 113.12,71.71 113.12,71.79 v1(112.95,71.95)
  BOTTOM w0.089: UC1.H31 v1(112.95,71.95)
  BOTTOM w0.127: JDIMM1.224 115.21,33.14 v1(115.92,33.85)
DDR_A_D55: length 49.6
  IN1 w0.084: v1(112.95,71.29) 112.88,71.21 112.88,70.09 110.25,67.47 110.25,67.46 109.66,66.87 109.66,47.99 109.91,47.74 109.91,47.62 109.66,47.38 109.66,47.26 109.78,47.14 109.9,47.14 110.15,47.39 110.27,47.39 110.38,47.27 110.38,47.15 110.07,46.83 110.07,46.71 110.19,46.6 110.31,46.6 110.62,46.91 110.74,46.91 110.86,46.79 110.86,46.67 110.54,46.36 110.54,46.24 110.66,46.12 110.78,46.12 111.1,46.44 111.21,46.44 111.33,46.32 111.33,46.2 111.02,45.88 111.02,45.77 115.01,41.78 115.01,33.48 114.92,33.39 114.26,33.39 114.18,33.31 114.18,33.1 114.26,33.02 115.23,33.02 v1(115.92,32.33)
  BOTTOM w0.089: UC1.H32 v1(112.95,71.29)
  BOTTOM w0.127: v1(115.92,32.33) 116.2,32.05 JDIMM1.228
DDR_A_D56: length 51.5
  IN1 w0.084: v1(117.98,37.35) 119.37,37.35 119.46,37.43 119.46,37.97 119.37,38.06 118.71,38.06 118.62,38.14 118.62,38.31 118.71,38.39 119.37,38.39 119.46,38.48 119.46,38.64 119.37,38.73 118.71,38.73 118.62,38.81 118.62,38.98 118.71,39.06 119.37,39.06 119.46,39.15 119.46,39.31 119.37,39.4 118.83,39.4 118.75,39.48 118.75,39.65 118.83,39.73 119.37,39.73 119.46,39.82 119.46,39.98 119.37,40.07 119.09,40.07 119.01,40.15 119.01,40.32 119.09,40.4 119.37,40.4 119.46,40.49 119.46,40.67 119.37,40.76 118.9,40.76 118.81,40.84 118.81,42.22 118.24,42.79 118.12,42.79 117.91,42.58 117.8,42.58 117.68,42.7 117.68,42.82 117.89,43.03 117.89,43.14 117.77,43.26 117.65,43.26 117.44,43.05 117.32,43.05 117.2,43.17 117.2,43.29 117.41,43.5 117.41,43.62 117.29,43.74 117.18,43.74 116.97,43.53 116.85,43.53 116.73,43.65 116.73,43.77 116.94,43.98 116.94,44.09 116.82,44.21 116.7,44.21 116.49,44 116.37,44 116.25,44.12 116.25,44.24 116.46,44.45 116.46,44.57 116.33,44.7 116.21,44.7 116.04,44.53 115.85,44.53 111.99,48.39 111.99,62.18 112.07,62.26 112.07,66.63 114.07,68.62 114.07,70.68 114.37,70.98 114.37,71.43 114.76,71.83 v1(114.76,71.95)
  BOTTOM w0.089: UC1.L31 114.76,71.95 v1(114.76,71.95)
  BOTTOM w0.127: JDIMM1.233 117.45,37.87 v1(117.98,37.35)
DDR_A_D57: length 52
  IN1 w0.084: v1(114.74,71.27) 114.74,71.12 114.29,70.68 114.29,68.58 112.28,66.56 112.28,49.16 112.61,48.83 112.61,48.71 112.4,48.5 112.4,48.39 112.51,48.27 112.63,48.27 112.84,48.48 112.96,48.48 113.08,48.36 113.08,48.24 112.87,48.03 112.87,47.91 112.99,47.79 113.11,47.79 113.32,48 113.44,48 113.55,47.88 113.55,47.77 113.34,47.56 113.34,47.44 113.46,47.32 113.58,47.32 113.79,47.53 113.91,47.53 114.03,47.41 114.03,47.29 113.82,47.08 113.82,46.96 113.94,46.84 114.06,46.84 114.27,47.05 114.38,47.05 114.5,46.94 114.5,46.82 114.29,46.61 114.29,46.49 114.41,46.37 114.53,46.37 114.74,46.58 114.86,46.58 114.99,46.45 114.99,46.33 114.78,46.12 114.78,46 114.9,45.88 115.02,45.88 115.23,46.09 115.35,46.09 115.47,45.97 115.47,45.85 115.26,45.65 115.26,45.53 115.37,45.41 115.49,45.41 115.7,45.62 115.82,45.62 115.94,45.5 115.94,45.38 115.73,45.17 115.73,45.05 115.85,44.93 115.97,44.93 116.18,45.14 116.3,45.14 120.48,40.96 120.48,40.59 120.39,40.51 119.89,40.51 119.74,40.36 119.74,36.96 118.61,35.82 v1(117.98,35.82)
  BOTTOM w0.089: UC1.L32 114.75,71.3 v1(114.74,71.27)
  BOTTOM w0.127: JDIMM1.237 118.45,37.83 118.71,37.57 118.71,36.18 118.35,35.82 v1(117.98,35.82)
DDR_A_D58: length 49.9
  IN1 w0.084: v1(120.96,34.49) 121.33,34.49 122.48,35.64 122.48,42.34 121.92,42.9 121.8,42.9 121.47,42.56 121.35,42.56 121.23,42.68 121.23,42.8 121.57,43.14 121.57,43.25 114.14,50.68 114.14,61.18 114.6,61.64 114.61,61.64 114.68,61.71 114.68,66.13 116.24,67.7 116.24,71.51 116.06,71.69 116.06,72.84 v1(115.68,73.22)
  BOTTOM w0.089: UC1.N29 v1(115.68,73.22)
  BOTTOM w0.127: JDIMM1.246 120.71,32.36 120.23,32.84 120.23,33.25 120.23,33.25 120.23,34.14 120.58,34.49 v1(120.96,34.49)
DDR_A_D59: length 49.4
  IN1 w0.084: v1(120.96,32.97) 121.86,33.86 121.86,34.61 123.25,36 123.25,41.97 114.43,50.8 114.43,60.7 114.86,61.13 114.86,66.07 116.42,67.63 116.42,71.55 116.22,71.76 116.22,73.31 v1(115.68,73.85)
  BOTTOM w0.089: UC1.N28 v1(115.68,73.85)
  BOTTOM w0.127: JDIMM1.250 121.71,32.22 v1(120.96,32.97)
DDR_A_D60: length 47.9
  IN1 w0.084: v1(117.98,32.77) 117.32,33.43 117.32,37.82 117.61,38.11 117.61,41.96 111.26,48.31 111.26,62.36 111.72,62.81 111.72,67.68 113.64,69.6 113.64,70.71 114.02,71.08 114.02,71.57 114.23,71.79 114.23,73.31 v1(114.77,73.85)
  BOTTOM w0.089: UC1.L28 v1(114.77,73.85)
  BOTTOM w0.127: v1(117.98,32.77) 118.2,32.55 JDIMM1.236
DDR_A_D61: length 48.8
  IN1 w0.084: v1(114.77,73.22) 114.39,72.84 114.39,71.72 114.21,71.53 114.21,71.04 113.82,70.66 113.82,69.53 111.89,67.61 111.89,62.56 111.66,62.32 111.66,48.31 118.01,41.96 118.01,40.25 118.1,40.16 118.25,40.16 118.34,40.08 118.34,39.91 118.25,39.83 118.1,39.83 118.01,39.74 118.01,39.58 118.1,39.49 118.25,39.49 118.34,39.41 118.34,39.24 118.25,39.16 118.1,39.16 118.01,39.07 118.01,38.01 117.61,37.6 117.61,34.38 117.69,34.3 v1(117.98,34.3)
  BOTTOM w0.089: UC1.L29 v1(114.77,73.22)
  BOTTOM w0.127: v1(117.98,34.3) 117.51,34.3 116.93,33.72 116.93,32.26 117.2,31.98 JDIMM1.232
DDR_A_D62: length 50.4
  IN1 w0.084: v1(115.69,71.94) 115.69,71.72 116.07,71.34 116.07,67.76 114.51,66.2 114.51,61.96 113.86,61.31 113.86,50.56 118.73,45.69 118.73,45.57 118.63,45.47 118.63,45.35 118.75,45.23 118.87,45.23 118.96,45.33 119.08,45.33 119.2,45.21 119.2,45.09 118.87,44.76 118.87,44.64 118.98,44.52 119.1,44.52 119.44,44.86 119.56,44.86 119.68,44.74 119.68,44.62 119.34,44.28 119.34,44.16 119.46,44.05 119.58,44.05 119.91,44.38 120.03,44.38 120.15,44.26 120.15,44.14 119.81,43.81 119.81,43.69 119.93,43.57 120.05,43.57 120.39,43.91 120.51,43.91 120.63,43.79 120.63,43.67 120.29,43.33 120.29,43.22 120.41,43.1 120.53,43.1 120.86,43.43 120.98,43.43 121.1,43.31 121.1,43.2 120.76,42.86 120.76,42.74 122.19,41.31 122.19,37.24 v1(120.96,36.01)
  BOTTOM w0.089: UC1.N31 115.69,71.96 v1(115.69,71.94)
  BOTTOM w0.127: v1(120.96,36.01) 121.28,36.01 121.72,36.46 121.72,37.1 121.46,37.36 JDIMM1.249
DDR_A_D63: length 51.4
  IN1 w0.084: v1(115.69,71.19) 115.69,67.63 114.33,66.27 114.33,62.22 113.57,61.46 113.57,50.44 113.98,50.03 113.98,49.91 113.64,49.58 113.64,49.46 113.76,49.34 113.88,49.34 114.21,49.68 114.33,49.68 114.45,49.56 114.45,49.44 114.12,49.1 114.12,48.98 114.23,48.86 114.35,48.86 114.69,49.2 114.81,49.2 114.93,49.08 114.93,48.96 114.59,48.63 114.59,48.51 114.71,48.39 114.83,48.39 115.16,48.73 115.28,48.73 115.4,48.61 115.4,48.49 115.06,48.15 115.06,48.03 115.18,47.92 115.3,47.92 115.64,48.25 115.76,48.25 115.88,48.13 115.88,48.01 115.54,47.68 115.54,47.56 115.66,47.44 115.78,47.44 116.11,47.78 116.23,47.78 116.35,47.66 116.35,47.54 116.01,47.2 116.01,47.09 116.13,46.97 116.25,46.97 116.59,47.3 116.71,47.3 116.82,47.18 116.82,47.07 116.49,46.73 116.49,46.61 116.61,46.49 116.72,46.49 117.06,46.83 117.18,46.83 117.31,46.7 117.31,46.58 116.98,46.24 116.98,46.12 117.09,46 117.21,46 117.55,46.34 117.67,46.34 117.79,46.22 117.79,46.1 117.45,45.77 117.45,45.65 117.57,45.53 117.69,45.53 118.02,45.87 118.14,45.87 118.26,45.75 118.26,45.63 117.92,45.29 117.92,45.17 118.04,45.06 118.16,45.06 118.28,45.18 118.4,45.18 118.52,45.06 118.52,44.94 118.4,44.82 118.4,44.7 121.91,41.19 121.91,38.5 120.96,37.56 v1(120.96,37.54)
  BOTTOM w0.089: v1(115.69,71.19) 116.08,71.37 UC1.N32
  BOTTOM w0.127: JDIMM1.245 120.45,38.05 v1(120.96,37.54)
DDR_A_DQS0: length 80.8
  IN4 w0.094: v1(60.05,35.38) 59.87,35.55 59.49,35.55 59.2,35.84 59.2,38.69 64.25,43.74 65.35,43.74 74.48,52.87 74.86,52.87 85.41,63.42 92.71,63.42 94.72,65.43 94.72,71.23 97.68,74.19 100.82,74.19 101.36,73.65 102.2,73.65 102.5,73.94 102.5,74.49 v1(102.32,74.66)
  BOTTOM w0.076: UC1.D27 110.85,74.8 110.71,74.94 110.63,75.12 110.58,75.16 110.55,75.18 110.53,75.19 110.41,75.23 110.18,75.23 110.04,75.2 109.82,75.2 109.8,75.2 109.74,75.22 109.57,75.22 109.37,75.19 109.11,75.19 109.11,75.19 108.34,75.19 108.08,75.44 107.38,75.44 107.13,75.19 103.63,75.19 103.47,75.36 102.84,75.36 102.66,75.18 102.66,74.73 102.59,74.66 v1(102.32,74.66)
  BOTTOM w0.104: v1(60.05,35.38) 60.57,35.38 60.92,35.73 60.92,37.32 60.46,37.79 JDIMM1.13
DDR_A_DQS1: length 73.7
  IN4 w0.094: v1(65.45,34.55) 65.45,34.77 65.8,35.12 66.21,35.12 66.41,35.33 66.41,39.22 87.04,59.85 100.02,59.85 104.16,63.98 104.16,71.17 104.02,71.31 104.02,71.56 v1(104.19,71.74)
  BOTTOM w0.076: v1(104.19,71.74) 104.01,71.92 104.01,72.18 104.11,72.27 104.61,72.27 104.75,72.13 107.31,72.13 107.85,72.66 108.15,72.66 108.31,72.51 108.89,72.51 109.38,72.51 109.58,72.54 109.72,72.54 109.76,72.53 109.8,72.51 110.06,72.51 110.2,72.55 110.38,72.55 110.47,72.52 110.48,72.51 110.49,72.5 110.49,72.5 110.54,72.39 110.51,72.29 110.4,72.24 UC1.C31
  BOTTOM w0.104: v1(65.45,34.55) 65.45,34.67 65.3,34.82 65.13,34.82 65.01,34.7 65.01,33.53 65.56,32.98 65.56,32.05 65.7,31.9 JDIMM1.34
DDR_A_DQS2: length 56.6
  IN1 w0.094: v1(112.83,76.21) 113.1,76.49 113.1,76.65 112.99,76.76 111.43,76.76 111.03,76.36 111.03,75.85 109.49,74.31 109.49,71.41 108.33,70.25 108.11,70.25 106.43,68.57 106.43,66.41 105.23,65.22 105.23,45.14 107,43.37 107,40.33 107.2,40.13 108.85,40.13 109.05,39.92 109.05,39.44 108.85,39.24 108.21,39.24 108.11,39.14 108.11,35.02 108.24,34.89 108.62,34.89 108.79,35.06 v1(108.79,35.31)
  BOTTOM w0.089: v1(112.83,76.21) UC1.G24
  BOTTOM w0.104: v1(108.79,35.31) 108.79,35.08 109,34.87 109.2,34.87 109.42,34.65 109.42,33.03 108.9,32.52 108.9,32.2 109.21,31.89 JDIMM1.200
DDR_A_DQS3: length 64.3
  IN1 w0.094: v1(106.74,77.32) 106.96,77.55 106.96,77.7 106.87,77.8 102.03,77.8 101.66,77.42 101.28,77.42 96.26,72.4 96.26,57.77 101.48,52.55 101.48,39 103.15,37.33 103.15,35.39 103.3,35.24 103.71,35.24 104.06,35.59 v1(104.06,35.82)
  BOTTOM w0.076: v1(106.74,77.32) 106.9,77.32 106.97,77.24 106.97,76.94 107.14,76.77 108.23,76.77 108.31,76.85 108.39,76.93 108.41,76.93 109.38,76.92 109.57,76.9 109.71,76.9 109.9,76.92 110.04,76.92 110.2,76.88 110.4,76.88 110.57,76.94 110.64,76.96 110.68,77.02 110.71,77.18 110.85,77.32 UC1.D23
  BOTTOM w0.104: JDIMM1.179 103.96,38.42 103.65,38.12 103.65,37.44 103.59,37.38 103.59,35.5 103.69,35.4 103.88,35.4 104.06,35.58 v1(104.06,35.82)
DDR_A_DQS4: length 67.9
  IN4 w0.094: v1(110.02,63.76) 109.77,63.76 109.49,63.48 109.49,63.18 102.5,56.18 88.17,56.18 73.43,41.45 73.43,40.2 71.61,38.39 71.61,35.79 71.41,35.59 v1(70.81,35.59)
  BOTTOM w0.076: UC1.J34 114.01,70.07 114.15,69.93 114.3,69.9 114.37,69.86 114.39,69.79 114.44,69.62 114.44,69.42 114.41,69.26 114.41,69.12 114.43,68.93 114.43,68.79 114.41,68.6 114.4,68.51 114.4,67.61 114.55,67.46 114.55,66.97 114.16,66.59 112.13,66.59 110.9,65.35 110.9,64.17 110.72,63.99 110.26,63.99 v1(110.02,63.76)
  BOTTOM w0.104: JDIMM1.55 70.96,38.5 70.81,38.35 70.81,38.12 71.53,37.4 71.53,36.11 71.29,35.88 70.92,35.88 70.81,35.78 v1(70.81,35.59)
DDR_A_DQS5: length 66.8
  IN4 w0.094: v1(76.45,35.12) 76.45,34.93 76.66,34.72 76.95,34.72 77.05,34.81 77.05,38.44 79.11,40.5 79.11,41.67 90.11,52.67 103.9,52.67 113.19,61.96 113.19,63.26 113.42,63.5 113.72,63.5 v1(113.94,63.72)
  BOTTOM w0.076: UC1.P35 116.49,69.62 116.53,69.72 116.65,69.76 116.75,69.74 116.79,69.59 116.79,69.43 116.76,69.28 116.76,69.11 116.78,68.92 116.78,68.8 116.76,68.61 116.75,68.41 116.75,67.54 116.91,67.38 116.91,67.23 116.91,67.07 114.74,64.9 114.51,64.68 114.51,63.55 114.45,63.49 114.18,63.49 v1(113.94,63.72)
  BOTTOM w0.104: JDIMM1.76 76.21,31.82 76.04,31.98 76.04,32.2 77.15,33.31 77.15,34.58 76.9,34.83 76.75,34.83 v1(76.45,35.12)
DDR_A_DQS6: length 49.1
  IN1 w0.094: v1(112.95,72.58) 112.67,72.58 112.58,72.49 112.58,70.16 109.31,66.89 109.31,62.97 109.17,62.83 109.17,46.91 114.51,41.57 114.51,38.44 114.31,38.23 113.82,38.23 113.73,38.14 113.73,37.86 113.82,37.76 114.31,37.76 114.51,37.56 114.51,37.22 114.31,37.02 113.8,37.02 113.7,36.92 113.7,35.59 113.81,35.48 114.24,35.48 114.4,35.64 v1(114.4,35.89)
  BOTTOM w0.089: UC1.H30 v1(112.95,72.58)
  BOTTOM w0.104: JDIMM1.221 114.45,38.41 114.15,38.1 114.15,37.11 113.95,36.91 113.95,35.91 113.86,35.82 113.86,35.59 113.96,35.48 114.2,35.48 114.4,35.68 v1(114.4,35.89)
DDR_A_DQS7: length 49.8
  IN1 w0.094: v1(119.51,34.68) 119.73,34.89 120.22,34.89 120.42,35.1 120.42,38.07 120.52,38.17 120.87,38.17 121.16,38.45 121.16,38.8 120.96,39 120.55,39 120.46,39.09 120.46,39.37 120.55,39.47 120.96,39.47 121.16,39.67 121.16,41.24 113.07,49.32 113.07,61.66 113.44,62.03 113.44,65.83 114.78,67.18 114.78,70.36 115.31,70.89 115.31,72.21 v1(115.68,72.58)
  BOTTOM w0.089: UC1.N30 v1(115.68,72.58)
  BOTTOM w0.104: v1(119.51,34.68) 119.51,34.8 119.35,34.97 119.23,34.97 119.13,34.87 119.13,33.39 119.44,33.08 119.44,32.14 119.71,31.88 JDIMM1.242
DDR_A_DQS#0: length 80.8
  IN4 w0.094: v1(103.17,74.64) 102.85,74.64 102.68,74.47 102.68,73.87 102.27,73.46 101.29,73.46 100.74,74.01 97.76,74.01 94.91,71.16 94.91,65.36 92.78,63.24 85.49,63.24 74.94,52.69 74.56,52.69 65.43,43.55 64.32,43.55 59.39,38.62 59.39,35.92 59.57,35.74 59.93,35.74 60.05,35.85 v1(60.05,36.14)
  BOTTOM w0.076: UC1.C27 110.4,74.76 110.51,74.81 110.54,74.91 110.49,75.02 110.49,75.02 110.48,75.03 110.47,75.03 110.38,75.07 110.2,75.07 110.06,75.03 109.8,75.03 109.76,75.04 109.72,75.05 109.58,75.05 109.38,75.03 109.23,75.03 109.19,75.02 108.27,75.02 108.02,75.27 107.45,75.27 107.2,75.03 103.56,75.03 103.4,75.19 102.91,75.19 102.83,75.11 102.83,74.73 102.91,74.66 103.17,74.66 v1(103.17,74.64)
  BOTTOM w0.104: JDIMM1.11 59.96,38.35 60.26,38.04 60.26,37.71 60.73,37.24 60.73,35.81 60.52,35.6 60.37,35.6 60.05,35.92 v1(60.05,36.14)
DDR_A_DQS#1: length 73.8
  IN4 w0.094: v1(103.64,71.66) 103.84,71.46 103.84,71.23 103.98,71.09 103.98,64.06 99.95,60.03 86.96,60.03 66.22,39.29 66.22,35.4 66.13,35.31 v1(65.45,35.31)
  BOTTOM w0.076: v1(103.64,71.66) 103.85,71.87 103.85,72.24 104.04,72.43 104.67,72.43 104.82,72.29 107.24,72.29 107.78,72.83 108.22,72.83 108.37,72.67 108.89,72.67 109.37,72.68 109.57,72.7 109.74,72.7 109.8,72.68 109.82,72.68 110.04,72.68 110.18,72.71 110.41,72.71 110.53,72.67 110.55,72.66 110.58,72.65 110.63,72.61 110.71,72.42 110.85,72.28 UC1.D31
  BOTTOM w0.104: v1(65.45,35.31) 65.45,35.24 65.24,35.03 65.08,35.03 64.82,34.78 64.82,33.45 65.37,32.9 65.37,32.11 65.21,31.95 JDIMM1.32
DDR_A_DQS#2: length 56.5
  IN1 w0.094: v1(113.46,76.21) 113.29,76.38 113.29,76.7 113.05,76.94 111.36,76.94 110.85,76.44 110.85,75.93 109.31,74.39 109.31,71.49 108.26,70.43 108.04,70.43 106.25,68.65 106.25,66.49 105.05,65.29 105.05,45.06 106.82,43.3 106.82,40.25 107.12,39.94 108.77,39.94 108.86,39.85 108.86,39.51 108.77,39.42 108.13,39.42 107.93,39.22 107.93,34.94 108.17,34.71 108.63,34.71 v1(108.79,34.55)
  BOTTOM w0.089: v1(113.46,76.21) UC1.H24
  BOTTOM w0.104: v1(108.79,34.55) 108.91,34.67 109.12,34.67 109.22,34.57 109.22,33.11 108.71,32.6 JDIMM1.198
DDR_A_DQS#3: length 64.3
  IN1 w0.094: v1(107.37,77.32) 107.15,77.55 107.15,77.78 106.94,77.98 101.96,77.98 101.58,77.61 101.21,77.61 96.08,72.47 96.08,57.69 101.29,52.47 101.29,38.93 102.97,37.26 102.97,35.31 103.22,35.06 v1(104.06,35.06)
  BOTTOM w0.076: UC1.C23 110.4,77.36 110.5,77.31 110.54,77.19 110.52,77.09 110.37,77.05 110.21,77.05 110.06,77.08 109.89,77.08 109.7,77.06 109.58,77.06 109.39,77.08 108.41,77.1 108.32,77.1 108.19,76.97 108.16,76.94 107.21,76.94 107.14,77.01 107.14,77.24 107.21,77.32 v1(107.37,77.32)
  BOTTOM w0.104: JDIMM1.177 103.45,38.4 103.46,38.4 103.46,37.52 103.4,37.46 103.4,35.42 103.61,35.21 103.91,35.21 v1(104.06,35.06)
