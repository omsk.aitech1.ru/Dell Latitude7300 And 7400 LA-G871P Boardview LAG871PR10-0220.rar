# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 71.7
  TOP w0.127: v1(296.3,43.36) v3(297.06,42.6) ; v3(292.17,35.78) v1(292.17,34.79)
  TOP w0.203: UA1.22 282.72,36.81 283.22,36.32 v1(283.22,36.19) ; UA1.37 283.52,43.82 283.71,44.01 v1(284.05,44.01)
  TOP w0.356: v1(283.05,46.08) 283.08,46.06 CA8.2
  TOP w0.381: v1(275.66,44.04) 275.46,44.24 CA41.2 ; CA57.2 283.19,36.16 v1(283.22,36.19)
  TOP w0.508: v1(284.93,48.25) 284.36,48.83 CA9.2 ; CA3.1 v1(298.27,39.05) ; v1(293.5,42.03) v3(292.96,41.49) 292.23,40.76 CA25.2 ; CA2.1 298.27,35.55 v1(297.63,34.92) ; CA74.2 v1(287.14,38.74) ; CA4.2 300.41,44.62 v1(300.3,44.51) ; RA37.1 v1(295.92,33.97) ; RA35.1 v1(296.3,43.36) ; v1(283.53,48.95) 283.34,49.14 RA36.1 ; CA73.2 v1(288.28,35.8) ; CA58.2 v1(289.12,33.52) ; RA44.2 286.8,48.8 v1(287.38,48.8) ; CA1.1 v1(308.82,45.65) ; v1(284.19,46.32) 283.98,46.11 CA35.2 ; CA51.2 v1(285.63,48.25) ; CA52.2 v1(289.76,34.73)
  GND1 w0.203: 303.46,33.45 JHP1.5 ; JHP1.5 303.46,32.8 ; JHP1.5 305.56,32.8 ; JHP1.5 304.51,32.8 ; JHP1.5 305.56,33.45 ; JHP1.7 308.21,43.6 ; JHP1.7 307.16,43.6 ; JHP1.7 306.11,43.6 ; JHP1.7 306.11,42.95 ; JHP1.7 308.21,42.95
  GND2 w0.203: 306.11,42.95 JHP1.7 ; JHP1.7 306.11,43.6 ; JHP1.7 307.16,43.6 ; JHP1.7 308.21,42.95 ; JHP1.7 308.21,43.6 ; 303.46,33.45 JHP1.5 ; JHP1.5 305.56,33.45 ; JHP1.5 303.46,32.8 ; JHP1.5 304.51,32.8 ; JHP1.5 305.56,32.8
  VCC w0.254: JHP1.7 307.16,43.6 ; JHP1.7 306.11,43.6 ; JHP1.7 306.11,42.95 ; JHP1.7 308.21,42.95 ; JHP1.7 308.21,43.6 ; 303.46,33.45 JHP1.5 ; JHP1.5 305.56,32.8 ; JHP1.5 304.51,32.8 ; JHP1.5 305.56,33.45 ; JHP1.5 303.46,32.8
  GND3 w0.203: JHP1.5 305.56,32.8 ; JHP1.5 303.46,33.45 ; JHP1.5 303.46,32.8 ; JHP1.5 305.56,33.45 ; JHP1.5 304.51,32.8 ; JHP1.7 307.16,43.6 ; JHP1.7 306.11,43.6 ; JHP1.7 308.21,43.6 ; JHP1.7 306.11,42.95 ; JHP1.7 308.21,42.95
  BOTTOM w0.381: v1(275.66,44.04) 276.59,44.04 278.77,46.22 282.91,46.22 v1(283.05,46.08)
  BOTTOM w0.508: v1(300.3,44.51) 299.18,45.63 DA2.3
  vias: v1(291.47,34.79)
VBAT1_CHG: length 7.9
  TOP w0.127: PR738.1 51.63,46.87 v2(52.05,46.45)
  TOP w0.203: PU700.31 47.93,51.23 48.44,50.72 49.17,50.72 50.38,49.51 50.38,48.36 51.05,47.68 PC755.1
  TOP w0.254: PC755.1 51.09,46.9 PR738.1
VBUS1_ECOK: length 4.1
  TOP w0.127: v2(285.11,77.24) 284.77,77.58 RE602.2
  TOP w0.254: UE1.N3 282.27,79.36 283.53,78.1 RE602.2
VBUS1_ECOK_R: length 349.2
  TOP w0.127: RE602.1 286.15,78.1 v1(286.23,78.02)
  TOP w0.254: PR826.1 v1(33.47,106.61) ; PR24.1 PR20.2 v2(80.44,99.49) 80.44,101.49 80.14,101.78 v1(80.08,101.78) ; v1(38.99,98.52) 38.71,98.24 PR861.2
  IN1 w0.084: v1(268.08,72.18) 269.89,72.18 270.51,71.56 271.46,71.56 272.02,72.12 277.36,72.12 277.69,72.44 280.11,72.44 280.43,72.76 285.82,72.76 286.03,72.97 288.08,72.97 288.7,73.59 288.93,73.59 289.15,73.81 289.15,75.13 288.26,76.02 288.26,76.92 287.17,78.02 v1(286.23,78.02)
  IN2 w0.254: v1(33.47,106.61) 33.47,103.32 35.51,101.28 38.55,101.28 38.99,100.83 v1(38.99,98.52)
  IN3 w0.122: v1(38.99,98.52) 39.73,97.78 41.36,97.78 41.79,98.22 44.59,98.22 44.74,98.37 46.54,98.37 46.78,98.61 46.78,100.64 47.3,101.16 50.43,101.16 51.02,101.75 66.99,101.75 67.54,102.29 79.57,102.29 v1(80.08,101.78) 81.69,100.17 84.08,100.17 84.59,100.68 90.71,100.68 94.12,104.09 103.74,104.09 104.08,103.75 113.46,103.75 113.85,104.14 115.07,104.14 115.45,104.53 121.54,104.53 122.2,105.19 135.09,105.19 135.69,105.79 140.43,105.79 141.49,106.85 146.9,106.85 147.96,105.78 153.36,105.78 154.14,106.56 161.08,106.56 162.13,105.51 171.37,105.51 173.08,103.8 173.4,103.8 178.16,99.04 178.16,96.16 179.74,94.58 179.74,93.71 181.21,92.24 181.21,87.69 183.8,85.09 183.8,83.78 184.09,83.5 184.09,82.31 187.23,79.17 187.23,77.31 190.43,74.12 190.43,62.2 194.29,58.34 194.29,57.23 194.83,56.69 194.83,55.29 196.1,54.02 208.24,54.02 218.45,43.81 228.71,43.81 230.58,41.94 234.41,41.94 234.82,42.35 241.98,42.35 242.83,43.2 244.01,43.2 245.32,44.51 248.57,44.51 251.77,47.7 252.82,47.7 254.29,49.17 255.12,49.17 256.67,50.72 258.96,50.72 260.24,52 261.99,52 263.78,53.8 263.78,54.34 266.43,57 266.43,60.89 267.29,61.74 267.29,62.55 266.17,63.68 266.17,66.01 268.12,67.96 268.12,70.34 267.66,70.8 267.66,71.76 v1(268.08,72.18)
VBUS2_ECOK: length 15.6
  TOP w0.127: v1(281.77,81.4) 281.42,81.75 UE1.M6
  TOP w0.254: v1(288.23,86.1) 288.25,86.12 291.28,86.12 v2(292.01,86.85) 292.49,87.33 RE603.1
  IN4 w0.254: v1(281.77,81.4) 285.7,81.4 287.36,83.06 287.36,83.83 288.23,84.7 v1(288.23,86.1)
VBUS2_ECOK_R: length 385.6
  TOP w0.127: v1(292.47,89.58) 292.47,88.57 RE603.2 ; PR49.2 57.83,96.15 58.08,95.89 v1(58.08,95.71)
  TOP w0.254: PR827.1 34.77,99.74 v1(34.66,99.74) ; PR819.1 37.31,93.01 PR816.1 37.33,92.64 37.9,92.07 v2(38.17,92.07) 38.87,92.07 39.53,92.73 39.53,93.82 38.61,94.74 38.61,96.58 v1(38.87,96.83)
  IN1 w0.084: v1(292.47,89.58) 291.58,88.69 290.06,88.69 288.02,90.73 284.3,90.73 283.55,89.97 282.38,89.97 281.75,90.6 279.05,90.6 278.59,90.15 276.6,90.15 275.68,89.23 274.66,89.23 273.9,88.47 271.64,88.47 271.31,88.13 268.7,88.13 268.62,88.21 264.48,88.21 v1(263.83,87.56)
  IN2 w0.254: v1(34.66,99.74) 34.88,99.74 37.79,96.83 v1(38.87,96.83)
  IN3 w0.122: 47.06,98.15 47.86,98.15 49.02,97 52.08,97 53.35,98.27 53.77,98.27 54.03,98 54.03,97.36 56.18,95.22 57.86,95.22 58.08,95.45 v1(58.08,95.71) ; 47.06,98.15 44.83,98.15 44.68,97.99 41.91,97.99 41.42,97.5 39.54,97.5 v1(38.87,96.83) ; 47.06,98.15 47.06,100.61 47.39,100.93 51.47,100.93 52.48,99.92 56.8,99.92 57.66,99.06 65.18,99.06 65.68,98.55 70.46,98.55 71.11,99.2 74.6,99.2 74.66,99.14 79.36,99.14 80.64,97.86 87.64,97.86 88.44,98.66 91.21,98.66 95.8,103.25 103.33,103.25 103.9,102.68 114.11,102.68 114.37,102.42 120.8,102.42 121.75,103.37 130.23,103.37 130.8,103.94 137.62,103.94 138.09,104.42 140.37,104.42 140.91,104.96 142.18,104.96 142.66,105.44 145.36,105.44 146.07,104.72 151.44,104.72 152.1,105.39 153.89,105.39 154.84,106.34 160.99,106.34 162.04,105.28 171.28,105.28 172.99,103.58 173.31,103.58 177.94,98.95 177.94,95.81 178.88,94.87 178.88,94.17 180.98,92.07 180.98,87.42 183.58,84.82 183.58,83.69 183.87,83.4 183.87,82.22 187.01,79.08 187.01,77.22 190.21,74.02 190.21,59.6 196.01,53.8 208.15,53.8 218.36,43.59 228.62,43.59 230.49,41.72 234.5,41.72 234.92,42.13 242.07,42.13 242.92,42.98 244.11,42.98 245.41,44.29 248.67,44.29 251.86,47.48 252.91,47.48 254.38,48.95 255.22,48.95 256.76,50.49 259.05,50.49 260.33,51.78 262.08,51.78 264,53.7 264,54.25 266.66,56.91 266.66,60.79 267.51,61.65 267.51,62.64 266.39,63.77 266.39,65.91 268.34,67.86 268.34,69.94 268.49,70.1 268.49,71.44 269.27,72.22 269.27,73.5 268.34,74.44 265.82,74.44 264.77,75.48 264.77,83.39 264.34,83.82 264.34,85.68 264,86.01 264,87.39 v1(263.83,87.56)
VBUSSENSE: length 11.8
  TOP w0.127: v2(150.43,97.4) v1(150.43,96.87) 150.43,96.32 RC49.1
  IN2 w0.102: 147.95,88.04 v1(147.8,88.04)
  IN2 w0.15: v1(150.43,96.87) 150.43,93.62 150.27,93.46 150.27,91.79 148.19,89.71 148.19,88.28 147.95,88.04
  BOTTOM w0.089: v1(147.8,88.04) UC1.CC6
VCC1_IA: length 1.6
  TOP w0.127: v2(78.66,88.4) 78.14,87.88 PR688.2
  vias: v1(77.79,85.72) v1(78.64,85.78)
VCC_1.05VALWP: length 1.1
  TOP w0.127: PC313.1 193.01,111.54 v2(193.33,111.86)
VCC_CPU_CORE: length 5.7
  TOP w0.203: PR602.1 60.98,61.64 v2(61.87,60.75) 63.01,59.61 PU602.34
  TOP w0.254: PC603.1 59.47,61.64 PR602.1
VCC_DDR: length 2.1
  TOP w0.254: PU200.14 220,29.55 219.82,29.37 v2(219.71,29.37) 218.93,29.37 PC207.1
VCC_GT: length 2.4
  BOTTOM w0.127: PR680.2 71.24,67.7 70.14,66.59 v2(69.48,66.59)
VCC_SENSE_GT: length 73
  TOP w0.254: PC653.1 PC651.2 PC639.1 76.46,60.78 v1(76.71,60.53) 76.96,60.28 v2(76.96,59.63) 76.96,58.95 76.5,58.49 74.71,58.49 PR648.1
  IN1 w0.254: v1(76.71,60.53) 76.83,60.53 80.34,64.04 82.61,64.04 85.86,67.28 85.86,69.53 85.54,69.84 85.54,74.86 85.29,75.11 85.29,83.33 85.74,83.79 91,83.79 91.5,84.28 91.5,86.85 92.07,87.42 92.07,88.27 92.98,89.17 95.61,89.17 97.94,86.84 100.92,86.84 103.04,88.96 103.04,92.63 105.44,95.03 108.38,95.03 v1(109.04,95.69)
  BOTTOM w0.254: RC632.2 108.85,95.5 v1(109.04,95.69) 109.1,95.75 109.1,96.52 RC160.2
VCC_SENSE_IA: length 126.1
  TOP w0.127: v2(68.9,49.77) 67.89,50.78 PC618.2
  TOP w0.203: PC618.2 67.82,51.75 PC617.1 67.72,51.85 PR622.1 66.87,53.54 PC620.1 66.87,54.25 v1(66.62,54.5)
  IN2 w0.203: v1(126.46,99.73) 126.17,99.43 125.81,99.43 125.3,98.93 125.3,91.7 124.83,91.23 112.34,91.23 111.07,92.5 106.75,92.5 106.3,92.95 103.89,92.95 102.7,91.75 102.7,89.15 100.72,87.17 98.11,87.17 95.07,90.21 90.93,90.21 90.01,91.13 86.8,91.13 82.75,95.18 70.3,95.18 69.25,94.13 69.25,71.72 67.44,69.91 67.44,63.73 65.79,62.08 64.22,62.08 63.37,61.24 63.37,56.66 65.21,54.82 66.3,54.82 v1(66.62,54.5)
  BOTTOM w0.127: RC150.2 126.2,99.73 v1(126.46,99.73) 127,99.73 127.31,99.41 RC430.2
VCC_SENSE_SA: length 116
  TOP w0.127: RC426.2 134.94,97.96 RC166.2 135.73,98.29 v1(135.86,98.16)
  TOP w0.203: v1(69.72,68.69) 69.58,68.83 66.5,68.83 65.66,67.98 PC652.1 65.67,67.5 PC650.2 65.68,66.63 66.52,66.63 PR649.2 66.59,66.7 PC640.2
  IN2 w0.203: v1(135.86,98.16) 134.75,98.16 134.5,97.91 134.5,91.5 133.61,90.61 112.56,90.61 111.93,89.97 110.78,89.97 109.7,91.05 108.76,91.05 108.09,90.38 105.96,90.38 v1(104.84,91.5)
  IN4 w0.203: v1(104.84,91.5) 103.83,90.48 103.83,89.85 100.84,86.86 97.99,86.86 94.94,89.91 90.81,89.91 89.91,90.81 86.61,90.81 82.92,94.5 70.38,94.5 69.45,93.57 69.45,71.79 70.87,70.36 70.87,69.35 70.36,68.84 69.87,68.84 v1(69.72,68.69)
VCCDSW_EN: length 155.5
  TOP w0.127: RC445.1 174.26,57.54 v1(174.26,58.34) 174.69,58.34 v2(174.86,58.17) ; CE66.1 286.03,82.29 284.88,82.29 284.61,82.56 283.04,82.56 v1(282.66,82.18) 281.79,82.18 UE1.M7
  IN3 w0.122: v1(174.26,58.34) 174.86,57.74 182.04,57.74 190.19,49.6 196.55,49.6 197.22,50.27 200.13,50.27 200.7,49.7 207.19,49.7 216.86,40.02 225.35,40.02 227.17,38.2 237.5,38.2 237.65,38.35 243.22,38.35 243.6,38.74 246.45,38.74 246.9,39.19 250.12,39.19 253.66,42.73 255.99,42.73 256.82,43.56 258.38,43.56 261.18,46.35 266.02,46.35 268.04,48.38 268.04,49.76 270.28,52 270.45,52 270.71,52.25 270.71,52.83 272.06,54.18 272.06,56.51 273.28,57.74 273.28,58.68 273.48,58.88 273.69,58.88 274.01,59.2 274.01,59.34 274.01,60.17 274.76,60.92 274.76,61.4 275.38,62.02 275.38,64.37 276.52,65.5 276.52,69.69 276.33,69.87 276.33,70.59 277.5,71.76 277.76,71.76 278.23,72.23 278.23,72.24 278.27,72.27 278.27,73.31 278.84,73.89 278.84,74.21 278.83,74.21 278.83,74.8 279.56,75.53 280.68,75.53 281,75.85 281,76.44 280.58,76.86 280.58,77.43 281.49,78.34 281.49,80.25 282.66,81.41 v1(282.66,82.18)
VCCDSW_EN_GPIO: length 8.5
  TOP w0.254: RC431.1 175.9,63.4 175.9,62.8 175.62,62.51 QC6.2 v2(175.62,59.24) 175.62,57.78 RC445.2 175.11,56.33 DC1.2
VCCDSW_EN_Q: length 3.7
  TOP w0.127: v2(172.05,57.56) RC442.1 173.26,56.48 DC1.1 DC2.2
VCCEOPIO_SENSE: length 1.7
  TOP w0.127: v1(118.87,76.39) 119.57,75.69 T368.1
  BOTTOM w0.2: UC1.V25 v1(118.87,76.39)
VCCGT_SENSE_R: length 7.4
  TOP w0.127: v3(108.85,94.94) 109.28,94.94 v1(109.38,95.04)
  BOTTOM w0.076: 108.85,94.1 108.85,94.09 109.18,93.76 109.52,93.76 111.18,92.1 111.18,91.11 111.24,91.05 111.24,91.04 111.34,90.95 111.34,90.67 111.34,90.67 111.34,90.35 111.34,90.35 111.34,90.06 111.54,89.86 UC1.E3
  BOTTOM w0.127: v1(109.38,95.04) 109.38,94.77 109.05,94.44 RC632.1 108.85,94.1
VCCHDA: length 3.3
  TOP w0.127: v1(165.97,78.51) 165.55,78.92 v3(165.55,79.22)
  TOP w0.508: LC4.2 166.87,78.32 CC95.2 v1(165.97,78.51)
  BOTTOM w0.2: v1(142.37,78.65) 142.61,78.96 UC1.BT20
VCCIO_SENSE: length 125.7
  TOP w0.254: RC163.2 97.54,78.6 v1(98.05,79.11) ; v1(96.72,27.26) 96.27,26.82 96.27,26.33 93.73,23.78 v2(93.67,23.78) 93.67,23.72 93.41,23.46 83.74,23.46 PR422.2
  IN1 w0.076: 141.17,75.3 141.73,74.74 141.73,74.19 v1(142.11,73.81)
  IN1 w0.15: 141.17,75.3 141.04,75.43 116.02,75.43 115.51,75.94 115.51,78.65 114.94,79.23 107.46,79.23 106.43,80.26 98.75,80.26 98.27,79.78 98.27,79.33 v1(98.05,79.11)
  IN1 w0.254: v1(98.05,79.11) 98.05,79.01 92.97,73.93 92.97,69.31 89.72,66.06 89.72,62.36 92.46,59.62 92.46,45.52 93.54,44.44 93.54,37.92 93.1,37.48 93.1,34.9 94.37,33.63 94.37,30.77 95.01,30.12 95.01,27.79 95.55,27.26 v1(96.72,27.26)
  BOTTOM w0.102: UC1.BP28 v1(142.11,73.81)
VCCPLL_EN: length 4.2
  TOP w0.127: RZ1419.2 RZ120.2 RZ1418.2 148.05,46.33 v2(147.25,45.54) 147.02,45.54 146.55,46.01 UZ27.4
VCCSENSE_R: length 15.1
  TOP w0.127: v1(129.23,99.31) v2(128.5,99.31)
  IN1 w0.15: v1(129.23,99.31) 129.36,99.31 131.07,97.59 131.07,90.5 129.78,89.22 129.78,88.5 v1(129.32,88.04)
  BOTTOM w0.127: v1(129.23,99.31) 128.33,99.31 RC430.1
  BOTTOM w0.2: v1(129.32,88.04) UC1.AN6
VCCST_EN: length 14.4
  TOP w0.127: UZ21.4 145.43,111.07 v1(144.68,111.82) ; RZ1423.2 RZ1417.2 RZ1416.2 137.8,110.38 137.42,110.76 137.42,111.63 v1(137.29,111.75) v2(136.52,111.75)
  IN4 w0.084: v1(137.29,111.75) 138.3,110.75 144.55,110.75 144.68,110.89 v1(144.68,111.82)
VCCST_PWRGD: length 167.9
  TOP w0.127: RC123.1 63.41,98.71 64.33,99.63 v3(64.33,101.78) 64.33,105.32 v1(64.52,105.51)
  IN1 w0.084: v1(156.32,110.67) 158.89,110.67 164.41,105.15 169.68,105.15 172.41,102.42 172.41,98.08 174.49,96.01 178.38,96.01 179.64,94.74 179.64,92.2 181.08,90.77 181.08,89.32 184.78,85.61 184.78,84.78 v1(184.78,84.78)
  IN2 w0.122: v1(64.52,105.51) 65.71,105.51 66.75,106.56 82.25,106.56 83.28,107.59 87.79,107.59 88.33,108.13 89.54,108.13 91.01,109.6 102.49,109.6 104.44,107.65 112.56,107.65 114.5,105.7 118.77,105.7 120.44,104.03 134.16,104.03 v1(135.61,102.58)
  IN4 w0.084: v1(135.61,102.58) 137.51,104.48 137.51,104.65 142.49,109.63 152.61,109.63 153.9,110.92 156.07,110.92 v1(156.32,110.67)
  BOTTOM w0.127: v1(184.78,84.78) 183.53,84.78 182.21,86.1 181.27,86.1 180.47,85.3 180.47,83.86 180.8,83.53 181.92,83.53 182.09,83.36 UE4.4 ; v1(135.61,102.58) 135.61,101.58 135.07,101.03 135.07,99.82 135.4,99.49 RC71.1 135.76,99.48 CC301.1 136.7,99.5 138.49,99.5 RC78.1
VCCST_PWRGD_CPU: length 9.1
  IN4 w0.084: v1(137.89,93.11) 138.23,93.11 138.44,93.32 138.44,95.73 138.44,95.94 v1(138.94,96.45)
  BOTTOM w0.076: UC1.BJ2 138.06,90.75 138.06,90.98 138.05,91 138.05,91.33 138.06,91.34 138.06,92.95 v1(137.89,93.11)
  BOTTOM w0.127: v1(138.94,96.45) 138.94,97.78 138.5,98.23 RC78.2
VCCSTG_EN: length 124.8
  TOP w0.127: v1(150.27,47.59) 149.92,47.24 v2(149.59,47.24) RZ120.1 ; v1(141.05,112.01) 141.05,112 140.98,111.93 UZ19.4 ; v1(150.05,110.99) 149.68,110.61 149.68,108.83 149.85,108.66 RZ320.2 150.31,108.66 150.56,108.4 150.88,108.4 151.21,108.07 UZ35.4
  IN2 w0.122: v1(150.05,110.99) 149.48,110.42 146.69,110.42 145.94,111.17 141.94,111.17 141.5,111.61 141.44,111.61 141.05,112 v1(141.05,112.01)
  IN3 w0.122: v1(150.27,47.59) 150.27,48.93 149.89,49.31 145.69,49.31 142.66,52.34 142.66,53.56 139.1,57.11 139.1,58.49 140.47,59.85 140.47,61.83 v1(140.01,62.29) ; v1(144.14,62.7) 144.54,62.7 145.05,62.19 145.05,62.03 145.12,61.95 145.54,61.54 146.57,61.54 147.1,62.07 147.1,64.27 148.14,65.31 148.14,67.24 148.68,67.78 148.68,68.93 149.65,69.89 151.58,69.89 153.46,71.77 153.46,76.28 153.91,76.73 155.42,76.73 155.58,76.89 156.7,76.89 157.08,77.27 157.08,79.19 162.43,84.54 162.43,86.03 162.69,86.29 164.48,86.29 164.82,85.95 165.28,85.95 166.31,86.99 167.83,86.99 168.47,87.62 168.47,92.77 168.28,92.96 168.28,94.04 168.2,94.12 168.2,95.36 166.59,96.97 156.87,96.97 v1(155.55,98.29)
  BOTTOM w0.076: v1(144.14,62.7) 142.31,62.7 141.9,62.29 v1(140.01,62.29)
  BOTTOM w0.127: v1(150.05,110.99) 150.12,110.99 151.61,109.5 151.61,103.09 154.06,100.64 154.06,100.2 155.55,98.7 v1(155.55,98.29)
VDD_CHG: length 22.5
  TOP w0.127: v2(54.78,56.15) 54.3,56.64 53.52,56.64 PR707.2
  TOP w0.203: PU700.18 43.88,54.85 PC739.2 42.86,55.29 v1(42.81,55.24)
  TOP w0.254: v1(45.81,59.67) 45.83,59.68 46.48,59.68 47.05,60.26 49.6,60.26 50.64,61.3 53.24,61.3 53.71,60.83 53.71,58.78 PR710.2 53.57,57.81 PR712.1 53.48,57.72 PR707.2
  IN3 w0.254: v1(42.81,55.24) 42.81,56.44 45.81,59.45 v1(45.81,59.67)
VDDP_CHG:
  vias: v2(50.51,56.69)
VIN_1.8VALW: length 0.6
  TOP w0.127: v1(182.23,104.95) v3(182.87,104.95)
VIN_1V_PRIM_CORE: length 1.5
  TOP w0.127: 176.32,28.52 v3(176.32,29.99)
VIN_1VS_VCCIO: length 1.4
  TOP w0.127: PL405.2 91.32,26.32 v2(91.8,25.84)
VIN_2.5V_MEM: length 1.4
  TOP w0.127: PU503.8 v2(125.34,26.55)
VIN_CPU_CORE: length 8
  TOP w0.203: PR603.1 58.45,63.73 PC604.1 61.14,63.1 61.56,62.68 v2(61.56,62.07) 61.56,61.59 63.14,60.01 PU602.33
VSS_SENSE_GT: length 74.1
  TOP w0.203: PC653.2 73.19,61.7 v2(72.1,61.7) 71.84,61.7 70.62,60.48 69.95,60.48 69.48,60.01 PU602.18
  TOP w0.254: v1(75.89,63.11) 73.81,63.11 PC654.2 73.27,61.7 PC653.2
  IN1 w0.254: v1(108.53,96.03) 108.53,95.78 108.13,95.38 105.29,95.38 102.69,92.78 102.69,89.11 100.78,87.2 98.08,87.2 95.75,89.53 92.83,89.53 91.7,88.4 91.7,87.56 91.14,87 91.14,84.43 90.85,84.14 85.6,84.14 84.91,83.45 84.91,74.92 85.16,74.67 85.16,69.69 85.48,69.37 85.48,67.41 82.47,64.4 80.09,64.4 78.26,62.57 77.81,62.57 77.26,63.11 v1(75.89,63.11)
  BOTTOM w0.254: RC631.2 108.21,95.34 108.53,95.66 v1(108.53,96.03) 108.53,96.11 108.08,96.55 RC161.1
VSS_SENSE_IA: length 124.9
  TOP w0.203: PU602.6 66.52,55.21 v2(67.11,54.62) v1(67.51,54.22) 67.78,53.95 PC620.2 68.66,53.59 PC619.2
  IN2 w0.203: v1(67.51,54.22) 66.61,55.12 65.34,55.12 63.68,56.78 63.68,61.11 64.34,61.78 65.92,61.78 67.76,63.62 67.76,69.78 69.55,71.57 69.55,94 70.43,94.88 82.61,94.88 86.66,90.82 89.88,90.82 90.8,89.91 94.94,89.91 97.99,86.86 100.84,86.86 103,89.02 103,91.62 104.02,92.64 106.18,92.64 106.62,92.2 110.94,92.2 112.21,90.93 125.04,90.93 125.61,91.5 125.61,98.8 125.93,99.12 126.3,99.12 v1(126.45,98.97)
  BOTTOM w0.127: RC429.2 127.31,98.59 126.93,98.97 v1(126.45,98.97) 126.26,98.97 RC151.1
VSS_SENSE_SA: length 122.5
  TOP w0.127: RC164.1 134.94,96.18 RC425.2 135.01,96.77 v1(135.81,97.58)
  TOP w0.203: PC650.1 66.1,65.29 66.1,62.6 66.12,62.59 PU602.26 ; v1(69.72,69.32) 69.54,69.15 66.26,69.15 v2(66.19,69.22) 66.02,69.06 65.39,69.06 64.14,67.81 64.14,66.35 PC649.1
  TOP w0.254: PC650.1 PC649.1
  IN2 w0.203: v1(135.81,97.58) 135.8,97.59 135.01,97.59 134.81,97.39 134.81,91.3 133.74,90.23 112.72,90.23 112.08,89.59 110.62,89.59 110.14,90.08 105.31,90.08 104.21,91.18 v1(104.21,91.56)
  IN4 w0.203: v1(69.72,69.32) 69.89,69.15 70.24,69.15 70.57,69.48 70.57,70.24 69.14,71.66 69.14,93.8 70.15,94.81 83.04,94.81 86.73,91.12 90.04,91.12 90.94,90.21 95.07,90.21 98.11,87.17 100.72,87.17 103.52,89.97 103.52,90.68 104.21,91.37 v1(104.21,91.56)
VSSEOPIO_SENSE: length 1.2
  TOP w0.127: T369.1 117.9,76.45 v1(117.96,76.39)
  BOTTOM w0.2: UC1.T25 v1(117.96,76.39)
VSSGT_SENSE_R: length 8.7
  TOP w0.127: v1(109.44,93.29) 109.2,93.05 v3(109.2,92.72)
  BOTTOM w0.076: UC1.D2 111.05,90.57 110.59,91.03 110.59,91.3 110.43,91.46 110.43,92.3 v1(109.44,93.29)
  BOTTOM w0.127: RC631.1 108.21,92.21 108.36,92.06 108.73,92.06 108.87,92.2 108.87,93.12 109.04,93.29 v1(109.44,93.29)
VSSIO_SENSE: length 126.9
  TOP w0.254: RC165.1 97.61,77.84 98.75,78.99 v1(98.75,79.18) ; PR412.2 85.17,24.27 85.48,23.97 93.19,23.97 v2(94.58,25.36) 95.75,26.52 95.75,27.63 95.97,27.85 v1(96.72,27.85)
  IN1 w0.076: v1(142.11,73.22) 141.77,72.88 141.62,72.88 141.57,72.93 141.57,74.67 141.14,75.1 141.08,75.1 141.06,75.12 140.98,75.12
  IN1 w0.15: 140.98,75.12 115.89,75.12 115.26,75.75 115.26,78.57 114.84,78.99 107.36,78.99 106.33,80.02 98.85,80.02 98.68,79.85 98.51,79.68 98.51,79.42 v1(98.75,79.18)
  IN1 w0.254: v1(96.72,27.85) 96.68,27.81 95.72,27.81 95.52,28.01 95.52,30.33 94.88,30.98 94.88,33.84 93.61,35.11 93.61,37.27 94.05,37.71 94.05,44.65 92.97,45.73 92.97,59.83 90.23,62.57 90.23,65.85 93.48,69.1 93.48,73.72 93.84,74.08 94.22,74.08 94.54,74.4 94.54,74.78 94.86,75.1 95.24,75.1 95.56,75.42 95.56,75.8 95.89,76.13 96.26,76.13 96.59,76.45 96.59,76.83 96.91,77.15 97.29,77.15 97.61,77.47 97.61,77.85 98.75,78.99 v1(98.75,79.18)
  BOTTOM w0.076: v1(142.11,73.22) 142,73.11 141.75,73.11 141.66,73.2 UC1.BP29
VSSSENSE_R: length 19.1
  TOP w0.127: v1(129.23,98.67) v2(129.83,98.67)
  IN1 w0.15: v1(129.32,88.67) 129.32,89.11 130.82,90.61 130.82,94.8 130.59,95.03 129.75,95.03 129.63,95.14 129.63,95.6 129.76,95.73 130.23,95.73 130.41,95.91 130.41,96.42 130.23,96.6 128.76,96.6 128.62,96.74 128.62,97.06 128.76,97.2 129.98,97.2 130.12,97.34 130.12,97.66 129.97,97.81 128.81,97.81 128.62,98 128.62,98.51 128.78,98.67 v1(129.23,98.67)
  BOTTOM w0.127: v1(129.23,98.67) 128.31,98.67 RC429.1
  BOTTOM w0.2: v1(129.32,88.67) UC1.AN5
2.7MM_CAM_DET#: length 186
  TOP w0.127: v3(96.26,105.66) 95.83,106.09 v1(95.83,106.57) 95.83,108.13 95.56,108.4 RV734.1
  IN2 w0.122: v1(158.97,108.05) 161.29,108.05 162.32,109.08 163.97,109.08 168.71,104.34 168.71,102.07 168.54,101.9 v1(168.54,101.9)
  IN3 w0.122: v1(168.54,101.9) 168.54,101.9 168.79,101.65 168.79,100.12 169.2,99.71 169.2,98.51 168.5,97.81 168.5,96.7 169.29,95.91 169.29,92.56 170.28,91.57 170.28,89.5 170.7,89.07 170.7,86.99 169.09,85.38 166.38,85.38 165.59,84.59 163.76,84.59 158.31,79.13 158.31,76.49 157.88,76.07 155.77,76.07 154.75,75.04 154.75,73.49 v1(154.66,73.41) ; v1(158.97,108.05) 158.71,108.31 153.02,108.31 152.91,108.2 148.66,108.2 148.37,108.5 146.14,108.5 145.32,109.32 139.72,109.32 138.53,108.13 130.28,108.13 129.17,109.24 128.2,109.24 128.07,109.37 125.8,109.37 125.62,109.19 114.16,109.19 111.39,106.42 101.16,106.42 100.53,107.05 96.31,107.05 v1(95.83,106.57) 95.57,106.57 95.18,106.96 92.22,106.96 91.93,107.26 86.38,107.26 85.69,106.57 85.69,105.24 86.51,104.42 86.51,103.41 86.15,103.05 82.53,103.05 79.48,106.1 79.26,106.1 77.42,107.94 68.02,107.94 67.2,108.76 64.56,108.76 63.33,109.99 59.68,109.99 v1(59.25,110.42)
  IN4 w0.084: v1(154.66,73.41) 154.95,73.69 154.95,74.66 154.58,75.02 148.6,75.02 148.31,75.3 148.22,75.3 147.94,75.58 146.26,75.58 145.99,75.3 145.61,75.3 145.29,74.99 145.29,72.45 145.76,71.98 v1(145.76,71.95)
  BOTTOM w0.089: v1(145.76,71.95) 145.3,72.18 UC1.BY31
  BOTTOM w0.127: JEDP1.5 59.03,110.9 59.25,110.68 v1(59.25,110.42)
3MM_CAM_DET#: length 119.5
  TOP w0.127: RV325.1 93.78,110.05 v3(93.73,110.11) 93.61,110.23 93.61,110.68 v1(93.92,111)
  IN2 w0.089: 153.89,92.41 153.89,88.17 155.6,86.46 157.3,86.46 158.43,85.33 v1(158.43,85.31)
  IN2 w0.122: 153.89,92.41 153.89,92.58 154.11,92.8 156.31,92.8 157.08,93.57 157.08,98.2 154.95,100.34 154.95,102.16 154.74,102.37 v1(154.49,102.37)
  IN3 w0.122: v1(93.92,111) 95.01,109.91 101.94,109.91 103.24,111.21 105.51,111.21 106.3,110.42 110.65,110.42 112.85,112.62 145.57,112.62 147.2,110.99 149.11,110.99 149.72,111.61 152.84,111.61 153.85,112.62 161.25,112.62 162.64,111.24 v1(162.64,109.75)
  BOTTOM w0.076: UC1.CR12 154.07,84.36 154.82,84.36 154.94,84.24 155.88,84.24 156.25,84.62
  BOTTOM w0.102: 156.25,84.62 156.32,84.69 157.81,84.69 v1(158.43,85.31)
  BOTTOM w0.127: JIRTS1.8 v1(93.92,111) ; v1(162.64,109.75) 162.25,109.36 158.97,109.36 154.11,104.5 154.11,102.75 v1(154.49,102.37)
32KHZ_OUT: length 4.8
  TOP w0.127: v1(275.79,76.55) 275.8,76.55 275.8,76.28 275.01,75.5 CE54.1 ; UE1.F3 276.6,79.36 276.24,79 v1(276.24,78.95)
  BOTTOM w0.127: v1(275.79,76.55) 276.19,76.95 276.19,78.9 v1(276.24,78.95)
+BL_PWR_SRC: length 14.1
  IN3 w1.016: 69.28,101.4 70.49,101.4 71.35,100.55 75.47,100.55 75.6,100.42 79.98,100.42 81.11,99.3 82.5,99.3
  vias: v1(63.6,110.4) v1(64.18,110.41) v1(64.74,110.42) v1(68.8,100.2) v1(69.36,100.2) v1(70.35,100.2) v1(84.3,98.98) v1(84.85,98.98) v1(85.41,98.98) v1(85.97,98.98) v3(65.54,105.47) v3(65.54,103.75) v3(67.61,101.99)
+BL_PWR_SRC_P: length 2
  BOTTOM w0.127: v2(90.02,95.49) 90.1,95.49 QV1.6
+COINCELL: length 65.5
  TOP w0.508: v1(242.65,33.69) 242.65,33.95 242.25,34.35 241.13,34.35 v2(240.73,34.74) 239.67,34.74 PR2.1
  IN3 w0.508: v1(254.48,28.22) 255.75,28.22 255.92,28.05 279.42,28.05 279.91,27.55 284.76,27.55 288.51,23.8 288.51,21.62 289.88,20.25 289.88,16.85 v1(291.47,15.26)
  BOTTOM w0.508: v1(254.48,28.22) 246.84,28.22 242.65,32.41 v1(242.65,33.69) ; JRTC1.1 v1(291.47,15.26)
+DDR_VREF_A_CA: length 7.6
  TOP w0.508: RD15.2 RD16.1 RD17.1 v2(101.56,29.19) 101.56,29.22 101.37,29.42 v1(100.84,29.42) 100.48,29.78 CD25.1 CD26.1
  BOTTOM w0.305: v1(100.84,29.42) 100.21,30.05 JDIMM1.164
+DDR_VREF_B_CA: length 12.1
  TOP w0.508: v1(177.41,32.49) v3(176.86,31.94) 175.63,30.72 175.63,29.7 175.1,29.16 173.76,29.16 173.12,28.52 RD28.2 173.12,27.51 CD57.1 CD58.1 RD29.1 170.96,27.44 170.38,26.85 RD30.1
  BOTTOM w0.305: JDIMM2.164 v1(177.41,32.49)
+DDR_VREF_B_DQ: length 185.3
  TOP w0.508: v1(171.88,29.41) 171.35,29.41 v2(170.6,28.66) 169.61,27.67 CD62.1 169.36,27.41 169.35,27.4 RD30.2
  IN1 w0.508: v1(79.85,62.16) 79.85,49.99 71.7,41.84 71.7,32 74.94,28.76 77.43,28.76 v1(78.12,28.06) ; v1(113.54,28) 113.86,27.68 117.1,27.68 117.86,28.44 125.04,28.44 126.02,27.46 144.22,27.46 146.06,29.3 146.06,30.07 146.53,30.54 160.6,30.54 162.03,29.11 164.37,29.11 166,30.74 170.55,30.74 v1(171.88,29.41)
  BOTTOM w0.127: UC1.E36 111.61,68.64 110.47,67.5 109.17,67.5 108.42,68.26 107.35,68.26
  BOTTOM w0.508: v1(78.12,28.06) 78.12,27.71 80.63,25.2 81.77,25.2 83.55,23.43 97.94,23.43 103.19,28.68 105.94,28.68 106.62,28 v1(113.54,28) ; v1(79.85,62.16) 79.85,63.26 80.57,63.99 102.04,63.99 102.63,64.59 102.63,66.17 104.34,67.88 106.97,67.88 107.35,68.26
+DDR_VREF_CA: length 102.7
  TOP w0.508: CD31.1 102.35,27.31 RD17.2 101.56,26.7 100.45,25.58 v2(99.51,25.58) 98.62,25.58 v1(98.18,26.03)
  IN1 w0.508: v1(78.95,28.87) 78.95,29 78.3,29.65 78.3,30.35 77.79,30.86 75.32,30.86 73.92,32.25 73.92,41.33 81.24,48.65 81.24,62.64 v1(81.03,62.85)
  BOTTOM w0.127: UC1.F36 112.17,68.88 110.58,67.29 108.04,67.29
  BOTTOM w0.508: 108.04,67.29 107.61,66.86 104.76,66.86 103.65,65.75 103.65,64.17 102.33,62.85 v1(81.03,62.85) ; v1(78.95,28.87) 79.14,29.06 80.05,29.06 80.28,28.84 81.34,28.84 84.03,26.14 87.99,26.14 89.25,27.4 91.15,27.4 92.55,26 98.15,26 v1(98.18,26.03)
+EC_DEBUG_VCC: length 9.6
  TOP w0.127: v1(293.19,88.2) 292.91,88.47 292.91,90.18 294.12,91.39 v2(294.12,91.76) 294.31,91.95 294.31,92.37 294.68,92.74 295.25,92.74 RE71.2
  BOTTOM w0.127: v1(293.19,88.2) 293.15,88.16 293.15,87.98 293.54,87.59 JDEG1.1
+EDP_VDD: length 2.3
  BOTTOM w0.127: v2(106.29,96.96) 106.29,97.42 106.94,98.06 RV101.2
+LCDVDD: length 36.3
  TOP w0.127: DV12.2 85.96,104.93 86.81,105.78 86.81,107.19 v3(87.33,107.72) ; v3(85.77,106.36) 85.77,105.18
  IN3 w1.524: 69.12,108.95 77.72,108.95 79.61,107.06 79.9,107.06 82.57,104.39 84.02,104.39
  BOTTOM w1.524: 103.19,103.94 103.04,104.1 94.88,104.1 94.78,104.2 88.68,104.2
  vias: v1(67.92,110.42) v1(68.5,110.42) v1(69.06,110.42) v1(84.73,103.67) v1(85.3,103.67) v1(85.88,103.67) v3(84.58,105.19)
+MIC2-VREFO-L: length 10.1
  TOP w0.203: v1(285.91,39.34) 285.07,39.34 284.97,39.44 UA1.28
  TOP w0.508: v1(290.52,38.22) 290.52,38.54 290.01,39.05 289.31,39.05 v2(289.03,39.33) 288.63,39.73 RA5.1
  IN4 w0.508: v1(290.52,38.22) 290.52,38.41 290.01,38.92 288.49,38.92 288.07,39.34 v1(285.91,39.34)
+MIC2-VREFO-R: length 13.4
  TOP w0.508: RA6.1 288.94,40.62 289.76,39.81 290.39,39.81 v2(291.28,38.92) v1(291.28,38.22)
  IN4 w0.508: v1(285.26,39.82) 285.3,39.86 285.3,40.88 285.64,41.22 288.28,41.22 289.82,39.68 290.33,39.68 291.28,38.73 v1(291.28,38.22)
+PECI_VREF: length 11.4
  TOP w0.127: v1(283.15,92.13) 283.52,92.13 v3(283.89,92.5)
  TOP w0.254: v1(279.41,86.15) 279.02,85.76 UE1.J11
  TOP w0.381: RE59.2 281.74,92.03 CE25.1 282.78,92.03 282.88,92.13 v1(283.15,92.13)
  IN4 w0.508: v1(279.41,86.15) 278.83,86.73 278.83,87.24 280.19,88.6 280.19,89.96 282.37,92.13 v1(283.15,92.13)
+RREF: length 2.4
  TOP w0.127: RR4.1 288.94,62.19 288.45,61.69 288.11,61.69 v2(287.18,60.76)
+RTC_CELL: length 191.7
  TOP w0.127: PD3.1 237.47,31.32 v3(237.47,30.99)
  TOP w0.381: v1(287.28,42.86) 287.27,42.84 RA54.2
  TOP w0.508: RE551.2 271.82,66.11 QE15.3 270.49,67.44 270.49,67.7 v1(270.49,67.7) ; RE31.1 266.57,73.15 266.97,72.74 v1(266.97,72.4) ; RE507.2 267.02,80.44 266.67,80.78 RE822.2 266.15,80.21 264.46,78.52 v1(263.63,78.52) ; v1(276.36,34.22) 275.85,34.73 273.56,34.73 272.84,35.45 272.84,36.8 272.99,36.95 272.99,39.68 273.4,40.09 273.4,40.9 272.74,41.56 272.74,42.22 271.66,43.3 271.66,47.97 272.45,48.76 274.58,48.76 275.28,49.46 275.28,50.86 v1(276.42,52) ; v1(242.97,31.11) 242.97,31.34 242.12,32.19 240.67,32.19 240.1,31.62 PC3.1 239.05,32.04 PD3.1 ; RE32.1 268.85,73.21 v1(268.85,72.89) 268.85,72.47 RE508.2
  IN1 w0.508: v1(242.97,31.11) 243.68,31.11 246.08,28.71 253.36,28.71 254.01,29.36 255.01,29.36 255.66,28.71 261.78,28.71 262.54,29.48 264.78,29.48 264.99,29.27 266.01,29.27 266.51,29.77 273.04,29.77 274.6,31.33 274.6,33.03 275.13,33.56 275.7,33.56 v1(276.36,34.22) ; v1(298.39,68.18) 299.01,67.56 301.06,67.56 301.89,66.73 301.89,62.92 303.73,61.08 303.73,53.91 300.93,51.11 298.71,51.11 298.33,50.73 298.33,49.78 297.63,49.08 296.17,49.08 295.09,48 292.87,48 292.11,48.76 288.35,48.76 v1(287.42,47.83) 287.53,47.72 287.53,46.67 287.28,46.41 v1(287.28,42.86)
  IN3 w0.508: v1(266.97,72.4) 267.26,72.69 267.7,72.69 267.9,72.89 v1(268.85,72.89)
  IN4 w0.508: v1(279.98,70.31) 279.44,70.31 278.28,69.15 275.31,69.15 274.85,69.61 274.85,70.16 274.34,70.67 271.72,70.67 271.29,71.1 270.57,71.1 270.13,70.66 270.13,68.58 270.49,68.22 v1(270.49,67.7) ; v1(263.63,78.52) 263.63,77.09 266.97,73.75 266.97,72.4 v1(266.97,72.4)
  BOTTOM w0.508: v1(298.39,68.18) 297.24,69.34 293.83,69.34 292.08,71.09 289.29,71.09 288.74,70.54 285.86,70.54 285.67,70.35 281.82,70.35 281.67,70.51 280.51,70.51 280.32,70.31 v1(279.98,70.31) ; v1(270.49,67.7) 270.49,68.98 269.56,69.91 266.78,69.91 266.27,70.42 266.27,71.89 266.78,72.4 v1(266.97,72.4) ; v1(276.42,52) 276.42,51.81 278.29,49.94 279.06,49.94 279.66,49.33 279.66,48.63 280.26,48.04 284.31,48.04 284.98,47.36 285.95,47.36 286.42,47.83 v1(287.42,47.83)
+RTC_CELL_PCH: length 211.5
  TOP w0.127: v1(152.47,55.2) v3(151.15,55.2)
  TOP w0.254: v1(142.39,76.96) 142.39,76.99 141.83,77.55 CC72.1
  TOP w0.381: v1(150.81,51.46) 150.73,51.54 150.73,52.17 CC73.1 150.46,52.43 RC56.2 RC69.2
  TOP w0.508: RC57.2 152.42,52.94 152.93,52.43 v1(152.93,52.13) ; RE546.1 272.17,67.82 271.35,68.64 270.41,68.64 QE15.1 270.26,69.34 v1(270.78,69.86)
  IN2 w0.508: v1(152.93,52.13) 152.72,52.33 152.72,54.95 v1(152.47,55.2)
  IN3 w0.508: 152.89,52.77 153.13,53.01 154.57,53.01 155.14,52.44 157.86,52.44 158.82,53.4 165.44,53.4 168.73,50.11 180.65,50.11 183.04,47.72 206.49,47.72 215.94,38.27 224.52,38.27 226.34,36.44 237.61,36.44 238.15,35.9 244.53,35.9 245.45,36.82 246.7,36.82 247.11,37.22 250.01,37.22 252.05,39.26 256.42,39.26 258.75,41.59 260.83,41.59 261.78,42.54 262.96,42.54 264.29,43.87 267.08,43.87 268.15,44.94 268.84,44.94 269.64,45.74 269.64,49.82 270.73,50.91 270.95,50.91 271.79,51.75 271.79,52.38 273.14,53.73 273.14,54.02 273.71,54.59 274.17,54.59 274.68,55.1 274.68,56.07 275.21,56.6 276.2,56.6 277.1,57.49 277.1,58.83 278.19,59.93 278.19,61.52 277.94,61.77 277.94,65.71 278.53,66.3 v1(278.53,67.59) ; 152.89,52.77 152.89,52.16 v1(152.93,52.13) ; 152.89,52.77 151.65,52.77 150.81,51.93 v1(150.81,51.46) ; 141.1,76.7 141.1,76.07 140.6,75.56 140.6,71.09 142.06,69.62 144.64,69.62 146.6,67.66 146.6,65.7 v1(146.79,65.5)
  IN4 w0.508: v1(146.79,65.5) 147.02,65.5 147.58,64.95 147.58,59.27 151.64,55.2 151.96,55.2 151.96,55.2 v1(152.47,55.2) ; v1(270.78,69.86) 270.78,69.32 272.23,67.88 274.64,67.88 275.31,68.54 277.22,68.54 278.17,67.59 v1(278.53,67.59)
  BOTTOM w0.2: UC1.BR23 v1(142.39,76.96)
+RTC_CELL_VBAT: length 6.9
  TOP w0.127: RE32.2 268.92,74.48 268.37,73.93 268.37,73.01 v2(268.1,72.74)
  TOP w0.254: UE1.A2 v1(272.26,78.2)
  IN4 w0.508: v1(270.49,75.11) 271.82,76.45 271.95,76.45 272.45,76.96 272.45,78.01 v1(272.26,78.2)
+SDREG2:
  vias: v2(295.47,68.14)
+SIM_PWR: length 45
  TOP w0.127: v1(300.62,63.21) v3(300.62,64.07)
  TOP w0.508: RZ335.1 290.52,56 v1(290.26,55.75) ; CZ37.1 299.4,62.54 CZ41.1 299.96,62.55 v1(300.62,63.21)
  IN2 w0.508: v1(300.62,63.21) 299.35,63.21 291.89,55.75 v1(290.26,55.75)
  IN4 w0.508: v1(288.76,61.29) 288.76,62.27 288.58,62.46 288.58,63.98 287.85,64.71 286.89,64.71 283.22,68.37 282.03,68.37 281.12,67.46 281.12,66.97 280.18,66.03 278.48,66.03 278.37,65.92 277.5,65.92 277.06,65.48 v1(275.94,65.48)
  BOTTOM w0.305: JNGFF2.36 275.93,65.47 v1(275.94,65.48)
  BOTTOM w0.508: v1(300.62,63.21) 300.81,63.01 JSIM1.C1 ; v1(290.26,55.75) 289.95,55.75 289.31,56.38 289.31,58.16 289.76,58.61 289.76,59.75 288.76,60.75 v1(288.76,61.29)
+TBT_SVR_IND:
  vias: v3(21.05,88.97)
+TBTA_LDO_BMC: length 3.5
  BOTTOM w0.203: CT71.1 32.55,53.85 32.06,53.85 31.7,54.2 v2(31.7,54.62) 31.66,54.66 31.66,55.87 UT5.E1
+TS_PWR: length 23.9
  TOP w0.127: v3(55.96,108.55) 56.58,109.18 v1(56.58,110.39) ; v3(76.65,111.53) 77.31,110.87 FV2.1
  IN3 w1.016: 74.96,106.06 66.31,106.06 63.68,108.69 57.04,108.69 56.33,109.4
  vias: v1(56.03,110.39) v1(75.3,106.97) v1(75.88,106.97) v3(76,107.68)
+TS_PWR_QV8: length 1.6
  TOP w0.127: v2(78.34,111.4) 78.81,110.93 FV2.2
+USB_EX2_PWR: length 1.3
  TOP w0.127: v1(26.93,40.95) v3(26.93,39.62)
  vias: v1(25.22,40.95) v1(25.79,40.95) v1(26.36,40.95)
+UZ12_TPM: length 2.3
  TOP w0.254: CZ50.1 180.54,84.72 v2(180.79,84.46) 181.41,83.84 UZ12.8
+VHDMI_VCC: length 11.2
  IN2 w0.508: v1(7.11,52.52) 8.07,51.56 11.24,51.56 11.86,52.18 15.79,52.18
  BOTTOM w0.508: RV23.2 RV22.2 v1(7.11,52.52)
  vias: v1(13.21,59.94) v1(20.33,47.94) v1(20.9,47.94) v2(14.26,60.04)
+VR_CAP: length 39.3
  TOP w0.127: v3(265.42,76.12) 266.27,75.27 v1(266.81,75.27)
  TOP w0.254: v1(273.79,85.38) 273.85,85.38 274.22,85.01 UE1.C10 ; CE31.1 280.93,75.62 v1(280.36,76.19) 279.02,77.53 UE1.J1
  IN1 w0.508: v1(266.81,75.27) 267.47,74.6 268.66,74.6 269.86,75.8 274.2,75.8 274.52,75.48 277.74,75.48 277.93,75.67 279.85,75.67 280.36,76.18 v1(280.36,76.19)
  IN3 w0.508: v1(273.79,85.38) 269.91,85.38 268.61,86.68 v1(268.61,86.77)
  BOTTOM w0.508: v1(268.61,86.77) 268.61,85.66 265.54,82.58 265.54,76.54 v1(266.81,75.27)
+Z4012: length 4.9
  TOP w0.127: v2(237.23,34.96) PR2.2
  TOP w0.508: PR9.1 238.92,36.52 PQ13.2 238.52,34.98 PR2.2 238.54,34.23 PD3.2
AC_DIS: length 344.3
  TOP w0.102: v1(277.76,88.32) 277.76,87.64 277.78,87.62 277.78,87 UE1.H12
  TOP w0.127: RE83.1 278.85,93.28 278.85,92.29 278.28,91.71 278.28,89.23 277.76,88.71 v1(277.76,88.32)
  TOP w0.254: PR720.1 42.24,69.49 PQ703.2 42.24,68.58 40.99,67.33 40.99,65.37 v2(41.03,65.34) 41.28,65.08 41.28,63.94 42.2,63.02 44.03,63.02 44.71,62.34 44.71,61.96 v1(45.1,61.56)
  IN1 w0.084: v1(288.27,88.51) 288.23,88.55 285.67,88.55 285.42,88.3 282.41,88.3 282.26,88.45 278.93,88.45 278.87,88.51 277.95,88.51 v1(277.76,88.32)
  IN3 w0.122: v1(288.27,88.51) 288.11,88.51 285.34,85.74 285.34,84.21 286.16,83.39 286.16,82.7 286.03,82.58 284.14,82.58 283.94,82.38 283.94,80.46 283.89,80.42 283.89,78.48 282.95,77.53 282.95,76.92 282.55,76.52 282.55,76.03 283.03,75.55 283.03,73.46 283.45,73.04 283.45,72 283.22,71.77 282.47,71.77 281.86,71.15 281.86,68.87 280.82,67.83 280.82,65.34 280.45,64.98 280.45,61.96 281.68,60.74 281.68,58.52 281.85,58.34 281.85,57.65 280.91,56.7 280.91,54.92 280.15,54.16 278.25,54.16 276.99,52.9 275.35,52.9 274.87,52.42 274.87,51.21 272.71,49.05 272.71,48.13 272.5,47.92 272.5,43.86 270.93,42.29 269.25,42.29 268.74,41.78 268.21,41.78 267.41,40.98 264.52,40.98 262.43,38.89 261.22,38.89 259.64,37.32 257.27,37.32 256.31,36.36 253.6,36.36 253.23,36 250.89,36 250.13,35.24 245.72,35.24 245.07,34.59 237.61,34.59 237.18,35.02 225.28,35.02 225.02,35.28 221.86,35.28 220.19,36.96 215.27,36.96 210.17,42.05 207.52,42.05 205.2,44.38 203.93,44.38 202.62,45.69 153.98,45.69 152.68,44.39 142.13,44.39 138.18,48.35 95.1,48.35 92.97,46.22 83.68,46.22 83.51,46.06 67.09,46.06 66.87,45.84 60.17,45.84 59.85,45.52 58.78,45.52 58.53,45.78 53.26,45.78 49.92,49.12 49.92,51.22 49.01,52.12 45.22,52.12 43.31,54.03 43.31,56.54 45.89,59.11 46.22,59.11 46.63,59.52 46.63,60.89 46.16,61.36 45.31,61.36 v1(45.1,61.56)
AC_DISC#: length 411.8
  TOP w0.127: v3(39.97,106.22) 39.48,106.71 v1(38.92,106.71) ; v1(275.57,88.67) 275.57,87.6 UE1.E13
  TOP w0.254: v1(34.63,101.51) PC810.1 33.95,101.61 PQ810.6 34.49,102.51 34.74,102.76 34.74,103.24 35.31,103.81 PQ810.3 ; v1(51.39,106.12) 51.97,106.12 52.1,105.99 PR829.1 52.09,105.93 52.09,105.5 PQ811.6
  TOP w0.508: PR828.2 38.61,106.41 v1(38.92,106.71)
  IN1 w0.084: v1(287.66,89.22) 287.21,88.77 286.6,88.77 286.08,89.29 285.77,89.29 285.15,88.67 282.6,88.67 282.45,88.83 280.01,88.83 279.58,89.26 277.12,89.26 276.54,88.67 275.58,88.67 v1(275.57,88.67)
  IN3 w0.122: v1(287.66,89.22) 287.6,89.16 287.6,88.63 284.89,85.92 284.89,84.44 284.26,83.81 284.25,83.81 283.27,82.83 283.27,81.33 282.05,80.11 282.05,77.29 281.47,76.71 281.47,75.59 280.99,75.12 280.99,73.05 279.59,71.65 279.59,69.04 279.08,68.53 279.08,66.26 278.36,65.54 278.36,61.94 278.61,61.69 278.61,59.59 278.24,59.22 278.24,57.84 276.58,56.18 275.4,56.18 275.1,55.88 275.1,54.93 274.32,54.15 274.16,54.15 272.21,52.21 272.21,51.54 271.17,50.5 270.91,50.5 270.06,49.65 270.06,45.57 269.01,44.52 268.32,44.52 266.7,42.9 264.85,42.9 262.84,40.89 258.64,40.89 255.98,38.23 251.6,38.23 250.18,36.81 247.28,36.81 246.87,36.4 245.62,36.4 244.7,35.48 237.98,35.48 237.46,36 226.2,36 224.35,37.85 215.77,37.85 208.09,45.53 204.05,45.53 202.99,46.59 153.61,46.59 152.39,45.36 142.43,45.36 138.43,49.37 94.85,49.37 92.85,47.36 83.55,47.36 83.14,46.95 64.14,46.95 63.94,46.75 61.02,46.75 60.71,47.06 55.11,47.06 54.79,46.75 53.55,46.75 51.76,48.55 51.76,53.42 52.42,54.09 52.42,57.75 51.39,58.78 51.39,60.77 50.86,61.3 49.33,61.3 48.88,61.75 48.88,62.31 45.63,65.56 45.63,72.56 47.13,74.06 47.13,74.35 48.23,75.46 48.23,76.15 49.51,77.43 49.51,82.66 52.31,85.46 52.31,86.94 52.05,87.2 48.27,87.2 46.17,89.31 46.17,91.3 47.21,92.35 47.21,93.87 45.72,95.37 40.65,95.37 40.54,95.26 38.29,95.26 37.11,96.43 37.11,100.36 35.96,101.51 v1(34.63,101.51)
  BOTTOM w0.254: v1(34.63,101.51) 34.63,102.47 36.57,104.41 36.57,106.16 37.6,107.19 38.56,107.19 38.92,106.84 v1(38.92,106.71) 38.92,105.32 39.35,104.88 39.35,101.97 40.24,101.09 41.94,101.09 42.36,100.67 45.1,100.67 46.73,102.29 50.09,102.29 51.39,103.59 v1(51.39,106.12)
AC_PRESENT: length 204.9
  TOP w0.127: v1(280.22,83.76) UE1.K8 ; v2(169.67,66.53) 169.34,66.21 v1(169.34,65.54)
  IN2 w0.122: v1(176.9,63.67) 176.29,63.67 175.63,64.33 175.04,64.33 174.72,64.65 174.5,64.87 173.51,64.87 173.17,65.21 172.52,65.21 172.18,64.87 170.01,64.87 v1(169.34,65.54)
  IN3 w0.122: v1(280.22,83.76) 279.82,83.35 279.82,81.2 279.81,81.19 279.81,76.47 277.82,74.48 277.82,72.46 277.56,72.2 276.18,72.2 274.96,70.99 274.96,65.18 274.31,64.52 274.31,61.27 272.83,59.79 272.83,58.9 272.26,58.33 272.26,57.35 272.14,57.23 271.61,56.7 271.61,54.36 270.62,53.38 270.26,53.38 269.68,52.8 269.68,52.03 267.59,49.94 267.59,48.56 265.83,46.8 260.99,46.8 258.22,44.03 254.71,44.03 253.95,43.27 253.57,43.27 249.93,39.63 246.71,39.63 246.27,39.19 243.42,39.19 243.03,38.8 237.47,38.8 237.31,38.65 227.36,38.65 225.53,40.47 217.05,40.47 206.73,50.79 192.98,50.79 192.43,50.24 190.49,50.24 182.25,58.48 182.25,60.06 180.93,61.39 179.28,61.39 178.92,61.74 178.92,62.46 177.71,63.67 v1(176.9,63.67)
  BOTTOM w0.076: UC1.BU35 143.83,69.57 143.83,69.09 143.79,68.98 143.79,68.74 143.88,68.5 143.88,67.44 145.07,66.24 145.07,64.92 145.09,64.9 145.09,62.51 146.22,61.39
  BOTTOM w0.127: 146.22,61.39 147.37,60.24 153.23,60.24 154.22,59.25 155.94,59.25 157.54,57.65 159.9,57.65 160.41,58.16 161.55,58.16 161.89,58.5 161.89,59.33 162.06,59.49 168.01,59.49 168.77,60.26 174.44,60.26 175.9,61.72 175.9,62.41 176.54,63.05 176.54,63.05 176.9,63.42 v1(176.9,63.67) ; RC555.1 169.34,66.37 v1(169.34,65.54)
ACAV_IN: length 411.6
  TOP w0.127: UE1.C7 273.86,82.2 v1(273.82,82.2) ; v3(265.82,82.6) v1(266.69,82.6) 267.05,82.6 CE67.1 ; DZ12.1 301.56,5.28 v1(301.61,5.28)
  TOP w0.254: PR744.1 42.11,64.8 PR740.2 42.84,63.81 43.22,63.43 44.13,63.43 45.07,62.49 45.07,62.4 v1(45.51,61.96)
  IN1 w0.084: v1(288.99,55.75) 288.37,56.37 282.63,56.37 282.42,56.58 281.18,56.58 v1(280.29,55.68) ; v1(266.69,82.6) 266.79,82.49 268.37,82.49 268.97,83.09 271.49,83.09 272.75,81.83 273.4,81.83 273.77,82.2 v1(273.82,82.2) 274.54,82.2 274.91,81.83 276.58,81.83 278.3,80.11 280.35,80.11 280.61,79.85 280.61,79.45 280.68,79.39 v1(282.93,79.39)
  IN3 w0.122: v1(282.93,79.39) 282.93,78.57 282.72,78.37 282.72,77.01 282.33,76.62 282.33,75.94 282.45,75.81 282.45,75.28 282.25,75.07 282.25,74.75 282.45,74.54 282.45,72.38 281.41,71.34 281.41,69.14 280.66,68.39 279.89,68.39 279.75,68.25 279.75,65.99 280.01,65.73 280.01,61.78 281.23,60.55 281.23,58.33 281.41,58.16 281.41,57.83 280.29,56.72 v1(280.29,55.68) 280.45,55.52 280.45,55.1 279.96,54.61 278.06,54.61 276.81,53.35 275.16,53.35 274.85,53.03 274.68,53.03 274.42,52.77 274.42,51.48 272.26,49.33 272.26,48.32 272.05,48.11 272.05,44.04 270.74,42.73 269.05,42.73 268.54,42.23 265.13,42.23 262.24,39.34 261.03,39.34 259.46,37.76 256.92,37.76 256.71,37.56 251.88,37.56 250.46,36.14 247.56,36.14 247.15,35.73 245.9,35.73 244.98,34.81 237.7,34.81 237.23,35.29 225.33,35.29 225.11,35.51 221.95,35.51 220.28,37.18 215.36,37.18 210.26,42.27 207.62,42.27 205.19,44.7 203.93,44.7 202.71,45.92 153.89,45.92 152.59,44.62 142.22,44.62 138.27,48.57 95,48.57 93.07,46.63 83.77,46.63 83.42,46.28 66.99,46.28 66.79,46.08 60.09,46.08 59.76,45.74 58.88,45.74 58.54,46.08 53.28,46.08 50.14,49.22 50.14,51.31 49.11,52.35 45.31,52.35 43.53,54.13 43.53,56.44 45.98,58.89 46.31,58.89 46.85,59.43 46.85,61.16 46.06,61.96 v1(45.51,61.96) ; v1(288.99,55.75) 288.99,55.54 287.53,54.08 287.53,52.7 286.59,51.76 285.45,51.76 284.9,51.21 283.43,51.21 283.25,51.21 282.2,50.15 282.2,49.87 282.12,49.79 282.12,49.53 282,49.41 282,49.07 281.44,48.51 280.87,48.51 280.29,47.94 280.29,47.93 278.2,45.84 278.2,36.95 284.04,31.11 286.39,31.11 287.02,30.48 293.94,30.48 299.92,24.5 299.92,9 302.09,6.83 302.09,5.76 v1(301.61,5.28)
  BOTTOM w0.254: v1(45.51,61.96) 45.66,61.8 47.64,61.8 48.04,61.41 PR3010.2
ACAV_IN1: length 46.9
  TOP w0.254: PQ703.1 41.59,67.17 42.23,67.81 42.61,67.81 43.11,68.31 43.11,69.86 43.61,70.35 44.72,70.35 PR741.1 45.21,70.38 46.91,70.38 v1(47.25,70.03) ; PR716.1 55.19,58.63 PR710.1 54.36,58.63 54.16,58.83 54.16,60.92 53.35,61.73 v3(52.32,61.73) 50.56,61.73 49.45,60.61 46,60.61 v1(45.95,60.66) ; PR722.1 40.2,50.79 v1(40.13,50.87)
  IN3 w0.122: v1(45.95,60.66) 45.37,60.08 44.99,60.08 44.77,59.86 44.77,58.82 42.17,56.21 42.17,52.91 v1(40.13,50.87)
  IN4 w0.254: v1(45.95,60.66) 46.58,60.66 47.02,61.11 47.02,65.55 46.68,65.89 46.68,69.53 47.19,70.03 v1(47.25,70.03)
  BOTTOM w0.254: v1(45.95,60.66) 46.18,60.43 PR3009.2
ACIN_CHG: length 12.2
  TOP w0.203: PC736.1 42.22,54.4 42.42,54.6 v1(42.92,54.6) 43.69,54.6 43.84,54.45 PU700.19
  TOP w0.254: PR706.1 39.93,54.44 PR705.2 40.39,55.31 v2(40.89,54.81) 41.29,54.4 PC736.1
  BOTTOM w0.254: v1(42.92,54.6) 43.15,54.6 45.89,51.86 PR3001.2
ACOK_CHG: length 3.8
  TOP w0.203: PR722.2 42.32,50.79 42.51,50.98 43.24,50.98 43.86,51.59 v2(43.86,51.76) 43.86,51.82 44.49,52.45 PU700.24
ADJ_2.5V_MEM: length 5.3
  TOP w0.127: PR515.2 118.05,25.19 v2(117.47,24.61)
  TOP w0.254: PR515.2 PC515.2 118.94,25.95 PR516.1 119.41,25.1 119.56,25.25 PU503.3
ADP_CHG: length 4.7
  TOP w0.203: PR703.2 42.14,56.79 42.68,56.79 v2(43.02,57.13) 43.39,57.13 44.21,56.31 45.32,56.31 45.53,56.11 PU700.16
ALW_PWRGD_3V_5V: length 81.5
  TOP w0.127: DC2.1 175.35,55.33 177.07,55.33 v1(177.07,55.34) 177.81,56.07 UZ6.2 177.81,56.85 v2(177.2,57.46)
  TOP w0.254: PR119.2 v1(185.84,96.74)
  IN2 w0.122: v1(185.84,96.74) 184.13,96.74 182.89,95.5 182.08,95.5 178.27,99.31 v1(175.01,99.31)
  IN3 w0.122: v1(175.01,99.31) 175.01,98.44 175.6,97.85 175.6,95.91 176.24,95.27 176.24,92.86 178.27,90.83 178.27,89.01 179.7,87.58 179.7,86.5 179.79,86.41 179.79,85.35 182.59,82.56 182.59,81.72 182.58,81.71 182.58,80.72 184.79,78.5 184.98,78.5 185.73,77.75 185.73,76.69 186.14,76.28 186.14,73.67 188.75,71.06 188.75,67.48 188.53,67.26 188.53,60.49 187.78,59.74 187.78,59.04 188,58.82 v1(188.28,58.82)
  BOTTOM w0.127: v1(177.07,55.34) 177.07,54.5 177.85,53.72 180.49,53.72 181.84,55.07 186.14,55.07 188.28,57.21 v1(188.28,58.82)
  BOTTOM w0.254: PR120.2 185.19,96.74 v1(185.84,96.74)
ALWON: length 164.7
  TOP w0.127: v2(185.3,95.8) 185.59,95.52 PR114.1 185.59,93.64 v1(185.73,93.49) ; UE1.A5 272.39,80.96 272.09,80.65 v1(271.66,80.65)
  IN1 w0.084: v1(271.66,80.65) 271.58,80.65 271.15,81.08 266.77,81.08 266.58,81.27 263.09,81.27 v1(262.58,80.77)
  IN3 w0.122: v1(262.58,80.77) 262.36,80.55 262.36,73.68 265.75,70.29 265.75,68.82 264.38,67.45 264.38,63.55 263.82,62.99 263.82,57.95 263.49,57.61 263.49,57.5 263.11,57.12 260.95,57.12 257.62,53.79 255.19,53.79 252.59,51.19 251.32,51.19 246.72,46.59 244.87,46.59 244.03,45.75 240.72,45.75 240.02,45.05 240.02,44.46 239.69,44.14 234.08,44.14 233.94,44 232.63,44 231.03,45.6 219.2,45.6 208.98,55.81 208.95,55.81 205.83,58.93 197.11,58.93 194.24,61.8 194.24,67.24 194.94,67.94 194.94,78.75 190.56,83.12 190.56,84.11 188.82,85.85 188.82,86.62 188.43,87.01 188.43,94.25 189.01,94.83 189.01,95.91 188.57,96.36 186.6,96.36 186.51,96.27 186.51,95.61 185.59,94.68 185.59,93.64 v1(185.73,93.49)
AMON/BMON_CHG: length 4.6
  TOP w0.203: PR729.1 48.86,49.27 PC750.1 PR743.1 47.21,49.61 47.68,50.08 v2(47.68,50.32) 47.68,50.4 47.13,50.95 PU700.29
AR_DP1_CTRL_CLK: length 69.1
  TOP w0.127: RT13.1 32.26,84.86 v1(32.26,84.19)
  IN2 w0.122: v1(32.26,84.19) 32.26,83.69 31.63,83.05 31.63,80.13 32.26,79.5 33.15,79.5 33.72,78.92 33.72,71.37 32.71,70.35 31.18,70.35 29.66,68.83 29.66,66.92 28.58,65.84 27.44,65.84 27.18,65.59 26.68,65.59 v1(26.61,65.65)
  IN4 w0.084: v1(26.61,65.65) 26.55,65.59 26.55,62.72 29.15,60.11 29.15,58.1 28.84,57.78 28.84,53.95 29.6,53.19 29.6,50.3 28.82,49.52 27.64,49.52 26.25,50.92 17.61,50.92 16.02,52.51 13.53,52.51 12.71,53.33 11.82,53.33 v1(11.37,53.78)
  BOTTOM w0.076: UT1.Y2 30.69,82.3 30.69,82.62 30.7,82.63 30.7,82.74 31.11,83.15 31.22,83.15 31.31,83.24 31.31,83.31 31.5,83.5 31.5,83.59 31.71,83.8
  BOTTOM w0.127: 31.71,83.8 32.04,84.13 32.07,84.13 32.14,84.19 v1(32.26,84.19) ; QV3.1 9.33,54.24 9.78,53.78 v1(11.37,53.78)
AR_DP1_CTRL_DATA: length 66.7
  TOP w0.076: v1(31.37,84.07) 31.68,83.76 v2(31.86,83.76)
  TOP w0.127: v1(31.37,84.07) 31.38,84.07 RT12.1
  IN2 w0.122: v1(31.37,84.07) 31.31,84.01 31.31,80.07 32.2,79.18 33.09,79.18 33.47,78.8 33.47,71.49 32.65,70.67 31.06,70.67 29.34,68.95 29.34,66.99 28.52,66.16 26.74,66.16 v1(26.61,66.29)
  IN4 w0.084: v1(11.43,53.08) 12.64,53.08 13.4,52.32 15.94,52.32 17.53,50.73 26.17,50.73 27.57,49.33 28.9,49.33 29.79,50.22 29.79,53.27 29.03,54.03 29.03,57.65 29.34,57.97 29.34,60.19 26.74,62.8 26.74,65.02 26.99,65.27 26.99,66.03 26.74,66.29 v1(26.61,66.29)
  BOTTOM w0.076: v1(31.37,84.07) 31.18,83.88 31.18,83.5 30.51,82.82 30.51,82.58 UT1.Y1
  BOTTOM w0.127: QV3.4 v1(11.43,53.08)
AR_DP1_HPD: length 45.6
  TOP w0.127: QV5.3 16.45,65.86 RV20.1 16.45,63.7 v2(16.29,63.54) 16.06,63.3 v1(15.44,63.3)
  IN3 w0.122: v1(15.44,63.3) 15.63,63.3 16.58,64.26 16.58,77.07 16.12,77.53 16.12,83.62 16.39,83.89 16.39,85.78 16.12,86.05 16.12,88.62 16.9,89.4 22.87,89.4 23.73,88.54 24.32,88.54 v1(24.81,88.05)
  BOTTOM w0.076: 24.67,85.1 24.2,84.63 24.2,83.62 24.28,83.54 24.28,82.88 24.48,82.68 UT1.G1
  BOTTOM w0.127: v1(24.81,88.05) 24.5,87.74 24.5,86.67 24.67,86.51 24.67,85.1
AR_DP1_N0: length 41.2
  IN2 w0.102: v1(28.42,83.8) 28.17,83.56 27.87,83.56 27.57,83.26 27.57,82.56 26.85,81.85 23.04,81.85 22.51,81.31 22.51,73.1 23.69,71.92 23.69,70.84 24.84,69.7 24.84,62.73 23.31,61.21 23.31,59 22.83,58.52 22.83,54.46 21.94,53.56 21.36,53.56 v1(21.27,53.65)
  BOTTOM w0.089: UT1.R1 27.9,83 27.9,83.27 28.42,83.78 v1(28.42,83.8)
  BOTTOM w0.114: CV32.1 20.28,53.51 20.53,53.51 CT201.2 20.77,53.5 21.12,53.5 v1(21.27,53.65)
AR_DP1_N1: length 43.8
  IN2 w0.102: v1(26.71,83.91) 26.89,83.91 27.01,84.03 27.01,84.42 26.6,84.83 22.69,84.83 22.07,84.21 20.61,84.21 19.63,83.23 19.63,78.5 20.06,78.07 20.06,71.16 16.95,68.05 16.95,65.59 17.8,64.74 17.8,63.46 20.65,60.62 20.65,59.94 20.01,59.3 20.01,57.44 20.35,57.09 21.56,57.09 21.66,57.19 21.66,57.41 21.56,57.51 v1(21.27,57.51)
  BOTTOM w0.089: UT1.N1 27.24,82.53 27.24,83.03 26.83,83.43 26.83,83.79 v1(26.71,83.91)
  BOTTOM w0.114: v1(21.27,57.51) 21.03,57.27 20.83,57.27 20.66,57.44 CT202.2 20.63,57.44 20.51,57.32 20.22,57.32 CV34.1
AR_DP1_N2: length 37.5
  IN2 w0.102: v1(21.27,55.83) 21.47,56.03 21.47,56.08 22.23,56.85 22.23,58.81 22.61,59.19 22.61,62.07 24.14,63.6 24.14,69.26 21.9,71.49 21.9,81.58 22.91,82.59 24.99,82.59 25.25,82.84 25.25,83.86 25.47,84.09 25.96,84.09 26.15,83.91 v1(26.16,83.91)
  BOTTOM w0.076: UT1.L1 26.45,82.53 26.53,82.6 26.53,82.71 26.37,82.87 26.37,83.43 26.3,83.5 26.1,83.5 25.99,83.6 25.99,83.74 v1(26.16,83.91)
  BOTTOM w0.114: CV36.1 20.2,55.56 20.5,55.56 CT203.2 20.74,55.52 20.96,55.52 v1(21.27,55.83)
AR_DP1_N3: length 33.6
  IN2 w0.102: v1(24.79,84.16) 24.63,84 23.47,84 21.3,81.84 21.3,78.44 20.52,77.65 20.52,71.92 23.5,68.94 23.5,64.02 21.98,62.49 21.98,59.51 21.6,59.13 21.45,59.13 v1(21.22,59.37)
  BOTTOM w0.089: v1(24.79,84.16) 24.81,84.16 25.17,83.81 25.17,83.5 25.48,83.19 25.48,82.79 25.4,82.71 UT1.J1
  BOTTOM w0.114: CV38.2 20.28,59.18 20.45,59.18 20.62,59.34 CT204.2 20.81,59.18 21.02,59.18 v1(21.22,59.37)
AR_DP1_P0: length 41.2
  IN2 w0.102: v1(28.26,83.12) 28.26,83.26 28.15,83.37 27.95,83.37 27.76,83.18 27.76,82.48 26.93,81.65 23.12,81.65 22.7,81.24 22.7,73.18 23.88,72 23.88,70.92 25.03,69.78 25.03,62.66 23.5,61.13 23.5,58.92 23.02,58.44 23.02,54.38 22.02,53.37 21.58,53.37 v1(21.27,53.07)
  BOTTOM w0.089: UT1.R2 28.27,82.07 28.39,82.19 28.39,82.69 28.56,82.86 28.56,83.01 28.45,83.12 v1(28.26,83.12)
  BOTTOM w0.114: v1(21.27,53.07) 21.09,53.25 20.87,53.25 20.66,53.04 CT201.1 20.42,53.26 20.21,53.26 CV31.1
AR_DP1_P1: length 43.8
  IN2 w0.102: v1(21.22,56.71) 21.03,56.9 20.27,56.9 19.82,57.36 19.82,59.38 20.46,60.02 20.46,60.54 17.61,63.38 17.61,64.66 16.75,65.51 16.75,68.13 19.87,71.24 19.87,77.99 19.44,78.42 19.44,83.31 20.53,84.4 21.99,84.4 22.61,85.02 26.68,85.02 27.2,84.5 v1(27.2,83.63)
  BOTTOM w0.089: v1(27.2,83.63) 27.38,83.25 27.46,83.08 27.46,82.38 UT1.N2
  BOTTOM w0.114: CV33.1 19.93,56.74 20.26,57.08 20.42,57.08 CT202.1 20.67,56.85 20.8,56.98 20.96,56.98 v1(21.22,56.71)
AR_DP1_P2: length 37.4
  IN2 w0.102: v1(21.25,55.05) 21.53,55.05 21.66,55.18 21.66,56.01 22.43,56.77 22.43,58.74 22.8,59.11 22.8,61.99 24.33,63.52 24.33,69.34 22.09,71.57 22.09,81.5 22.99,82.4 25.07,82.4 25.44,82.77 25.44,83.5 v1(25.64,83.7)
  BOTTOM w0.076: UT1.L2 26.1,82.37 26.1,82.73 26.2,82.83 26.2,83.16 25.66,83.7 v1(25.64,83.7)
  BOTTOM w0.114: v1(21.25,55.05) 21.03,55.27 20.81,55.27 CT203.1 20.42,55.26 20.21,55.26 CV35.1
