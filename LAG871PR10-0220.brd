# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WP_INT_C: length 4.3
  BOTTOM w0.127: v2(38.64,40.24) PR955.1
  BOTTOM w0.254: PR955.1 39.27,38.95 WC1.6
WP_SMBCLK_C: length 4
  BOTTOM w0.127: v2(42.3,41.85) 41.28,40.84 PR953.1
  BOTTOM w0.254: PR953.1 41.92,39.92 WC1.4
WP_SMBDAT_C: length 4.2
  BOTTOM w0.127: v2(39.25,41.41) 39.67,40.99 40.34,40.99 PR954.1
  BOTTOM w0.254: WC1.5 40.58,39.83 PR954.1
WWAN_ANT_CONFIG: length 4.5
  TOP w0.127: RZ1450.1 282.75,61.64 v1(282.75,62.03) 282.48,62.3 v2(282.17,62.3)
  BOTTOM w0.127: JNGFF2.68 283.93,63.45 283.79,63.3 283.79,63.05 282.77,62.03 v1(282.75,62.03)
WWAN_COEX1: length 7.7
  TOP w0.127: RZ373.1 RZ130.1 281.63,60.07 281.63,62.47 282.08,62.91 282.46,62.91 v1(282.47,62.9) 282.47,63.18 v2(281.77,63.87)
  BOTTOM w0.127: v1(282.47,62.9) 282.47,63.13 282.93,63.59 JNGFF2.64
WWAN_COEX2: length 8.2
  TOP w0.127: v1(280.84,60.08) 281.17,60.41 v2(281.17,60.6) 281.17,61.93 280.98,62.12 RZ129.1 RZ372.1
  BOTTOM w0.127: v1(280.84,60.08) 282.07,61.31 282.07,63.11 282.43,63.47 JNGFF2.62
WWAN_COEX3: length 7.2
  TOP w0.127: v1(279.83,60.6) 279.64,60.79 279.64,62 279.51,62.12 RZ128.1 RZ374.1
  BOTTOM w0.127: JNGFF2.60 281.93,63.37 281.84,63.28 281.84,62.61 v1(279.83,60.6)
WWAN_FULL_PWR_EN: length 167.3
  TOP w0.127: v1(268.37,61) v2(268.98,61) 269.98,61 CZ198.1 RZ43.1
  IN2 w0.084: v1(156.04,77.46) 156.4,77.1 157.67,77.1
  IN2 w0.089: 161.76,79.14 161.57,78.95 159.52,78.95 157.67,77.1
  IN2 w0.122: 161.76,79.14 163.27,80.65 165.24,80.65 166.98,78.92 166.98,78.07 168.58,76.47 173.85,76.47 178.45,71.86 178.45,71.17 181.09,68.53 182.07,68.53 185.91,64.69 195.43,64.69 198.82,61.29 198.82,60.7 203.08,56.44 203.08,47.14 204.68,45.54 212.92,45.54 219.83,38.63 243.7,38.63 244.68,39.62 246.03,39.62 246.47,40.06 248.92,40.06 249.51,40.65 251,40.65 252.01,41.66 256.59,41.66 257.44,42.51 259.1,42.51 259.75,41.87 263.19,41.87 264.45,43.13 264.45,45.68 263.33,46.8 263.33,48.82 264.28,49.77 264.28,51.01 265.37,52.1 265.37,55.45 266.49,56.57 266.49,59.12 v1(268.37,61)
  BOTTOM w0.076: UC1.CM23 152.58,77.59 153.06,77.59 153.18,77.55 153.41,77.55 153.53,77.59 153.71,77.59 153.83,77.55 154.95,77.55 155.02,77.62 155.24,77.84 155.58,77.84 155.65,77.77
  BOTTOM w0.102: 155.65,77.77 155.96,77.46 v1(156.04,77.46)
  BOTTOM w0.127: v1(268.37,61) 268.87,61.49 268.87,63.05 268.43,63.48 JNGFF2.6
WWAN_MIPI_ANT_CLK: length 63.4
  IN1 w0.084: v1(306.65,97.47) 305.26,96.08 303.18,96.08 301.63,94.53 298.36,94.53 v1(297.26,93.43)
  IN2 w0.122: v1(285.63,67.89) 285.88,67.89 286.15,68.16 286.15,69.78 286.13,69.8 286.13,70.78 286.73,71.37 286.73,72.47 287.54,73.28 287.54,73.5 287.72,73.69 287.72,74 288.21,74.48 288.93,74.48 289.39,74.94 289.39,78.02 288.85,78.56 288.85,81.26 289.54,81.95 289.54,83.21 290.09,83.76 290.79,83.76 292.04,85.01 292.04,86.55 292.79,87.31 292.79,88.36 293.37,88.93 293.37,90.03 294.46,91.12 295.43,91.12 297.26,92.95 v1(297.26,93.43)
  IN4 w0.084: v1(306.69,106.85) 306.69,106.53 307.09,106.13 307.09,105.15 306.71,104.77 306.71,100.58 306.08,99.94 306.08,98.04 v1(306.65,97.47)
  BOTTOM w0.127: v1(306.65,97.47) 306.48,97.3 JANT2.4 ; v1(285.63,67.89) 284.72,67.89 284.32,68.3 282.61,68.3 282.44,68.47 282.04,68.47 281.18,67.62 281.18,65.72 281.43,65.47 JNGFF2.58 ; JANT1.4 306.64,106.9 v1(306.69,106.85)
WWAN_MIPI_ANT_DAT: length 66.8
  TOP w0.127: v1(297.24,94.08) 296.44,94.88 v3(296.13,94.88)
  IN1 w0.084: v1(297.24,94.08) 298.16,95 301.44,95 302.99,96.55 305.07,96.55 306.49,97.97 307.02,97.97 307.16,97.83 v1(307.16,97.8)
  IN2 w0.122: v1(285.63,68.45) 285.65,68.47 285.65,69.57 285.63,69.59 285.63,70.99 286.23,71.58 286.23,72.68 287.03,73.49 287.03,73.71 287.22,73.9 287.22,74.2 287.83,74.81 287.83,75.5 287.98,75.65 287.98,79.29 288.31,79.61 288.31,79.94 288.28,79.96 288.28,81.4 289.04,82.16 289.04,83.42 289.88,84.26 290.58,84.26 291.54,85.21 291.54,86.76 292.29,87.52 292.29,88.57 292.86,89.14 292.86,90.24 294.25,91.62 295.22,91.62 296.74,93.14 296.74,93.58 v1(297.24,94.08)
  IN4 w0.084: v1(307.26,106.84) 307.6,106.5 307.6,104.9 307.28,104.58 307.28,100.2 306.58,99.5 306.58,98.37 v1(307.16,97.8)
  BOTTOM w0.127: v1(307.26,106.84) 306.86,106.45 306.41,106.45 306.3,106.55 JANT1.5 ; v1(285.63,68.45) 284.88,68.45 284.53,68.81 282.82,68.81 282.65,68.98 281.83,68.98 280.68,67.83 280.68,67.41 280.68,67.41 280.68,65.46 280.93,65.21 JNGFF2.56 ; v1(307.16,97.8) 307.21,97.75 307.21,97.3 306.86,96.95 JANT2.5
WWAN_RADIO_DIS#: length 61.4
  TOP w0.127: v1(280.55,100.5) 280.03,100.5 276.55,97.03 276.55,96.41 RE10.1 ; v2(272.44,59.3) 273.09,59.3 v1(273.29,59.5) 273.29,60.06 DZ5.1 ; v1(276.2,86.98) 276.62,86.56 UE1.F12
  IN2 w0.122: v1(276.2,86.98) 275.48,86.98 275.02,87.43 272.93,87.43 272.63,87.14 272.63,86.63 272.6,86.6 272.6,85.73 273.23,85.1 273.23,83.43 273.55,83.12 273.88,83.12 274.23,82.77 274.23,78.7 272.79,77.26 272.79,75.22 273.21,74.8 273.21,72.47 273.76,71.91 273.76,71.5 273.3,71.04 273.3,65.74 274.18,64.86 274.18,60.39 v1(273.29,59.5)
  IN3 w0.122: v1(280.55,100.5) 280.52,100.47 280.52,98.7 280.01,98.2 278.36,98.2 275.33,95.17 275.33,90.6 274.88,90.15 274.88,88.21 276.12,86.98 v1(276.2,86.98)
WWAN_RADIO_DIS#_R: length 9.1
  TOP w0.127: v2(273.91,59.34) 273.75,59.49 273.75,61.72 273.43,62.05 DZ5.2 272.18,62.05 v1(271.97,61.84)
  BOTTOM w0.127: v1(271.97,61.84) 270.87,62.94 269.46,62.94 268.93,63.47 JNGFF2.8
WWAN_WAKE#: length 44.9
  TOP w0.102: UE1.M13 281.7,87.64 v1(281.7,88.08) 281.7,88.18 282.08,88.56 282.08,89.77 RE38.1
  TOP w0.127: v1(272.67,57.99) 272.67,57.99 v2(272.12,57.44)
  IN2 w0.122: v1(272.67,57.99) 273.26,58.58 273.26,58.8 274.41,59.95 274.41,61.19 275.49,62.28 275.49,64.39 274.62,65.26 274.62,67.52 273.65,68.5 273.65,70.31 274.67,71.33 274.67,72.99 274.21,73.46 274.21,74.12 273.01,75.31 273.01,77.17 273.75,77.91 275.47,77.91 275.85,78.29 275.85,81.59 276.04,81.78 276.77,81.78 276.96,81.97 276.96,82.23 277.95,83.22 277.95,84 278.09,84.15 280.55,84.15 280.68,84.27 280.68,86.42 281.7,87.44 v1(281.7,88.08)
  BOTTOM w0.127: JNGFF2.23 272.68,57.98 v1(272.67,57.99)
XCLK_BIASREF: length 6.2
  BOTTOM w0.114: RC402.1 153.04,95.93 v2(153.04,95.19) 153.04,94.86 150.5,92.32 UC1.CJ1
XDP_DBRESET#: length 274.6
  TOP w0.127: v1(60.31,98.15) 60.31,98.59 59.95,98.95 CC326.1 60.03,99.41 RC137.1 ; RC243.1 RC248.1 CC78.1 173.68,89.34 172.92,88.58 v1(172.7,88.58) ; v1(45.69,44.57) v2(45.69,43.67)
  IN2 w0.122: v1(60.31,98.15) 59.51,98.95 57.88,98.95 56.82,97.89 56.82,97.46 56.44,97.08 56.01,97.08 55,96.07 55,94.09 56.71,92.37 56.71,89.31 50.77,83.37 50.77,78.07 46.6,73.91 46.6,65.96 44.3,63.66 44.3,60.22 44.71,59.81 44.71,57.14 v1(45.03,56.83) ; v1(45.69,44.57) 51.86,44.57 53.2,45.92 58.26,45.92 59.1,46.75 59.49,46.75 59.7,46.54 80.07,46.54 83.62,50.08 138.02,50.08 141.04,47.06 145.89,47.06 146.35,46.59 156.06,46.59 158.42,48.95 182.05,48.95 184.29,51.19 184.29,53.66 186.05,55.43 188.59,55.43 190.7,57.53 190.7,58.6 191.31,59.21 v1(191.57,59.21)
  IN4 w0.084: v1(172.7,88.58) 174.19,88.58 175.4,87.36 176.23,87.36 176.74,86.85 176.74,86.15 177,85.89 177.61,85.89 177.69,85.81 177.69,84.84 179.88,82.66 179.88,81.54 183.52,77.9 183.52,77.2 184.72,76 187.1,76 189.52,73.58 189.52,70.03 190.79,68.76 190.79,67.44 192,66.23 192,61.65 191.57,61.22 v1(191.57,59.21) ; v1(45.03,56.83) 44.38,56.18 44.37,56.18 44.15,55.96 44.15,55.95 43.92,55.72 43.92,52.6 43.82,52.51 43.82,49.68 44.07,49.44 44.89,49.44 45.76,48.57 46.93,48.57 47.22,48.29 47.22,45.55 46.24,44.57 v1(45.69,44.57)
  BOTTOM w0.127: v1(60.31,98.15) 60.29,98.17 60.26,98.17 59.78,98.65 JXDP1.48
XDP_JTAGX: length 21.1
  TOP w0.127: RC328.2 104.82,97.06 104.23,96.48 RC87.1 104.15,96.13 104.44,95.84 CC305.1 104.44,95.14 105.86,93.72 v2(105.86,93.03) v1(105.86,92.11)
  IN4 w0.084: v1(105.86,92.11) 105.86,90.29 107,89.15 116.6,89.15 116.77,88.98 116.77,88.6 117.32,88.04 v1(117.32,87.96)
  BOTTOM w0.076: v1(117.32,87.96) 117.18,87.82 UC1.P6
XDP_OBS0: length 4
  TOP w0.127: RC239.2 65.92,97.15 66.3,96.77 v2(67.06,96.77) 67.75,96.77 67.88,96.89 v1(67.88,97.23)
  BOTTOM w0.127: JXDP1.21 v1(67.88,97.23)
XDP_OBS0_R: length 74.3
  TOP w0.127: v1(65.28,100.2) 65.28,99.88 65.92,99.24 RC239.1
  BOTTOM w0.076: 118.64,92.97 118.64,92.77 118.67,92.74 118.67,91.27 UC1.U1
  BOTTOM w0.114: 118.64,92.97 118.64,95.16 118.47,95.34
  BOTTOM w0.127: 118.47,95.34 118.05,95.75 118.05,98.01 117.39,98.67 117.39,99.94 109.15,108.18 102.66,108.18 101.45,109.39 88,109.39 87.69,109.08 84.66,109.08 83.89,109.85 79.79,109.85 76.52,106.58 67.41,106.58 65.69,104.86 65.69,102.19 65.28,101.78 v1(65.28,100.2)
XDP_OBS1: length 2.9
  TOP w0.127: v2(67.6,98.48) 67.11,98 66.81,98 RC240.2 66.9,97.66 67.06,97.66 67.28,97.44 v1(67.28,97.23)
  BOTTOM w0.127: JXDP1.23 v1(67.28,97.23)
XDP_OBS1_R: length 73.7
  TOP w0.127: RC240.1 66.68,99.09 v2(66.42,99.35) 65.87,99.91 v1(65.87,100.19)
  BOTTOM w0.076: UC1.U2 118.77,90.75 118.48,91.04 118.48,92.66 118.44,92.7 118.44,92.93
  BOTTOM w0.114: 118.44,92.93 118.44,94.92 117.78,95.58 117.78,95.62
  BOTTOM w0.127: 117.78,95.62 117.78,97.67 116.96,98.5 116.96,99.76 108.98,107.74 102.48,107.74 101.27,108.96 88.18,108.96 87.87,108.65 84.48,108.65 83.71,109.42 79.97,109.42 76.7,106.15 67.59,106.15 66.14,104.7 66.14,102.03 65.87,101.76 v1(65.87,100.19)
XDP_OBS2_R: length 6.3
  BOTTOM w0.076: 118.85,92.99 118.85,92.83 118.86,92.82 118.86,91.5 119.03,91.32 119.03,91.07 119,90.98 119,90.7 119.03,90.61 119.03,90.42 118.81,89.91 UC1.U3
  BOTTOM w0.114: T366.1 118.85,95.66 118.85,92.99
XDP_OBS3_R: length 6
  BOTTOM w0.076: 119.05,93.02 119.05,91.54 119.2,91.39 119.2,91.05 119.16,90.95 119.16,90.73 119.2,90.63 119.2,90.38 119.05,90.04 119.05,89.73 118.77,89.45 UC1.U4
  BOTTOM w0.114: T367.1 119.05,94.42 119.05,93.02
XDP_PRSNT_PIN1: length 10.4
  TOP w0.127: RC122.1 69.6,96.58 69.64,96.62 RC121.1 70.33,96.62 70.48,96.77 72.27,96.77 v2(73.19,97.69) 73.73,98.23 75.06,98.23 75.25,98.04 v1(75.25,97.4)
  BOTTOM w0.127: JXDP1.1 73.88,96.2 74.01,96.07 74.68,96.07 75.22,96.61 75.22,97.37 v1(75.25,97.4)
XDP_TMS: length 2.7
  TOP w0.127: RC852.2 56.91,101.17 RC735.1 56.92,100.88 57.09,100.7 v1(57.09,100.32)
  BOTTOM w0.127: JXDP1.58 56.78,99.99 57.09,100.3 v1(57.09,100.32)
XTAL24_IN: length 4.7
  BOTTOM w0.104: YC1.3 157.58,95.73 CC21.1 156.6,95.8 155.82,95.8 155.29,96.34 RC59.2 RC728.2
XTAL24_IN_CPU: length 7.4
  BOTTOM w0.076: UC1.CK3 151.38,89.75 150.88,90.24 150.88,91.87 RC728.1
XTAL24_OUT: length 6.8
  BOTTOM w0.104: YC1.1 159.24,93.97 157.23,93.97 157.05,94.15 CC22.1
  BOTTOM w0.127: CC22.1 157.05,94.9 156.7,95.26 155.63,95.26 155.47,95.42 RC59.1 155.26,94.67 RC729.2
XTAL24_OUT_CPU: length 7.4
  BOTTOM w0.076: UC1.CK2 151.19,90.16 151.3,90.05 151.59,90.05 151.67,90.13 151.67,90.37 151.28,90.76 151.28,90.87 151.71,91.29 151.71,91.75 151.4,92.05 151.4,92.16 154.08,94.83 154.19,94.83 RC729.1
XTAL_25_IN: length 5.5
  BOTTOM w0.076: UT1.D22 23.31,72.65 23.31,72.13
  BOTTOM w0.127: RT394.1 21,68.85 21,68.85 21,68.99 21.6,69.59 21.6,70.03 23.31,71.75 23.31,72.13
XTAL_25_IN_R: length 4.2
  BOTTOM w0.104: YT1.1 21.17,64.66 20.38,65.45 20.38,67.21 20.42,67.25 CT21.1 20.42,68.39 20.42,68.4 RT394.2
XTAL_25_OUT: length 6.3
  BOTTOM w0.127: RT40.1 19.02,68.6 19.44,69.02 20.58,69.02 21.22,69.65 21.22,70.1 v2(21.89,70.77) 23.1,71.98 UT1.D23
XTAL_25_OUT_R: length 2.2
  BOTTOM w0.127: RT40.2 CT20.1 19.6,67.4 19.06,66.86 YT1.3
N14048965: length 4.3
  BOTTOM w0.127: v3(23.4,94.49) 23.4,93.85 22.8,93.25 22.8,92.68 21.96,91.84 UT7.3
N15612276: length 2.8
  TOP w0.127: v2(292.06,79.27) 292.27,79.48 RI14.2 293.09,79.44 UI3.16
N15643257: length 4.6
  TOP w0.127: v2(256.48,57.47) 256.91,57.47 257.21,57.18 258.3,57.18 258.72,56.76 CZ109.1 258.72,56.43 258.88,56.27 259.2,56.27 259.79,55.67 UZ43.10
N15644626: length 1.7
  TOP w0.203: UZ3.10 179.78,94.74 179.57,94.94 178.75,94.94 CZ114.1
N15647018: length 3
  TOP w0.127: v2(296.04,23.63) 295.9,23.77 295.01,23.77 CZ121.1 294.38,23.64 UZ8.6
N15655766: length 1.7
  TOP w0.127: UZ47.12 266.93,41.29 267.11,41.12 CZ117.1
N15655998: length 1.6
  TOP w0.127: UZ47.10 266.14,40.81 CZ118.1
N15670126: length 2.7
  TOP w0.127: v2(290.47,57.13) 290.86,56.74 RZ334.1 292.56,56.74 CZ38.2
N15674340: length 3.4
  TOP w0.127: v1(273.68,58.49) 273.42,58.49 v2(273.18,58.25) RZ326.1
  BOTTOM w0.127: JNGFF2.25 273.18,57.99 v1(273.68,58.49)
N16783095: length 2
  TOP w0.127: PR108.1 v2(191.59,92.51)
  TOP w0.254: PC113.2 PR108.1
N16783134: length 2.2
  TOP w0.127: PR117.1 44.75,33.59 v2(45.43,33.59)
  TOP w0.254: PR117.1 44.05,32.89 PC127.2
N16783222: length 1
  TOP w0.127: PC119.1 41.61,29.89 v2(41.74,30.02)
N17370862: length 36.7
  TOP w0.127: v2(77.45,98.66) 78.05,98.06 v1(78.05,97.21)
  TOP w0.254: PQ5.1 75.34,96.02 75.41,95.96 PR16.1 78.43,96.83 v1(78.05,97.21)
  IN3 w0.254: v1(50.51,94.08) 50.98,94.55 62.5,94.55 63.49,93.55 64.99,93.55 68.21,96.77 77.61,96.77 v1(78.05,97.21)
N17370885: length 8.5
  TOP w0.254: PQ5.2 72.71,95.05 v3(72.26,94.6) 70.35,92.69 PR10.2 PR15.1
N17370921: length 2.9
  TOP w0.127: PR15.2 70.61,90.23 v2(70.61,89.92)
  TOP w0.254: PR15.2 69.28,91.04 69.28,91.05 PQ1.6
N17370927: length 4
  TOP w0.127: v3(82.23,95.42) 81.99,95.18 PQ7.1
  TOP w0.254: PR16.2 80.05,95.04 PQ7.1
N17370961: length 28.3
  TOP w0.254: v1(46.06,99.92) 45.55,99.42 PL3.1 ; PR3.1 52.62,84.54 PQ2.1 51.14,83.06 PR6.1 v2(50.58,84.31) 50.58,86.95 52.42,88.78 52.42,89.39 52.14,89.66 50.32,89.66 49.62,90.35 49.62,92.09 49.96,92.42 49.96,93.42 49.7,93.67 49.7,94.82 v1(49.59,94.93)
  BOTTOM w0.254: v1(49.59,94.93) 49.41,95.11 49.41,98.29 48.25,99.45 46.53,99.45 v1(46.06,99.92)
N17370983: length 5.4
  TOP w0.127: PQ2.3 54.6,85.18 v2(56.39,83.38)
  TOP w0.254: PQ2.3 53.53,86.47 PR3.2 53.53,87.61 PR5.1
N17370995: length 3.4
  TOP w0.127: PR8.1 50.4,81.34 v2(49.57,82.16)
  TOP w0.254: PQ3.2 51.47,82.15 PR6.2 PR8.1
N17370999: length 4.8
  TOP w0.127: PQ3.1 53.61,80.57 v2(54.12,80.05)
  TOP w0.254: PQ3.1 54.57,81.26 PR7.2 54.65,83.42 PQ2.2
N17371029: length 9.7
  TOP w0.254: v1(59.87,91.49) 59.95,91.49 60.51,90.93 v2(61.5,90.93) 61.98,90.44 61.98,89.71 61.61,89.34 PQ11.1 60.49,88.66 PR18.1
  BOTTOM w0.254: v1(59.87,91.49) 59.66,91.49 59.25,91.08 PQ9.4 59.01,91.73 59.23,91.94 PC6.2 PR12.2
N17371043: length 2.9
  TOP w0.127: v2(64.75,87.74) 64.29,88.2 PQ6.1
  TOP w0.254: PQ6.1 62.5,88.2 PR18.2
N17371125: length 2.5
  TOP w0.127: PQ7.2 81.92,97.08 v2(82.01,97.17)
  TOP w0.254: PQ7.2 80.84,97.4 81.36,97.92 PR20.1
N17371182: length 2.5
  TOP w0.254: PR22.2 v2(64.32,91.4) 64.29,91.37 PQ6.2
N17372063: length 3.5
  TOP w0.254: PR17.2 65.75,92.55 PR19.2 65.98,92.78 65.98,93.47 66,93.47 66.35,93.82 v2(66.62,93.82) 66.66,93.82 67.09,93.39 PQ1.3
N17372074: length 3.8
  TOP w0.127: v2(65.44,89.2) 65.44,89.66 PR25.1
  TOP w0.254: PR25.1 66.1,89.97 67.25,89.97 67.74,90.46 PQ1.5
N17372283: length 3.7
  TOP w0.127: PQ1.2 67.74,93.27 68.14,93.67 v2(68.14,93.92)
  TOP w0.254: PR19.1 66.22,91.8 66.61,92.18 67.49,92.18 67.74,92.43 PQ1.2
N17538214: length 5
  TOP w0.127: PR31.2 55.56,88.08 v2(54.92,87.45)
  TOP w0.254: PR31.2 56.27,88.08 56.58,88.4 PR32.1 56.99,88.88 PQ11.2
N17539406: length 2.9
  TOP w0.127: PR33.2 53.43,91.28 52.84,90.68 v2(52.46,90.68)
  TOP w0.254: PQ10.5 PQ10.6 53.59,90.44 53.59,91.19 PR33.2
N21875993: length 2.1
  TOP w0.203: UZ3.3 v2(183.46,93.94) 184.19,93.94 RZ64.2
N22005589: length 1.6
  TOP w0.203: CZ113.1 179.58,93.83 179.69,93.94 UZ3.12
N23230799: length 1.9
  TOP w0.127: RA17.2 274.96,37.26 CA33.1 v2(273.89,37.24)
N23230891: length 1.4
  TOP w0.127: CZ127.1 295.26,53.11 295.03,52.87 UZ5.10
N23230909: length 1.6
  TOP w0.127: UZ5.12 294.23,52.68 294.15,52.76 294.15,53.37 CZ126.1
N24411441: length 2.2
  BOTTOM w0.127: RZ63.1 182.52,78.63 182.44,78.71 CZ56.1 182.78,79.1 v2(183.43,79.75)
N24740920: length 3.7
  TOP w0.127: RV18.2 18.87,60.76 v2(20.12,59.51)
  TOP w0.508: RV18.2 17.06,60.81 QV4.2
N24906879: length 1.9
  TOP w0.127: PD700.1 41.61,62.92 v2(40.73,63.79)
N24908379: length 4.2
  TOP w0.254: PR737.2 48.6,65.39 v2(48.6,65.77) 47.71,66.66 46.88,66.66 PD705.2
N24908381: length 2.9
  TOP w0.127: v2(46.35,63.87) 46.53,64.05 PR735.1
  TOP w0.254: PR735.1 47.25,64.83 PR736.2 47.29,65.77 PD705.3
N24908396: length 2.3
  TOP w0.254: PU701.2 44.24,68.33 44,68.57 v2(44,68.94) 44.27,69.21 PR741.2
N24908406: length 4.5
  TOP w0.127: v2(46.11,69.89) 45.71,69.5 PR739.1
  TOP w0.254: PR739.1 45.65,68.93 44.89,68.17 PU701.1 46.79,67.81 PD705.1
N24908424: length 2.2
  TOP w0.127: PR740.1 v2(43.75,63.82)
  TOP w0.381: PU701.4 43.59,65.38 43.75,65.23 PR740.1
N24908981: length 3.4
  TOP w0.127: v1(45.94,47.68) 45.94,47.54 v2(45.5,47.1)
  TOP w0.254: PR728.2 45.5,48.04 45.86,47.68 v1(45.94,47.68)
  BOTTOM w0.254: PC751.1 45.71,48.69 45.94,48.46 v1(45.94,47.68)
N25295845: length 4
  BOTTOM w0.127: QV2.1 v2(97.53,101.78) 96.2,101.78 96.18,101.8 RV5.2
N25300633: length 3.6
  TOP w0.127: RZ388.2 49.4,106.53 v2(48.66,105.8)
  TOP w0.254: RZ388.2 49.78,106.53 50.11,106.86 CZ220.1 51.29,106.86 51.32,106.83 QZ1.2
N25301385: length 6
  TOP w0.127: v2(79.96,106.04) 80.2,106.29 QV7.2
  TOP w0.254: QV7.2 83.5,106.29 83.78,106.57 RV324.2 83.78,107.3 RV323.2 83.78,107.31 RV326.2
N25301415: length 4
  TOP w0.381: QV8.2 77.03,106.79 CV635.1 v2(77.99,105.97) 78.19,105.97 78.56,106.33 RV400.2
N25301447: length 6.3
  TOP w0.254: RV400.1 79.71,107.34 v2(79.92,107.34) 80.03,107.34 80.58,106.79 QV7.1 81.38,106.79 81.39,106.8 83,106.8 83.32,107.12 83.32,108.01 83.02,108.31 RV6.1
N25591846: length 3.6
  TOP w0.254: PR47.2 55.72,95.69 v2(54.86,95.69) 54.55,95.38 PC13.2 54.01,94.71 53.53,94.23 PU3.5
N25591872: length 2
  TOP w0.254: PR45.1 54.56,93.81 PR43.2 54.56,92.98 54.19,92.98 53.81,92.61 PU3.4
N25591876: length 8.3
  TOP w0.127: PR44.2 51.71,99.66 v2(51.23,99.66)
  TOP w0.203: PU3.2 51.81,93.26 52.39,93.85 52.39,94.42 53.16,95.18 53.16,95.19 53.19,95.23 53.19,96.21 53.24,96.35 53.24,97.25 52.63,97.86 PR44.2
N25591912: length 6.2
  TOP w0.254: PQ10.2 54.22,88.77 55.45,90 55.76,90 v2(56.52,90.76) 56.52,91.43 55.78,92.17 PR41.2 PR43.1
N25591942: length 21.3
  TOP w0.127: PR44.1 53.55,99.13 v2(52.58,100.1)
  TOP w0.254: PR44.1 53.55,98.33 53.46,98.24 v1(53.46,97.68) 53.46,97.66 53.84,97.28 PQ8.1 ; v1(64.99,94.55) 64.45,94 63.62,94 63.4,93.78 PR27.1 PR22.1
  IN3 w0.254: v1(53.46,97.68) 53.46,97.43 55.96,94.93 62.61,94.93 63.63,93.91 64.52,93.91 64.99,94.38 v1(64.99,94.55)
N25591952: length 2.8
  TOP w0.254: PR42.2 51.47,91.88 50.97,92.37 50.97,93.43 51.45,93.91 PU3.1
N25709568: length 0.9
  TOP w0.127: RE350.2 CE57.1
N25710703: length 2
  TOP w0.127: QE17.1 274.91,67.3 274.39,67.82 RE546.2
N25852174: length 1.1
  TOP w0.127: RE94.1 263.52,85.3 QE12.1
N25890123: length 2
  TOP w0.127: PC647.1 75.01,59.3 v2(75.39,58.92)
  TOP w0.254: PC647.1 74.17,59.87 PR650.2
N25907811: length 7.7
  TOP w0.127: PC804.1 v2(46.86,72.64)
  TOP w0.254: PC804.1 PR817.1 46.86,74.61 46.5,74.97 PU800.3 46.5,76.84 46.98,77.31 47.97,77.31 48.37,76.92 48.48,76.92 PR805.1 48.67,76.15 48.66,76.14 PR800.2
N25907817: length 6
  TOP w0.127: v2(44.89,72.59) PR815.1
  TOP w0.254: PC800.1 44.83,74.57 44.03,74.57 44.01,74.56 43.99,74.57 43.14,74.57 PR809.2 ; PC800.1 44.86,73.69 PR815.1 ; PC800.1 44.86,74.69 45.28,75.11 45.54,75.11 45.85,75.43 PU800.2
N25907922: length 10.4
  TOP w0.254: PQ803.2 38.34,90.37 v2(38.58,90.61) 39,91.03 39,91.5 39.44,91.94 40.81,91.94 42.06,90.7 PR807.1 PR801.2
N25907924: length 14
  TOP w0.127: v2(41.92,91.6) 42.08,91.43 v1(42.61,91.43)
  TOP w0.254: PR807.2 43.42,90.96 42.95,91.43 v1(42.61,91.43) ; PR858.1 41.76,95.79 42.53,95.79 42.91,96.17 v1(42.91,96.65) 42.91,96.9 43.42,97.41 PQ802.6
  IN4 w0.254: v1(42.61,91.43) 41.73,91.43 41.22,91.94 40.9,91.94 40.01,92.83 40.01,94.67 41.24,95.9 42.53,95.9 42.91,96.29 v1(42.91,96.65)
N25907948: length 3
  TOP w0.254: PR853.2 45.14,94.1 45.66,93.58 45.66,92.18 45.98,91.87 PU801.1
N25907954: length 4.8
  TOP w0.127: PU801.5 43.56,91.87 v2(43.41,91.73)
  TOP w0.254: PU801.5 44.98,91.87 45.29,91.55 PC814.2 PR859.2 46.16,90.16 PR860.2
N25907966: length 2.6
  TOP w0.127: PR818.2 v2(34.37,98.36)
  TOP w0.254: PR818.2 35.99,97.39 PQ804.2
N25907978: length 27.6
  TOP w0.254: PR818.1 37.26,98.71 37.85,98.71 37.86,98.72 38.11,98.72 v2(38.81,99.43) 39.83,100.44 PQ807.1 40.41,101.29 v1(40.74,101.63) 40.74,102.13 40.45,102.42 PR822.1 ; v1(48.14,102.8) 48.82,102.11 48.82,95.67 48.51,95.36 48.51,94.43 48.74,94.21 48.74,92.72 48.43,92.41 PR854.1
  IN3 w0.254: v1(40.74,101.63) 41.34,102.23 43,102.23 43.88,103.12 45.78,103.12 46.37,102.52 47.86,102.52 v1(48.14,102.8)
N25907980: length 3.9
  TOP w0.254: PQ802.5 42.77,97.91 42.98,98.13 43.64,98.13 43.95,97.82 43.95,97.24 43.54,96.83 PR856.1 PR857.2
N25907988: length 3.6
  TOP w0.254: PR856.2 43.21,95.38 43.21,93.85 PR855.1 43.89,93.17 PU801.4
N25908000: length 3.1
  TOP w0.127: v2(48.61,91.78) 48.33,91.5 PR854.2
  TOP w0.254: PR854.2 47.22,91.5 47.06,91.66 47.06,92.26 46.8,92.52 PU801.2
N25908024: length 9.8
  TOP w0.127: PR831.2 47.57,83.71 v2(47.82,83.97)
  TOP w0.254: PQ813.6 46.56,83.96 PR831.2 46.81,83.09 PD802.1 ; PU800.5 47.15,81.62 47.44,81.91 PD802.1 ; PD802.1 48.35,82.45 48.55,82.25 PC811.1 PR842.1 PR870.2
N25908041: length 7.4
  TOP w0.254: PU800.7 45.85,81.98 45.37,82.45 PD802.2 44.86,82.26 43.92,82.26 v2(43.64,82.54) 43.9,82.8 43.9,83.37 43.43,83.84 PC813.1 43.27,83.86 PR840.1 PR835.2
N25908049: length 7.6
  TOP w0.127: v2(42.97,77.63) 42.89,77.71 42.89,78.18 PR843.1
  TOP w0.254: PU800.6 46.5,80.52 46.49,80.51 46.49,79.43 45.95,78.89 44.04,78.89 43.76,78.61 PR843.1 PC812.1 PR832.2
N25908061: length 3.6
  TOP w0.254: PQ813.5 45.07,84.35 44.14,85.27 42.94,85.27 PR840.2
N25908120: length 2.7
  TOP w0.254: PQ804.6 36.63,95.2 36.87,94.95 v2(37.75,94.95) 38.15,94.55 PR811.2
N25908122: length 22.9
  TOP w0.127: v2(39.13,93.52) 39.13,93.28 v1(38.87,93.01)
  TOP w0.254: PR811.1 v1(38.87,93.01) ; v1(44.02,89.26) 42.98,89.26 42.86,89.39 40.95,89.39 40.88,89.32 39.56,89.32 39.31,89.06 PQ803.1
  IN2 w0.254: v1(44.02,89.26) 43.48,89.26 40.61,92.13 39.74,92.13 v1(38.87,93.01)
  BOTTOM w0.254: PQ800.4 42.73,83.8 42.87,83.94 43.38,83.94 43.58,84.14 44.54,84.14 44.94,84.54 PR803.2 PC803.2 46.01,86.99 46.01,88.16 44.91,89.26 v1(44.02,89.26)
N25908132: length 3
  TOP w0.127: v2(45.93,86.81) 45.5,86.38 44.94,86.38 PQ813.3
  TOP w0.254: PR836.1 43.54,85.86 PQ813.3
N25908138: length 65.6
  TOP w0.254: PR808.1 47.34,93.5 47.06,93.78 v1(46.74,93.78) ; v1(39.77,82.86) 39.87,82.77 39.87,81.23 40.38,80.71 40.38,73.54 v3(41.01,72.91) 42.46,71.46 46.48,71.46 46.54,71.39 48.88,71.39 49.93,72.44 49.93,75.03 v1(49.74,75.22) ; PQ805.2 35.84,89.38 v1(35.31,89.91)
  IN2 w0.254: v1(39.77,82.86) 39.77,83.92 38.79,84.91 37.83,84.91 36.04,86.7 36.04,88.13 35.78,88.39 34.69,88.39 34.22,88.85 34.22,89.64 34.49,89.91 v1(35.31,89.91) 35.31,93.15 34.72,93.75 34.72,98.09 v1(33.38,99.42)
  IN3 w0.254: v1(33.38,99.42) 33.84,99.42 35.79,97.47 35.79,95.42 36.79,94.42 46.17,94.42 46.74,93.85 v1(46.74,93.78)
  BOTTOM w0.254: PR802.2 49.74,76.03 v1(49.74,75.22)
N25908140: length 3.1
  TOP w0.254: PR808.2 48.25,94.14 48.15,94.24 48.15,95.75 48.08,95.83 PQ806.3
N25908152: length 42.6
  TOP w0.127: v1(47.71,76.54) 48.22,76.04 48.22,75.5 v2(48.79,74.92)
  TOP w0.254: PQ805.1 33.76,89.4 34.01,89.15 34.61,89.15 v1(34.68,89.08) ; PR812.1 34.56,94.82 v1(35.21,94.82)
  IN2 w0.254: v1(35.21,94.82) 35.82,94.22 35.82,89.72 35.19,89.08 v1(34.68,89.08)
  IN3 w0.254: v1(35.21,94.82) 35.85,94.82 36.62,94.05 43.17,94.05 45.88,91.35 45.88,89.19 48.96,86.1 48.96,77.62 47.89,76.54 v1(47.71,76.54)
  BOTTOM w0.254: PC802.2 49.24,76.5 PR804.2 47.76,76.5 v1(47.71,76.54) PQ801.4
N25908168: length 12.8
  TOP w0.254: PR813.2 43.37,103.88 PR852.2 v1(42.85,104.07) ; v1(47.39,103.13) 47.39,100.59 46.51,99.71 PR814.2 46.51,98.66 46.78,98.4 PQ806.6
  IN3 w0.254: v1(42.85,104.07) 46.45,104.07 v1(47.39,103.13)
  BOTTOM w0.127: v1(42.85,104.07) v2(42.23,104.07)
N25908188: length 4.2
  TOP w0.127: PR812.2 33.85,95.54 v2(33.85,94.05)
  TOP w0.254: PQ804.3 35.33,97.04 35.09,96.8 34.58,96.8 34.31,96.53 PR812.2
N25908210: length 1.9
  TOP w0.127: PR814.1 v2(48.41,99.07)
  TOP w0.254: PQ806.5 PR814.1
N25908220: length 4.4
  TOP w0.254: PQ806.2 47.43,96.02 47.04,95.63 46.51,95.63 45.84,96.3 45.23,96.3 44.84,95.9 PR820.1
N25908319: length 3.3
  TOP w0.254: PQ804.5 35.98,94.91 v2(35.62,94.55) 35.73,94.43 37.19,94.43 37.33,94.29 PR816.2
N25908329: length 3.6
  TOP w0.254: PR825.2 PR826.2 33.47,104.67 33.03,104.22 v2(33.03,104.12) 33.03,103.63 33.49,103.16 PQ810.5
N25908331: length 3.9
  TOP w0.127: PR841.1 37.86,99.65 v2(37.42,99.21)
  TOP w0.254: PQ808.5 37.63,101.86 PR834.2 37.03,100.92 37.24,100.92 37.36,100.8 37.36,100.72 37.37,100.71 37.37,100.65 PR841.1
N25908337: length 10.4
  TOP w0.127: v2(38.86,100.83) 38.61,101.07 PR841.2
  TOP w0.254: PQ810.1 36.29,102.51 36.65,102.86 38.11,102.86 v1(38.16,102.81) 38.28,102.69 PQ808.6 38.28,101.49 PR841.2 ; PR830.2 v1(37.79,106.74)
  BOTTOM w0.254: v1(37.79,106.74) 37.98,106.55 37.98,102.99 v1(38.16,102.81)
N25908347: length 6.7
  TOP w0.254: 37.63,103.6 37.45,103.42 37.1,103.42 36.98,103.53 PQ808.3 ; 37.63,103.6 37.86,103.37 38.79,103.37 39.46,104.05 v2(39.46,104.2) 39.46,104.48 41.03,106.04 PR833.2 ; 37.63,103.6 PQ808.2
N25908367: length 2.1
  TOP w0.127: v2(54.03,106.08) 53.71,106.08 53.64,106 53.48,106 53.43,105.95 PR829.2
  TOP w0.254: PR829.2 53,105.93 53,105.59 53.19,105.4 PQ811.5
N25908379: length 7.3
  TOP w0.127: PR827.2 35.62,101.17 35.73,101.06 v2(35.73,99.33)
  TOP w0.254: PR824.2 36.96,104.71 36.46,104.2 36.46,103.31 36.31,103.16 PQ810.2 35.48,103.16 35.25,102.93 35.25,101.21 PR827.2
N25908405: length 14.9
  TOP w0.127: v2(45.15,105) 45.15,105.58 44.92,105.82 PQ809.6
  TOP w0.254: v1(40.01,104.32) 40.58,103.75 41.98,103.75 42.18,103.96 PR845.2 42.32,104.53 43.9,104.53 44.6,105.23 PQ809.6 ; PR838.2 36.14,104.83 v1(35.76,104.45) 35.25,104.45 34.61,103.81 PQ810.4
  IN1 w0.254: v1(40.01,104.32) 39.56,104.77 36.07,104.77 v1(35.76,104.45)
N25908421: length 2.6
  TOP w0.254: PR844.2 42.47,104.92 v2(43.62,104.92) 43.95,105.25 PQ809.5
N25908431: length 5.4
  TOP w0.254: PR839.2 41.73,107.32 41.73,107.72 v2(42.13,108.12) 42.68,108.67 43.05,108.67 43.3,108.41 PQ809.3 43.3,107.32 43.48,107.14 43.84,107.14 43.95,107.25 43.95,107.71 PQ809.2
N26019067: length 3.6
  TOP w0.127: UZ35.1 153.21,109.49 153.33,109.36 153.97,109.36 153.97,109.37 RZ1420.2 154.31,109.36 154.75,109.36 RZ1422.1 v2(156.13,109.03)
N26019799: length 15.9
  TOP w0.127: RC425.1 133.8,96.77 133.63,96.94 v1(133.21,96.94)
  IN1 w0.076: v1(136.71,87.4) 136.27,86.96 136.27,86.71 135.94,86.38 135.64,86.38 135.41,86.61 135.41,89.21 135.46,89.26 135.46,89.56
  IN1 w0.15: 135.46,89.56 132.27,92.74 132.27,96.22 132.99,96.94 v1(133.21,96.94)
  BOTTOM w0.2: UC1.BE7 v1(136.71,87.4)
N26019801: length 18.4
  TOP w0.127: RC426.1 133.78,97.47 133.77,97.46 v1(133.42,97.46) v2(132.9,97.46)
  IN1 w0.076: 135.02,89.51 135.24,89.29 135.24,86.54 135.57,86.21 136.93,86.21 137.1,86.38 137.1,87.12 137.39,87.4 v1(137.63,87.4)
  IN1 w0.15: v1(133.42,97.46) 133.31,97.34 133.04,97.34 132.02,96.32 132.02,92.51 135.02,89.51
  BOTTOM w0.25: UC1.BG7 v1(137.63,87.4)
N26021766: length 4.2
  TOP w0.127: v2(172.27,64.18) 172.43,64.02 QC7.2 173.24,63.2 RC432.2 174.18,63.29 CC340.1 174.2,63 173.69,62.49 RC433.1
N26021852: length 4
  TOP w0.127: RC433.2 174.12,61.57 174.97,60.73 QC6.1 174.97,59.81 174.52,59.35 v2(174.05,59.35)
N26022763: length 1.5
  TOP w0.127: CC77.1 v2(169.72,78.71)
  TOP w0.381: RC845.2 CC77.1
N26125245: length 4.5
  BOTTOM w0.127: v2(35.57,40.24) PR956.1
  BOTTOM w0.254: PR956.1 36.77,39.62 37.81,38.58 WC1.7
N26168283: length 2.7
  TOP w0.127: PQ12.1 56.84,93 v2(56.46,92.62)
  TOP w0.254: PQ12.1 57.98,92.5 PR46.2
N26168409: length 1.8
  TOP w0.203: PQ12.2 58.74,95.51 PR49.1
N26168635: length 3.1
  TOP w0.127: v2(39.17,97.91) 39.31,97.91 39.97,97.25 PQ814.1
  TOP w0.254: PR858.2 40.44,96.58 PQ814.1
N26172409: length 4.4
  TOP w0.127: v2(37.79,96.27) 38.23,96.72 PR861.1
  TOP w0.254: PR861.1 39.06,97.33 39.39,97 39.39,95.88 39.32,95.82 PQ814.2
N26262634: length 1.1
  TOP w0.127: T353.1 118.72,74.16 v1(118.41,73.85)
  BOTTOM w0.089: UC1.V28 v1(118.41,73.85)
N26262636: length 1.1
  TOP w0.127: v1(118.41,73.22) 118.8,72.83 T354.1
  BOTTOM w0.089: UC1.V29 v1(118.41,73.22)
N26268119: length 2
  TOP w0.127: CC1453.1 RC299.2 188.51,63.86 v2(187.8,63.86)
N26268121: length 2
  BOTTOM w0.127: CC1452.1 193.16,73 193.12,73.04 RC289.2 v2(192.04,73.07)
N26281421: length 8.6
  BOTTOM w0.127: UC1.F37 112.26,68.5 110.61,66.85 108.56,66.85 107.51,65.81 105.4,65.81 T16.1
N26281423: length 9.4
  BOTTOM w0.127: UC1.F34 112.3,69.9 111.89,69.49 111.76,69.49 111.21,68.94 110.96,68.94 110.77,68.75 110.77,68.1 110.69,68.02 110.69,68.02 110.39,67.72 109.32,67.72 108.34,68.69 105.09,68.69 T17.1
N26281433: length 3.9
  TOP w0.127: v1(155.9,68.07) 155.95,68.13 T18.1
  BOTTOM w0.089: 155.35,68.07 155.33,68.07 154.08,69.32 153.81,69.32 153.81,69.31 153.47,69.31 UC1.CP36
  BOTTOM w0.127: v1(155.9,68.07) 155.83,68 155.42,68 155.35,68.07
N26281435: length 5.7
  TOP w0.127: v1(156.81,67.16) 156.82,67.15 T19.1
  BOTTOM w0.076: UC1.CN36 152.97,68.86 153.61,68.86 153.62,68.85 153.8,68.67 153.8,68.66 153.82,68.65
  BOTTOM w0.114: 153.82,68.65 155.31,67.16 v1(156.81,67.16)
N26281437: length 4
  BOTTOM w0.127: T20.1 139.86,67.22 139.54,67.54 139.54,69.81 UC1.BK34
N26281439: length 1.1
  TOP w0.127: v1(142.39,81.16) 142.04,81.51 142.04,81.52 T21.1
  BOTTOM w0.076: v1(142.39,81.16) 142.39,81.16 142.07,80.83 UC1.BR18
N26281489: length 5.7
  BOTTOM w0.076: UC1.CR4 154.31,89.41 154.88,89.97 156.53,89.97 157.11,90.54 157.11,90.93 157.47,91.29
  BOTTOM w0.127: T360.1 157.74,91.56 157.47,91.29
N26643986: length 2
  TOP w0.127: T50.1 100.16,29.37 v1(99.71,29.83)
  BOTTOM w0.107: v1(99.71,29.83) JDIMM1.162
N26644006: length 6.2
  TOP w0.127: T51.1 101.01,36.6 v1(100.18,37.43)
  BOTTOM w0.127: JDIMM1.165 100.45,37.71 v1(100.18,37.43)
N26671961: length 2.5
  TOP w0.127: CD31.2 RD18.1 v2(104.87,28.19)
N26693933: length 2.4
  TOP w0.127: RD31.1 167.72,28.58 v2(167.16,28.02)
  TOP w0.254: CD62.2 RD31.1
N26707415: length 3.4
  TOP w0.127: PC865.1 50.87,98.04 v2(50.49,98.42)
  TOP w0.254: PQ8.2 51.29,97.39 PC865.1 PR865.1
N26732492: length 10.6
  TOP w0.127: T54.1 179.98,38.81 178.89,37.71 178.89,34.86 178,33.97 176.7,33.97 v1(176.62,33.89)
  BOTTOM w0.102: JDIMM2.162 176.91,31.96
  BOTTOM w0.127: 176.91,31.96 176.91,33.6 v1(176.62,33.89)
N26732518: length 3.6
  TOP w0.127: v1(178.14,37.22) 178.14,38.57 T55.1
  BOTTOM w0.107: JDIMM2.165 177.66,39.23 177.66,38.16 178.14,37.67 v1(178.14,37.22)
N26884945: length 7.4
  TOP w0.127: v1(142.01,63.11) 141.31,62.41 RC848.2
  BOTTOM w0.076: UC1.BP36 141.7,67.19 142.56,66.33 142.56,63.67 v1(142.01,63.11)
N26942341: length 1.6
  TOP w0.203: CA35.1 283.98,44.76 283.95,44.74 283.95,44.7 283.12,43.87 UA1.38
N26942651: length 8.2
  TOP w0.127: v2(287.8,48.29) 287.2,48.29 RA44.1
  TOP w0.203: RA44.1 286.47,47.56 CA51.1 284.98,46.91 284.13,46.91 283.48,46.26 283.48,44.66 282.72,43.9 UA1.39
N26943364: length 6.4
  TOP w0.203: UA1.32 285.24,41.04 285.55,41.36 286.29,41.36 286.39,41.46 v2(289.06,41.46) 289.76,40.76 CA25.1
N26945044: length 7.6
  TOP w0.127: v2(284.6,34.69) 284.77,34.86 v1(285.11,34.86)
  TOP w0.203: UA1.21 282.32,36.57 282.38,36.51 282.38,36.46 v1(282.58,36.25)
  TOP w0.254: v1(285.11,34.86) 285.12,34.86 285.25,34.73 CA52.1
  IN1 w0.254: v1(285.11,34.86) 284.54,35.43 283.33,35.43 282.58,36.18 v1(282.58,36.25)
N26945786: length 2.9
  TOP w0.203: UA1.19 v2(281.52,36.21) 281.52,35.65 CA53.1
N26948154: length 3.2
  TOP w0.203: RA54.1 286.31,42.28 286.31,42.09 RA53.1 285.96,41.71 v2(285.44,41.71) 285.37,41.71 285.1,41.44 UA1.33
N27268572: length 4.4
  BOTTOM w0.076: UC1.BP34 141.47,69.93 141.47,69.72 141.42,69.61 141.42,69.41 141.46,69.31 141.46,69.06 141.41,68.94 141.41,68.78 141.46,68.66 141.46,67.2 141.95,66.71 141.95,66.49 T361.1
N27268574: length 3.8
  BOTTOM w0.076: UC1.BP35 141.7,69.26 141.95,69.01 141.95,68.77 141.93,68.72 141.93,67.25 T363.1
N27268584: length 6.1
  BOTTOM w0.076: UC1.A34 109.31,70.29 106.98,70.29 106.39,69.7 105.33,69.7 104.84,70.19 T364.1
N27268586: length 6.9
  BOTTOM w0.076: UC1.B35 109.94,69.81 109.79,69.97 107.28,69.97 106.77,69.45 104.38,69.45
  BOTTOM w0.127: T365.1 104.15,69.45 104.38,69.45
N27268596: length 43
  TOP w0.127: RC563.1 91.36,65.71 v1(91.36,65.18) 91.36,64.47 v2(91.31,64.41)
  IN2 w0.089: 108.29,67.3 109.92,67.3 111.89,69.27 124.02,69.27 124.47,69.72 124.47,70.1 125.23,70.86 125.23,74.16 125.56,74.49 v1(125.71,74.49)
  IN2 w0.122: v1(91.36,65.18) 91.39,65.21 101.29,65.21 103.38,67.3 108.29,67.3
  BOTTOM w0.2: UC1.AH26 v1(125.71,74.49)
N27268606: length 44
  TOP w0.127: v1(92.72,67.18) 92.65,67.24 v2(92.11,67.24) 91.42,67.24 RC564.1
  IN2 w0.089: 123.77,75.05 123.51,74.79 123.51,70.16 122.94,69.59 111.96,69.59 109.9,67.53 108.29,67.53
  IN2 w0.102: 123.77,75.05 126.06,75.05 v1(126.62,74.49)
  IN2 w0.122: 108.29,67.53 103.1,67.53 101.02,65.45 96.55,65.45 94.83,67.18 v1(92.72,67.18)
  BOTTOM w0.2: UC1.AJ27 v1(126.62,74.49)
N27268608: length 2.3
  TOP w0.127: RC564.2 RC436.2 89.77,65.51 v2(89.48,65.22)
N27268619: length 27.5
  TOP w0.127: v1(90.79,65.17) 90.46,65.17 89.54,64.26 v2(89.54,63.27)
  IN2 w0.089: 105.03,69.85 105.39,70.21 v1(106.26,70.21)
  IN2 w0.122: v1(90.79,65.17) 90.79,66.51 92.14,67.86 95.48,67.86 97.31,66.03 101.21,66.03 105.03,69.85
  BOTTOM w0.076: UC1.C34 110.45,70.45 110.34,70.34 110.34,70.33 110.17,70.16 109.93,70.16 109.86,70.16 109.61,70.41 109.44,70.59 109.19,70.59 109.08,70.47 106.35,70.47 106.26,70.39 v1(106.26,70.21)
N27386991: length 2.4
  BOTTOM w0.076: 27.9,60.64 28.01,60.64 28.01,60.64 28.04,60.64 28.22,60.45 28.22,60.42 28.41,60.24 28.47,60.24 29.02,60.24 UT5.K9
  BOTTOM w0.127: 27.9,60.64 27.84,60.7 27.64,60.7 27.58,60.76 RT104.1
N27386997: length 1.8
  BOTTOM w0.076: 28.33,61.64 28.5,61.48 28.5,61.26 UT5.L11
  BOTTOM w0.102: 28.2,61.78 28.33,61.64
  BOTTOM w0.127: RT103.2 28.2,62.23 28.2,61.78
N27387070: length 32.4
  TOP w0.127: v1(38.36,50.67) 37.53,50.67 36.3,49.44 RT98.1 32.49,49.44 v2(32.06,49.87)
  IN3 w0.122: v1(38.36,50.67) 37.41,51.62 37.41,52.57 38.8,53.97 38.8,54.54 35.79,57.56 35.79,63.34 35.6,63.53 35.6,64.23 35.21,64.61 32.58,64.61 v1(32.51,64.54)
  BOTTOM w0.076: UT5.F10 31.02,60.74 31.02,61.64
  BOTTOM w0.127: v1(32.51,64.54) 32.19,64.85 30.99,64.85 30.84,64.7 RT97.2 RT99.2 30.84,61.82 31.02,61.64
N27387074: length 2.4
  TOP w0.089: v2(32.26,58.59) 32.71,58.14 v1(32.74,58.14) 32.85,58.14 33.28,58.58 RT101.1
  BOTTOM w0.076: v1(32.74,58.14) 32.61,58.14 UT5.D6
N27387147: length 5.1
  BOTTOM w0.127: v2(31.95,51.71) 31.64,52.01 31.64,53.07 31.79,53.22 32.02,53.22 RT63.1 31.43,54.09 31.43,54.49 31.39,54.53 31.39,55.87 UT5.F1
N27387895: length 2.2
  TOP w0.089: v2(30.45,59.09) 30.09,58.73 v1(29.8,58.73)
  TOP w0.127: CT87.1 29.3,58.73 v1(29.8,58.73)
  BOTTOM w0.076: v1(29.8,58.73) 30.01,58.73 UT5.H7
N27388296: length 2.8
  BOTTOM w0.076: 28.02,61.64 28.33,61.34 28.33,61.08 28.67,60.74 29.02,60.74 UT5.K10
  BOTTOM w0.102: 27.75,61.65 27.76,61.64 28.02,61.64
  BOTTOM w0.127: 27.75,61.65 27.54,61.65 27.51,61.68 RT105.1
N27393275: length 2.6
  TOP w0.127: v2(21.37,45) 22.27,45.9 RT492.2 22.47,46.09 22.89,45.67 UT34.1
N27393279: length 2.8
  TOP w0.127: v2(21.84,43.52) 21.84,44.81 22.02,44.99 RT493.2 22.56,44.99 22.6,45.02 UT34.2
N27393450: length 3.2
  BOTTOM w0.127: UT32.1 40.69,64.19 40.65,64.14 RT445.2 RT456.2 v2(42.41,63.79)
N27393452: length 3.3
  BOTTOM w0.127: v2(38.26,62.43) 38.53,62.69 38.53,63.13 39.19,63.79 RT448.2 39.25,64.14 39.39,64.28 UT32.3
N27807641: length 3.5
  TOP w0.127: LV1.1 67.22,108.62 v2(66.48,109.37) 65.98,109.86 v1(65.98,110.41)
  BOTTOM w0.127: JEDP1.21 65.43,110.96 v1(65.98,110.41)
N27807832: length 3.4
  TOP w0.127: v3(62.76,112.35) 62.35,111.94 RZ1470.1 62.35,110.93 v1(62.89,110.38)
  BOTTOM w0.127: JEDP1.14 62.63,110.65 v1(62.89,110.38)
N28655281: length 6.9
  TOP w0.127: v2(303.71,105.91) 303.82,106.01 RZ1460.2 305.35,106.01 v1(305.44,106.1)
  BOTTOM w0.127: v1(305.44,106.1) 305.2,106.34 304.37,106.34 303.9,106.81 303.9,107.84 304.11,108.05 305.67,108.05 305.77,107.95 JANT1.1
N28655336: length 7.9
  TOP w0.127: v2(304.86,94.58) 304.72,94.72 v1(303.82,94.72) RZ1461.2
  BOTTOM w0.127: v1(303.82,94.72) 303.45,95.09 303.45,97.94 303.96,98.44 305.53,98.44 305.62,98.35 JANT2.1
N28690314: length 2.4
  BOTTOM w0.127: v2(301.07,29.25) 301.76,28.57 RC222.1 301.86,28.17 SW1.1
N28742748: length 3.1
  TOP w0.127: v2(23.7,35.26) 23.28,34.84 23.28,33.91 CZ306.1 23.78,33.41 UZ53.6
N28821883: length 4.8
  BOTTOM w0.127: v2(174.5,99.57) 174.07,99.57 173.85,99.8 QE11.3 172.77,99.8 171.95,98.98 RE90.2 RE70.1
N28821903: length 3
  BOTTOM w0.127: RE70.2 172.88,97.13 QE4.2 v2(174.51,95.74)
N28822790: length 4.5
  TOP w0.127: DV11.1 70.03,102.69 RV626.1 CV633.1 72.4,103.49 RV627.2 71.82,104.48 v2(71.76,104.48)
N28822814: length 4.8
  TOP w0.127: v2(87.24,105.72) 87.66,105.3 DV12.1 88.19,104.58 88.65,105.04 CV651.1 RV629.1 RV631.2
N28822851: length 5.2
  TOP w0.127: RV630.1 v2(92.53,102.14) 92.53,102.55 93.41,103.44 QV20.1
N28822863: length 5.9
  TOP w0.127: v2(93.48,107.91) 92.45,106.88 QV20.2 91.2,103.92 RV631.1
N28822977: length 4
  TOP w0.127: v2(78.42,104.64) 78.42,104.38 77.9,103.87 RV625.1
  TOP w0.508: RV625.1 75.3,103.87 QV18.1
N28823001: length 3.8
  TOP w0.127: v2(74.43,100.15) 74.05,100.52 QV18.2
  TOP w0.508: RV627.1 72.88,102.77 73.59,102.06 QV18.2
N28926400: length 3
  BOTTOM w0.127: QZ3.1 306.72,9.77 RZ25.1 v2(308.86,9.77)
N29074842: length 1.8
  TOP w0.127: v2(197.03,109.71) 196.94,109.62 PR308.1
  TOP w0.254: PC307.2 196.1,110.4 PR308.1
N29161342: length 19.2
  IN4 w0.254: v1(194.01,109.86) 193.15,109 187.86,109 183.3,104.44 181.48,104.44 180.79,105.12 v1(180.57,105.12)
  BOTTOM w0.254: v1(194.01,109.86) 194.68,109.86 195.21,109.34 PR314.2 ; v1(180.57,105.12) 181.02,105.57 PU501.5
N29161603: length 12.8
  TOP w0.127: PU402.4 185.82,28.28 185.97,28.43 v1(185.97,28.68) ; v2(195.24,29.31) v1(195.24,29.85) 194.81,30.28 PR315.1
  IN4 w0.084: v1(185.97,28.68) 187.59,30.3 191.31,30.3 191.44,30.42 194.67,30.42 v1(195.24,29.85)
N29478750: length 1.6
  BOTTOM w0.508: PR892.1 61.58,91.84 PD803.2
N29478753: length 2.6
  BOTTOM w0.508: PR893.1 59.73,94.28 60.28,93.73 PD803.3
N29559724: length 1.2
  BOTTOM w0.254: PU3000.1 51.64,61.11 52.01,61.47 PR3012.1
N29559810: length 1.1
  BOTTOM w0.254: PU3000.7 51.23,62.62 51.66,63.05 PR3013.1
N29694776: length 7.3
  BOTTOM w0.127: PC3003.2 49.32,56.61 49.62,56.31 49.62,55.96 v2(48.99,55.33)
  BOTTOM w0.254: PC3003.2 49.12,56.91 49.06,56.91 PR3005.2 49.06,57.56 48.72,57.9 PR3004.2 48.72,58.9 49.59,59.76 PD3001.1 49.94,60.42 50.23,60.71 PU3000.3
N29694837: length 8.3
  BOTTOM w0.127: v2(46.56,65.46) PR3007.2
  BOTTOM w0.203: PU3000.6 50.73,62.56 50.44,62.85 49.16,62.85 48.71,63.29 48.23,63.29 PR3008.2
  BOTTOM w0.254: PR3007.2 45.35,65.26 PC3004.2 45.41,64.7 46.82,64.7 PR3008.2
N29694873: length 7.5
  TOP w0.127: v1(49.52,62.33) v2(49.52,63.46)
  BOTTOM w0.254: PC3005.1 PR3011.1 47.57,62.41 47.71,62.56 PD3002.1 ; PU3000.5 v1(49.52,62.33) 48.96,62.33 48.73,62.56 PD3002.1 ; PD3002.1 48.34,62.06 48.95,61.45 PR3010.1 PR3009.1
N29694885: length 4.4
  BOTTOM w0.127: PD3000.1 v2(42.34,68)
  BOTTOM w0.254: PD3000.1 43.88,68 44.63,67.25 PR3006.2 PR3007.1
N29695031: length 12.3
  BOTTOM w0.254: PR3001.1 49.32,51.86 49.9,51.28 v2(50.44,51.28) 51.05,51.28 52.86,53.09 PQ3000.3 51.99,57.21 51.67,57.52 51.67,58.19 51.35,58.51 PQ3000.6
N29695162: length 6.1
  TOP w0.254: v1(50.73,60.17) 51.07,59.82 52.86,59.82 53.18,60.14 v1(53.18,60.33)
  BOTTOM w0.254: v1(53.18,60.33) 53.04,60.47 PR3002.2 53.8,61.02 PR3003.2 54.46,61 PC3001.2 ; PU3000.2 v1(50.73,60.17)
N30613280: length 1.9
  TOP w0.127: T423.1 153.98,69.95 153.98,69.95 v1(154.57,69.35)
  BOTTOM w0.076: v1(154.57,69.35) 154.28,69.64 UC1.CR35
N39469818: length 2.7
  TOP w0.127: PC631.1 v2(71.52,68.6)
  TOP w0.254: PR630.2 71.21,67.42 PC631.1
N39470129: length 2
  TOP w0.127: PC640.1 67.5,68.28 v2(67.3,68.47)
  TOP w0.203: PC640.1 67.5,66.58 PR646.2
N39470145: length 2
  TOP w0.127: PC601.1 68.41,68.25 v2(68.6,68.43)
  TOP w0.203: PC601.1 PR652.2
N39470173: length 2.2
  TOP w0.127: v2(63.06,67.3) 62.64,66.89 PC632.2
  TOP w0.203: PR641.1 62,67.63 PC632.2
N39470189: length 5
  TOP w0.127: PR642.2 90.63,88.68 v2(88.95,90.36)
  TOP w0.254: PR642.2 90.63,87.7 90.24,87.31 v1(89.92,87.31)
  BOTTOM w0.254: v1(89.92,87.31) 90.21,87.02 PH604.1
N46814682: length 54.5
  TOP w0.127: v1(74.83,93.89) 75.01,93.89 v2(75.47,93.43)
  TOP w0.254: PR610.1 62.46,52.93 PR631.2 v1(62.54,52.24)
  IN1 w0.254: v1(74.83,93.89) 74.65,94.07 70.08,94.07 69.16,93.15 69.16,70.86 68.65,70.35 68.65,67.75 69.67,66.73 69.67,62.35 69.22,61.91 69.22,57.4 68.08,56.25 66.55,56.25 v1(62.54,52.24)
  BOTTOM w0.254: PH601.2 v1(74.83,93.89)
N46814700: length 2.1
  TOP w0.127: PC627.1 v2(75,51.66)
  TOP w0.254: PR632.2 72.92,51.66 PC627.1
N46814728: length 3.1
  TOP w0.127: v2(82.18,87.09) 82.35,86.91 82.35,86.34 PR628.2
  TOP w0.254: v1(81.4,85.85) 81.62,86.06 PR628.2
  BOTTOM w0.254: v1(81.4,85.85) 81.77,85.85 PH602.1
N46814769: length 2
  TOP w0.127: v2(66.62,50.71) 66.83,50.92 PC617.2
  TOP w0.254: PC617.2 66.07,51.82 PR621.1
N46815164: length 4.7
  TOP w0.127: v2(65.79,49.64) 64.6,50.83 64.6,52.15 PC621.2
  TOP w0.254: PC621.2 65.14,52.71 PR623.1
N46815188: length 0.9
  TOP w0.254: PR617.1 63.28,52.91 PC614.2
N46816463: length 2.6
  TOP w0.127: v2(76.66,57.69) 76.36,57.99 PC629.2
  TOP w0.254: PC629.2 74.33,57.99 PR639.1
N46816511: length 13.9
  TOP w0.254: v1(78.81,65.78) 79.39,65.2 v2(79.39,63.37) 79.39,59.42 76.14,56.18 PR647.2 74.23,56.18 PR635.1
  BOTTOM w0.254: v1(78.81,65.78) 78.65,65.78 PH603.2
N46816817: length 2.4
  TOP w0.127: v2(74.28,68.23) 74.35,68.15 PR644.1
  TOP w0.254: PR644.1 73.54,66.39 PC630.2
N46816821: length 3.3
  TOP w0.127: v2(88,65.13) 88.4,65.53 v1(88.4,65.84)
  TOP w0.254: PR657.2 88.35,65.89 v1(88.4,65.84)
  BOTTOM w0.254: v1(88.4,65.84) 88.72,66.17 88.91,66.17 PH605.1
N46816907: length 0.9
  TOP w0.254: PR645.1 74.17,60.78 PC639.2
N48704005: length 5.6
  TOP w0.127: PR624.1 90.99,91.31 90.4,91.31 v2(89.78,91.93)
  TOP w0.254: PR624.1 92.56,90.61 92.91,90.95 v1(92.91,91.28)
  BOTTOM w0.254: PL614.3 93.04,91.41 v1(92.91,91.28)
N49204882: length 2.6
  TOP w0.127: v2(83.71,69.06) 83.37,69.4 v1(82.98,69.4)
  TOP w0.254: v1(82.98,69.4) 82.83,69.55 PR661.1
  BOTTOM w0.254: v1(82.98,69.4) 82.8,69.59 PL612.3
N49227484: length 0.7
  TOP w0.127: v1(76.4,80.68) v3(75.91,81.17)
N49231019: length 1.1
  BOTTOM w0.127: v2(72.44,72.53) 72.03,72.12 PC663.2

## Copper pours and planes (outline as drawn)
+0.6V_DDR_VTT on TOP (solid shape): 127.09,33 127.09,31.22 126.84,30.97 124.8,30.97 124.55,31.22 122.9,31.22 122.77,31.35 122.77,33.13 122.9,33.25 126.84,33.25
+0.6V_DDR_VTT on TOP (solid shape): 201.37,31.73 201.37,29.54 201.65,29.26 202.19,29.26 202.35,29.1 202.35,28.59 202.22,28.47 199.94,28.47 199.74,28.67 199.74,31.69 199.87,31.82 201.28,31.82
+0.6V_DDR_VTT on TOP (solid shape): 228.1,33.01 228.1,28.8 227.02,27.72 226.83,27.72 226.37,28.19 225.81,28.19 225.69,28.31 225.69,29.33 225.81,29.46 225.81,32.25 225.88,32.32 225.88,33.33 225.94,33.39 227.72,33.39
+0.6V_DDR_VTT on BOTTOM (solid shape): 201.07,31.87 201.07,29.33 200.81,29.08 199.59,29.08 199.46,29.2 199.46,29.56 199.73,29.82 199.73,29.86 199.84,29.97 200.56,29.97 200.75,30.16 200.75,31.87 200.81,31.94 201,31.94
+0.6V_DDR_VTT on IN2 (solid shape): 126.88,32.51 126.88,31.17 126.63,30.92 123.96,30.92 123.26,31.62 123.26,32.51 123.39,32.63 126.75,32.63
+0.6V_DDR_VTT on IN2 (solid shape): 130.69,29.84 130.69,28.31 130.5,28.12 129.67,28.12 129.36,28.44 129.36,29.14 128.91,29.58 128.91,30.22 129.1,30.41 130.12,30.41
+0.6V_DDR_VTT on IN4 (solid shape): 131.64,28.19 131.51,28.06 129.74,28.06 129.48,28.31 129.48,29.01 129.61,29.14 131.64,29.14
+0.6V_DDR_VTT on IN4 (solid shape): 201.17,29.97 201.17,28.82 200.92,28.57 200.09,28.57 199.78,28.89 199.78,30.09 199.9,30.22 200.92,30.22
+0.6V_DDR_VTT on IN4 (solid shape): 227.21,28.57 227.21,27.68 226.51,26.98 226.51,26.7 225.49,26.7 225.49,27.04 225.3,27.24 225.3,28.63 225.46,28.79 226.99,28.79
+0.6VSP on TOP (solid shape): 225.62,33.52 225.62,33.14 225.11,33.14 225.11,32.57 225.18,32.51 225.62,32.51 225.62,29.78 224.99,29.14 224.62,29.14 224.49,29.01 223.97,29.01 223.92,28.96 223.14,28.96 223.08,29.03 223.08,29.6 223.17,29.69 224.13,29.69 224.48,30.03 224.48,33.46 224.73,33.71 225.43,33.71
+0.9V_TBT_CIO on BOTTOM (solid shape): 28.17,79.51 28.31,79.42 28.47,79.41 28.5,79.39 28.52,79.32 28.55,79.28 28.58,79.24 28.63,79.21 28.63,78.99 28.57,78.93 28.54,78.9 28.38,78.74 28.38,77.58 28.14,77.35 28.01,77.35 27.86,77.45 27.68,77.47 27.66,77.49 27.61,77.61 27.55,77.66 27.52,77.7 27.52,77.89 27.55,77.93 27.66,78.12 27.55,78.31 27.55,78.42 27.97,78.84 28,78.87 28.01,78.88 28.08,79.09 28.01,79.3 27.96,79.36 27.95,79.42 27.95,79.47 28.03,79.55 28.13,79.55
+0.9V_TBT_DP on TOP (solid shape): 29.32,77.9 29.32,77.57 29.47,77.42 30.51,77.42 30.71,77.62 31.27,77.62 31.41,77.48 31.41,77.23 31.33,77.15 31.33,76.06 31.24,75.97 30.82,75.97 30.59,76.2 29.39,76.2 29.38,76.21 29.38,76.6 29.2,76.78 28.94,76.78 28.71,77.01 28.71,77.9 28.84,78.03 29.19,78.03
+0.9V_TBT_DP on BOTTOM (solid shape): 27.24,79.93 27.27,79.91 27.36,79.81 27.36,79.64 27.34,79.63 27.24,79.55 27.2,79.42 27.2,79.4 27.11,79.31 26.03,79.31 25.77,79.57 25.77,79.9 26,80.13 26.03,80.16 26.08,80.21 26.16,80.21 26.32,80.06 26.59,80.06 26.78,80.25 26.93,80.25
+0.9V_TBT_DP on BOTTOM (solid shape): 28.77,78.27 29,78.1 29.28,78.18 29.28,78.19 29.32,78.2 29.36,78.18 29.38,78.15 29.4,78.12 29.38,78.08 29.38,78.08 29.27,77.78 29.4,77.49 29.49,77.4 29.38,77.26 29.37,77.14 29.38,77.01 29.43,76.96 29.45,76.93 29.52,76.87 29.48,76.74 29.45,76.71 29.31,76.71 29.14,76.87 28.98,76.87 28.94,76.91 28.89,76.98 28.82,77.03 28.51,77.35 28.51,78.17 28.63,78.29 28.76,78.29
+0.9V_TBT_DP on IN1: 26.08,76.96 26.1,76.99 26.13,77.21 26.02,77.39 25.99,77.47 26.13,77.79 25.99,78.12 26.02,78.19 26.05,78.23 26.13,78.26 26.2,78.23 26.78,78.44 26.2,78.66 26.13,78.63 26.05,78.66 25.77,78.77 25.52,78.62 25.48,78.59 25.43,78.62 25.41,78.65 25.41,79.78 25.82,80.18 26.2,80.18 26.45,80.06 26.71,80.18 26.87,80.18 27.2,80.51 28.68,80.51 28.73,80.46 28.72,80.44 28.82,80.16 29.09,80.07 29.12,80.07 29.4,79.79 29.4,78.79 29.35,78.7 29.24,78.7 28.73,78.43 29.24,78.16 29.35,78.16 29.4,78.07 29.4,77.93 29.4,77.92 29.37,77.79 29.4,77.67 29.4,77.66 29.4,77.01 29.26,76.87 28.84,76.87 28.67,76.69 28.67,75.59 28.54,75.47 26.74,75.47 26.64,75.56 26.64,76.4
+0.9V_TBT_LVR_OUT on TOP (solid shape): 24.29,75.83 24.29,75.5 24.36,75.42 24.77,75.42 25.27,75.42 25.38,75.32 25.38,75.09 25.15,74.86 23.94,74.86 23.88,74.87 23.81,74.87 23.59,75.09 23.59,76.14 23.97,76.14
+0.9V_TBT_LVR_OUT on TOP (solid shape): 26.08,74.64 26.08,74.37 26.3,74.15 26.54,74.15 26.67,74.01 26.67,73.97 26.69,73.87 26.72,73.84 26.72,72.92 26.68,72.88 25.22,72.88 25.17,72.92 25.17,73.4 25.56,73.79 25.56,74.63 25.69,74.76 25.95,74.76
+0.9V_TBT_LVR_OUT on BOTTOM (solid shape): 25.43,78.49 25.43,78.35 25.55,78.23 25.67,78.14 25.81,78.11 25.83,78.11 25.92,78.02 25.96,77.96 26.03,77.91 26.03,77.72 25.9,77.6 25.67,77.6 25.48,77.7 25.29,77.6 25.02,77.6 24.97,77.65 24.91,77.68 24.85,77.7 24.7,77.85 24.7,78.1 24.91,78.32 24.91,78.48 25.08,78.66 25.27,78.66
+0.9V_TBT_LVR_OUT on IN2: 27.76,76.81 27.76,74.87 27.13,74.24 27.13,73.21 26.51,72.59 25.3,72.59 24.17,73.72 24.18,73.75 24.19,74 24.04,74.2 24.04,74.25 24.07,74.29 24.17,74.65 23.87,74.87 23.81,74.91 23.78,74.97 23.78,76.06 23.81,76.13 23.87,76.16 24.04,76.22 24.16,76.36 24.18,76.57 24.07,76.74 24.04,76.82 24.18,77.14 24.04,77.47 24.18,77.79 24.04,78.12 24.07,78.19 24.1,78.23 24.18,78.26 24.25,78.23 24.54,78.11 24.8,78.29 24.79,78.61 24.52,78.77 24.5,78.77 24.45,78.82 24.54,78.91 26.69,78.91 26.69,78.84 26.66,78.81 26.61,78.76 26.54,78.76 26.5,78.77 26.34,78.75 26.2,78.66 26.13,78.63 26.05,78.66 25.47,78.44 26.05,78.23 26.13,78.26 26.2,78.23 26.23,78.19 26.27,78.12 26.23,78.04 26.16,77.94 26.12,77.83 26.32,77.49 26.7,77.58 26.78,77.61 26.85,77.58 27.1,77.46 27.35,77.58 27.43,77.61 27.5,77.58 27.54,77.54 27.57,77.47 27.53,77.39 27.44,77.04 27.72,76.81
+0.9V_TBT_PCIE on TOP (solid shape): 26.75,76.66 26.75,76.35 26.84,76.27 27.32,76.27 27.36,76.23 27.36,74.49 27.36,74.33 27.48,74.21 27.48,74.05 27.46,73.78 27.65,73.59 27.68,73.58 27.74,73.51 28.19,73.51 28.42,73.29 28.42,72.9 28.31,72.79 26.98,72.79 26.87,72.89 26.87,73.87 26.81,73.93 26.8,74.01 26.77,74.04 26.77,74.05 26.58,74.25 26.57,74.25 26.54,74.27 26.35,74.27 26.2,74.42 26.2,74.68 26.18,74.7 26.18,76.62 26.28,76.72 26.69,76.72
+0.9V_TBT_PCIE on BOTTOM (solid shape): 26.92,76.9 26.95,76.84 26.94,76.78 26.77,76.48 26.95,76.2 26.98,76.18 26.98,75.63 26.98,75.5 27.55,74.93 27.55,74.16 27.52,74.13 27.47,74.08 27.41,74.08 27.17,74.31 27.14,74.31 27.02,74.31 26.87,74.46 26.69,74.46 26.53,74.3 26.39,74.3 26.3,74.21 26.23,74.16 26.17,74.1 26.06,74.1 26.03,74.14 26.03,74.3 26.13,74.54 26.03,74.79 26.03,74.95 26.11,75.08 26.13,75.23 26.2,75.3 26.27,75.34 26.32,75.4 26.35,75.58 26.23,75.72 26.19,75.8 26.22,75.88 26.28,75.94 26.28,76 26.36,76.17 26.28,76.34 26.28,76.65 26.34,76.74 26.35,76.86 26.38,76.93 26.46,76.96 26.85,76.96
+0.9V_TBT_SVR on TOP (solid shape): 24.38,77.98 24.38,77.36 24.71,77.36 24.79,77.32 24.81,77.24 24.8,77.1 24.84,76.97 24.86,76.93 24.89,76.9 24.89,76.74 24.85,76.67 24.36,76.67 24.28,76.6 24.28,76.36 24.15,76.23 24.03,76.23 24.02,76.25 23.67,76.25 23.6,76.32 23.6,77.35 23.45,77.49 23.2,77.5 22.99,77.49 22.87,77.37 22.87,77.26 22.85,77.15 22.86,77.04 22.81,76.99 21.9,76.99 21.86,77.02 21.86,77.04 21.75,77.04 21.22,77.56 20.77,77.56 20.56,77.77 20.56,77.97 20.66,78.06 23.94,78.06 23.95,78.08 24.28,78.08
+0.9V_TBT_SVR on BOTTOM (solid shape): 18.89,93.62 18.89,90.15 19.09,89.95 19.53,89.95 20.04,89.44 20.04,88.83 19.39,88.19 16.86,88.19 16.71,88.34 16.71,88.43 16.2,88.95 16.2,93.91 16.29,94.01 18.51,94.01
