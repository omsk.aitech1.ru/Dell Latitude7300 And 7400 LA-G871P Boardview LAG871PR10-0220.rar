# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_BIST_R: length 7.1
  TOP w0.127: QZ21.2 298.34,9.36 v2(298.38,9.32) CZ218.1 298.99,8.13 299.07,8.21 RZ1413.1 RZ1482.1 300.16,7.31 DZ12.2 300.98,7.84 RZ1415.1
MACO_EN: length 9
  TOP w0.127: T452.1 155.54,66.36 v1(154.86,66.36)
  BOTTOM w0.076: UC1.CL35 151.54,69.19 151.37,69.02 151.37,68.85 151.56,68.39 151.56,68.16 153.36,66.36 154.65,66.36
  BOTTOM w0.127: 154.65,66.36 v1(154.86,66.36)
MASK_BASE_LEDS#: length 2.9
  TOP w0.127: v2(306.69,68.74) 307.22,69.28 UZ10.4 307.22,70.04 307.46,70.28 v1(307.87,70.28)
  BOTTOM w0.127: QZ7.2 v1(307.87,70.28)
ME_FWP: length 142.8
  TOP w0.127: v1(277,87.03) 277,86.97 UE1.G12 ; v2(297.5,61.03) 296.83,61.7 v1(296.83,61.72)
  IN1 w0.084: v1(301.68,25.84) 301.68,28.26 299.28,30.66 290.9,30.66 289.31,32.25 282.14,32.25 277.5,36.89 277.5,43.64 278.72,44.86 278.72,45.94 278.94,46.16 279.64,46.16 281.82,48.34 281.82,49.52 282.07,49.78 282.07,50.29 282.51,50.73 284.68,50.73 285,50.41 289.18,50.41 289.36,50.23 295.02,50.23 296.73,51.94 300.11,51.94 301.12,52.96 301.12,53.21 302.46,54.54 302.46,57.02 300.62,58.86 300.62,59.36 298.26,61.72 v1(296.83,61.72)
  IN4 w0.084: v1(277,87.03) 277,88.05 276.92,88.13 276.92,90.11 281.69,94.88 287.04,94.88 287.29,95.13 289.99,95.13 291.06,96.21 292.3,96.21 293,95.5 293,89.21 292.62,88.83 292.62,87.22 293.74,86.1 294.77,86.1 296.5,84.37 296.5,77.45 297.57,76.38 297.57,74.37 296.58,73.38 296.58,72.33 295.98,71.74 295.98,69.4 295.11,68.53 295.11,67.67 296.64,66.13 296.64,61.91 v1(296.83,61.72)
  BOTTOM w0.127: v1(301.68,25.84) RC221.1 302.16,26.46 302.45,26.17 SW1.3
ME_FWP_PCH: length 191
  TOP w0.127: v1(261.39,30.87) 260.37,30.87 259.95,30.45 257.02,30.45 256.74,30.73 256.74,32.82 257.4,33.49 257.4,37.55 256.99,37.97 256.99,40.82 257.37,41.21 257.37,41.4 257.97,41.99 v1(258.17,41.99) ; RC562.1 147.71,50.79 148.23,50.26 148.23,50.13 148.48,49.88 148.83,49.88 148.83,49.89 149.46,49.89 150.51,48.84 151.33,48.84 151.75,48.42 154.76,48.42 156.48,50.15 156.9,50.15 166.89,50.15 167.55,50.81 v2(169.74,50.81) 173.87,50.81 174.08,50.59 180.65,50.59 181.36,51.3 181.71,51.3 182.24,51.83 182.24,53.03 v1(182.4,53.2) ; v1(296.12,24.28) 296.53,24.7 298.81,24.7 v1(301.16,27.04)
  IN1 w0.084: v1(264.04,28.71) 264.25,28.5 266.07,28.5 266.76,29.19 276.21,29.19 277.17,30.16 278.39,30.16 279.85,28.7 289.19,28.7 289.88,29.39 291.55,29.39 292.5,28.45 294.51,28.45 295.41,27.55 295.41,25.39 296.12,24.69 v1(296.12,24.28)
  IN3 w0.122: v1(182.4,53.2) 182.4,52.67 186.94,48.13 206.86,48.13 216.31,38.68 224.69,38.68 226.51,36.86 238.05,36.86 238.17,36.97 243.16,36.97 243.82,36.31 244.35,36.31 245.27,37.24 246.53,37.24 246.93,37.64 249.84,37.64 251.87,39.68 256.05,39.68 258.17,41.8 v1(258.17,41.99)
  BOTTOM w0.127: v1(264.04,28.71) 263.64,28.71 262.51,29.84 262.04,29.84 261.39,30.5 v1(261.39,30.87) ; v1(301.16,27.04) RC221.2 301.81,27.17 SW1.2
MEC_XTAL1: length 5.2
  TOP w0.127: UE1.A1 271.21,77.76 v2(270.55,77.1) CE28.1 269.22,77.1 268.7,76.58 YE1.1
MEC_XTAL2: length 2.9
  TOP w0.127: YE1.2 268.34,78.61 268.87,78.61 269.51,77.96 CE29.1 270.29,77.96 RE290.2
MEC_XTAL2_R: length 2.6
  TOP w0.127: RE290.1 271.84,78.58 UE1.A3
MEDIACARD_IRQ#: length 194.7
  TOP w0.127: UR1.32 290.98,68.9 290.79,69.09 RR19.1 287.71,69.09 v1(285.71,67.1)
  IN1 w0.084: v1(285.71,67.1) 285.07,67.1 284.56,67.61 282.79,67.61 282.19,67.02 278.44,67.02 277.85,67.61 277.24,67.61 277.17,67.55 275.14,67.55 274.36,66.77 271.98,66.77 271.44,66.23 268.33,66.23 v1(268.14,66.04)
  IN2 w0.084: v1(149.59,78.51) 150,78.92 151.77,78.92 152.76,77.94 155.23,77.94 156.53,79.24 159.26,79.24
  IN2 w0.089: 161.76,79.96 161.22,79.42 159.44,79.42 159.26,79.24
  IN2 w0.122: v1(268.14,66.04) 268.66,65.53 268.66,61.84 266.27,59.45 266.27,56.66 265.15,55.54 265.15,52.2 264.06,51.11 264.06,49.86 263.11,48.91 263.11,46.71 264.23,45.59 264.23,43.22 263.1,42.09 259.84,42.09 259.19,42.74 257.35,42.74 256.49,41.88 251.91,41.88 250.9,40.87 249.42,40.87 248.83,40.28 246.38,40.28 246.02,39.93 244.67,39.93 243.6,38.85 219.92,38.85 213.01,45.77 204.77,45.77 203.31,47.23 203.31,56.53 199.05,60.79 199.05,61.38 195.52,64.91 186.01,64.91 182.16,68.76 181.19,68.76 178.7,71.25 178.7,71.94 173.94,76.69 168.67,76.69 167.2,78.16 167.2,79.01 165.34,80.87 163.18,80.87 162.38,80.07 161.87,80.07 161.76,79.96
  BOTTOM w0.089: UC1.CG20 v1(149.59,78.51)
MEM_CONFIG0: length 5
  BOTTOM w0.076: UC1.CR20 154.04,79.29 154.82,79.29 154.98,79.13 156.3,79.13 156.39,79.23
  BOTTOM w0.102: 156.39,79.23 158.02,79.23 T408.1
MEM_CONFIG1: length 5.7
  BOTTOM w0.076: UC1.CM20 152.27,79.55 153.15,79.55 153.5,79.42 153.74,79.42 153.85,79.46 154.88,79.46 155.05,79.3 156.2,79.3 156.35,79.46
  BOTTOM w0.102: T409.1 156.96,79.46 156.35,79.46
MEM_CONFIG2: length 3.3
  BOTTOM w0.076: UC1.CN19 153.07,79.75 153.53,79.59 153.71,79.59 153.83,79.63 154.95,79.63 155.12,79.46 155.66,79.46 T410.1
MEM_CONFIG3: length 8
  BOTTOM w0.076: T411.1 159.61,80.09 155.75,80.09 155.63,80.21 155.09,80.21 154.95,80.07 153.83,80.07 153.71,80.11 153.53,80.11 153.41,80.07 153.18,80.07 153.06,80.11 152.58,80.11 UC1.CM19
MEM_CONFIG4: length 9
  BOTTOM w0.076: 160.69,79.85 160.29,80.25 155.82,80.25 155.7,80.37 155.01,80.37 154.88,80.24 153.85,80.24 153.74,80.28 153.5,80.28 153.39,80.24 153.2,80.24 153.09,80.28 152.79,80.28 UC1.CN18
  BOTTOM w0.127: T412.1 160.69,79.85
MEM_INTERLEAVED: length 29.3
  IN4 w0.076: 153.37,91.31 150.96,88.89 150.96,88.12 151.07,88.01 151.07,86.03 150.67,85.62 149.24,85.62 148.72,86.14 v1(148.72,86.21)
  IN4 w0.102: 153.37,91.31 153.47,91.41 153.47,92.89 157.54,96.96 162.09,96.96 162.44,96.61 162.44,96.39 163.58,95.24 167,95.24 v1(167.52,94.72)
  BOTTOM w0.089: v1(148.72,86.21) 148.28,85.96 UC1.CE9
  BOTTOM w0.127: RC844.1 RC843.1 167.54,94.7 v1(167.52,94.72)
MEM_SMBCLK: length 26.7
  IN1 w0.084: v1(151.49,82.66) 151.2,82.37 151.2,82.25 151.3,82.16 152.79,82.16 153.49,81.46 156.66,81.46 156.82,81.29 161.38,81.29 161.7,80.97 162.07,80.97 163.21,79.83 168.53,79.83 169.1,80.4 170.9,80.4 171.09,80.21 171.78,80.21 v1(171.96,80.38)
  BOTTOM w0.089: v1(151.49,82.66) UC1.CK14
  BOTTOM w0.127: v1(171.96,80.38) 172.03,80.32 172.03,79.94 171.73,79.64 CC320.1 RC12.1 171.81,78.62 171.81,77.58 171.69,77.46 QC2.6
MEM_SMBDATA: length 29.3
  IN1 w0.084: v1(172.55,80.38) 172.55,80.31 171.98,79.74 170.89,79.74 170.7,79.93 169.29,79.93 168.72,79.37 163.02,79.37 161.66,80.72 161.67,80.74 161.66,80.77 161.63,80.8 161.31,81.12 156.75,81.12 156.58,81.29 153.42,81.29 152.72,81.98 150.71,81.98 150.35,81.62 v1(150.22,81.62)
  BOTTOM w0.089: v1(150.22,81.62) UC1.CH15
  BOTTOM w0.127: v1(172.55,80.38) 172.65,80.28 v2(172.65,79.71) 172.65,78.77 RC14.1 172.59,78.49 172.32,78.22 172.32,76.6 172.46,76.46 QC2.3
MSCLK: length 29.1
  TOP w0.127: v1(291.89,93.66) RE72.2 292.47,93.2 292.39,93.11 RE30.1 ; v1(278.59,85.36) 278.59,85.32 UE1.H10
  IN4 w0.084: v1(278.59,85.36) 278.31,85.36 278.15,85.51 278.15,87.52 278.36,87.73 278.36,90.47 280.85,92.95 281.51,92.95 282.41,93.85 285.77,93.85 286.25,93.36 288.13,93.36 288.74,93.98 291.57,93.98 v1(291.89,93.66)
  BOTTOM w0.127: JDEG1.6 294.41,90.09 291.81,92.68 291.81,93.58 v1(291.89,93.66)
MSDATA: length 30.7
  TOP w0.127: v1(277.01,84.53) 277.04,84.53 UE1.G9 ; v1(291.83,94.42) RE86.1 292.41,95.18 RE75.2
  IN4 w0.084: v1(277.01,84.53) 277.04,84.53 277.69,85.18 277.94,85.44 277.94,87.6 278.14,87.8 278.14,90.54 280.76,93.16 281.42,93.16 282.32,94.06 285.85,94.06 286.34,93.57 288.04,93.57 288.66,94.19 291.6,94.19 v1(291.83,94.42)
  BOTTOM w0.127: JDEG1.7 294.27,90.59 292.07,92.78 292.07,93.28 292.28,93.49 292.28,93.96 v1(291.83,94.42)
NB_MODE#: length 11.5
  TOP w0.127: UE1.J6 279.08,81.76 279.38,81.46 279.39,81.46 v1(279.42,81.42) ; T348.1 284.35,74.68 v1(284.35,75.76)
  IN4 w0.084: v1(284.35,75.76) 283.33,75.76 283.23,75.86 282.96,75.86 282.74,76.08 282.74,76.35 280.61,78.48 279.3,78.48 278.96,78.82 278.96,80.96 279.42,81.41 v1(279.42,81.42)
NB_MUTE#: length 63.6
  TOP w0.127: v1(271.42,79.31) 271.48,79.37 271.91,79.37 272.62,80.07 UE1.A4
  TOP w0.203: v1(274.63,48.13) 274.38,47.87 v2(273.81,47.87) 272.73,47.87 DA8.1 273.37,46.74 RA48.1
  IN1 w0.084: v1(271.42,79.31) 271.42,78.21 271.8,77.83 277.8,77.83 278.11,77.52 280.44,77.52 281.05,78.13 281.36,78.13 281.51,78.28 283.91,78.28 285.54,76.65 285.54,76.53 286.44,75.63 286.89,75.63 287.98,74.54 288.2,74.54 v1(288.78,73.97)
  IN2 w0.122: v1(274.63,48.13) 274.63,48.61 275.83,49.81 276.17,49.81 277.28,50.92 279.72,50.92 281.5,52.7 285.18,52.7 286.71,54.22 286.71,57.72 287.39,58.4 287.39,61.17 288.01,61.78 288.01,63.78 286.66,65.13 286.66,65.99 287.92,67.24 287.92,68 287.02,68.9 287.02,70.41 287.52,70.91 287.52,72.36 288.56,73.4 288.56,73.75 v1(288.78,73.97)
NB_PSID: length 6.2
  TOP w0.127: PL3.2 44.7,99.73 v3(45.66,100.69)
  TOP w0.254: v1(43.95,98.61) 44.21,98.34 PD4.3 ; PD4.3 44.6,99.3 PL3.2 ; PD4.3 PD4.2
  BOTTOM w0.254: v1(43.95,98.61) 44.14,98.8 PJPDC1.1
NFC_ACTIVITY_STATUS#_R: length 19.7
  BOTTOM w0.127: v2(276.21,32.73) 277.02,31.92 RZ1473.2 276.56,31.41 275.08,31.41 273.64,29.97 268.54,29.97 268.14,29.56 267.06,29.56 266.42,28.92 265.03,28.92 264.39,29.56 263.76,29.56 261.93,31.39 JUSH1.2
NGFF_CONFIG_0: length 62.5
  TOP w0.102: v1(287.63,86.12) 287.07,85.57 284.17,85.57 283.31,84.7 282.77,84.7 UE1.N9
  TOP w0.127: RE804.1 289.01,88.66 v1(288.9,88.55)
  IN2 w0.122: v1(284.3,54.98) 284.3,56.83 285.3,57.83 285.3,59.62 283.16,61.76 283.16,64.17 284.47,65.48 284.47,66.88 283.59,67.76 283.59,70.11 283.54,70.16 283.54,71.97 284.34,72.77 285.05,72.77 285.17,72.89 285.17,73.65 286.77,75.25 286.77,75.94 286.92,76.09 286.92,80.14 286.27,80.8 286.27,82.04 287.92,83.69 287.92,85.08 287.63,85.37 v1(287.63,86.12) 288.16,86.65 288.16,87.8 v1(288.9,88.55)
  BOTTOM w0.127: v1(284.3,54.98) 283.34,54.03 278.45,54.03 278.07,54.41 272.87,54.41 272.18,55.1 JNGFF2.21
NGFF_CONFIG_1: length 109
  TOP w0.102: UE1.M10 281.9,85.43 283.44,85.43 284.15,86.14 285.41,86.14 286.18,86.91 287.66,86.91
  TOP w0.127: UZ29.9 245.65,45.67 245.94,45.97 v2(248.61,45.97) 249.48,45.97 v1(250.03,46.52) ; 287.66,86.91 v1(287.76,86.91) 289.36,86.91 289.79,87.34 RE562.1
  IN3 w0.122: v1(284.87,58.47) 285.04,58.47 285.43,58.86 285.43,59.7 284.49,60.64 283.59,61.53 283.59,62.83 283.77,63.02 283.77,63.74 284.56,64.53 284.56,69.96 285.62,71.02 285.62,73.86 285.67,73.91 285.67,74.68 285.03,75.32 285.03,78.86 285.25,79.08 289.46,79.08 290.47,80.09 290.47,80.67 288.68,82.46 288.68,82.64 287.45,83.86 286.31,83.86 285.78,84.4 285.78,85.55 287.14,86.91 v1(287.76,86.91)
  IN4 w0.084: v1(265.12,59) 264.75,59 262.31,56.55 261.74,56.55 259.89,54.71 258.61,54.71 258.2,54.29 258.2,53.01 256.43,51.25 256.43,50.48 255.8,49.84 254.25,49.84 250.92,46.52 v1(250.03,46.52)
  BOTTOM w0.127: v1(284.87,58.47) 284.36,58.47 284.18,58.29 JNGFF2.69 284.18,55.75 284.43,55.5 285.18,55.5 285.38,55.3 285.38,54.39 284.79,53.8 278.36,53.8 278.07,54.1 271.91,54.1 270.39,55.62 270.39,58.68 269.93,59.14 265.26,59.14 v1(265.12,59)
NGFF_CONFIG_2: length 48.2
  TOP w0.102: UE1.N10 283.27,84.96 284.16,85.85
  TOP w0.127: v1(284.87,59.03) v2(284.14,59.03) ; 284.16,85.85 286.67,85.85 v1(286.98,86.16) 287.34,86.51 289.3,86.51 290.01,87.23 290.01,90.3 RE803.1
  IN2 w0.122: v1(284.87,59.03) 284.87,59.52 284.02,60.36 283.54,60.36 282.01,61.89 282.01,64.59 283.36,65.94 283.36,68.22 282.67,68.91 282.67,72.48 282.96,72.76 283.68,72.76 284.31,73.39 284.31,74.54 285.57,75.8 285.57,78.22 286.7,79.35 286.7,80.05 286.04,80.71 286.04,82.63 286.85,83.44 286.85,86.02 v1(286.98,86.16)
  BOTTOM w0.127: JNGFF2.75 285.68,58.22 v1(284.87,59.03)
NGFF_CONFIG_3: length 43.7
  TOP w0.127: v1(275.83,67.95) 275.93,68.06 RE805.1 ; v1(276.25,79.73) 276.25,79.79 UE1.F4
  IN1 w0.084: v1(267.73,55.09) 266.93,55.9 263.33,55.9 262.16,57.07 262.16,58.22 264.34,60.4 264.34,61.29 266.44,63.39 266.44,65.53 267.33,66.42 271.37,66.42 271.9,66.95 274.1,66.95 275.1,67.95 v1(275.83,67.95)
  BOTTOM w0.127: v1(276.25,79.73) 276.61,79.37 277.25,79.37 277.5,79.11 277.5,76.6 276.17,75.26 276.17,68.29 v1(275.83,67.95) ; v1(267.73,55.09) 267.18,55.65 JNGFF2.1
NO_SMOKE_OVP: length 6.9
  TOP w0.127: v2(51.8,57.91) 51.8,58.17 v1(50.74,59.23)
  BOTTOM w0.254: PQ3000.5 50.56,57.86 50.31,58.11 PC3008.1 49.99,58.67 PC3009.1 50.54,59.23 v1(50.74,59.23) 51.11,59.23 PD3001.2 51.64,60.19 PR3012.2
NO_SMOKE_UVP: length 14.6
  TOP w0.254: v1(55.06,61.11) 54.57,61.11 52.41,63.27 v2(51.47,63.27) v1(50.54,63.27)
  BOTTOM w0.254: PQ3000.2 52.36,57.86 52.22,57.99 52.22,59.49 52.55,59.82 PC3010.1 ; PD3002.2 49.33,63.27 v1(50.54,63.27) 50.56,63.28 PR3013.2
  BOTTOM w0.305: v1(55.06,61.11) 55.06,60.87 54.34,60.15 PC3011.1 54.34,59.82 PC3010.1
NRB_BIT: length 37.9
  TOP w0.127: v2(176.87,62.83) 176.47,62.44 v1(176.47,62.29) 176.47,61.92 RC831.2
  IN2 w0.089: v1(148.49,73.22) 148.85,72.86 148.85,70.19 149.99,69.05 149.99,66.66
  IN2 w0.122: v1(176.47,62.29) 176.41,62.29 175.26,63.44 174.67,63.44 174.42,63.69 166.38,63.69 165.94,64.13 160.84,64.13 160.47,64.5 152.61,64.5 151.36,65.74 150.31,65.74 149.99,66.07 149.99,66.66
  BOTTOM w0.089: UC1.CE29 v1(148.49,73.22)
NTC_A_GT: length 6.4
  TOP w0.203: PR635.2 72.72,56.75 72.72,58.02 71.93,58.81 v2(71.66,58.81) PU602.15
NTC_B_IA: length 4
  TOP w0.203: PR610.2 62.98,55.23 64.62,55.23 65.32,55.92 PU602.3
NVME_LED#: length 23.5
  TOP w0.127: v2(10.72,23.11) RN100.1 v1(12.03,22.3)
  IN3 w0.076: 31.5,21.04 31.63,20.91 JNGFF3.10
  IN3 w0.122: v1(12.03,22.3) 14.06,22.3 15.2,21.16 31.38,21.16 31.5,21.04
ONE_DIMM#: length 33.1
  TOP w0.127: RC53.1 168.83,60.39 168.45,60.02 167.43,60.02 167.25,60.2 v2(167.25,61.73) 167.38,61.86 v1(167.38,62.59)
  IN2 w0.089: 149.76,66.66 149.76,69.02 148.02,70.76 148.02,73.37 148.49,73.83 v1(148.49,73.85)
  IN2 w0.122: v1(167.38,62.59) 166.86,62.59 165.54,63.91 160.74,63.91 160.37,64.28 152.51,64.28 151.27,65.52 150.17,65.52 149.76,65.92 149.76,66.66
  BOTTOM w0.089: UC1.CE28 v1(148.49,73.85)
OTGEN/CMIN_CHG: length 28.2
  TOP w0.127: v1(55.82,56.95) 56.15,57.28 v2(56.15,57.42)
  TOP w0.203: PU700.20 44.13,54.05 43.92,53.85 v1(42.93,53.85) 39.96,53.85 PR709.2
  TOP w0.254: PR712.2 54.48,57.3 54.82,56.95 v1(55.82,56.95) ; PR709.2 39.58,53.17 39.3,52.89 37.99,52.89 PR746.2
  IN2 w0.203: v1(42.93,53.85) 42.93,53.21 43.91,52.23 43.91,52.23 45.13,51.01 47.04,51.01 47.42,50.63 49.91,50.63 51.29,52 51.29,53.08 53.56,55.35 54.49,56.28 54.81,56.28 55.48,56.95 v1(55.82,56.95)
OTGPG/CMOUT_CHG: length 10.9
  TOP w0.203: v1(43.44,49.9) 43.44,50.1 v2(43.78,50.43) 44.46,51.11 45.63,51.11 45.93,51.41 PU700.26 ; v1(39.44,48.57) 40.05,49.18 PR727.2
  TOP w0.254: v1(43.44,49.9) 43.88,49.47 PR726.2 PR745.2
  IN3 w0.203: v1(39.44,48.57) 40.21,49.33 42.87,49.33 v1(43.44,49.9)
P_SENSOR_PWR_SAVE#: length 119.7
  TOP w0.127: v1(154.5,102.93) 154.07,102.93 v3(153.82,103.18) ; RV743.2 99.8,110.23 98.62,110.23 97.92,110.93 v1(97.92,111.01)
  IN2 w0.089: v1(158.99,85.31) 158.94,85.31 157.62,86.63 155.68,86.63 154.11,88.2 154.11,92.41
  IN2 w0.122: 154.11,92.41 154.11,92.49 154.2,92.58 156.41,92.58 157.31,93.48 157.31,98.29 155.17,100.43 155.17,102.64 154.88,102.93 v1(154.5,102.93)
  IN3 w0.122: v1(97.92,111.01) 97.92,110.87 98.31,110.48 101.88,110.48 102.24,110.84 102.24,111.88 102.43,112.07 104.3,112.07 104.49,112.26 108.85,112.26 109.67,113.07 145.79,113.07 146.49,112.37 149.25,112.37 149.55,112.07 152.67,112.07 153.67,113.07 161.44,113.07 163.42,111.09 v1(163.42,109.75)
  BOTTOM w0.076: UC1.CP12 153.35,84.24 153.83,83.98 154.1,83.98 154.32,84.2 154.76,84.2 154.88,84.08 155.58,84.08 155.96,84.08 156.26,84.38 156.31,84.38 156.38,84.45
  BOTTOM w0.102: v1(158.99,85.31) 158.14,84.46 156.38,84.46 156.38,84.45
  BOTTOM w0.127: v1(154.5,102.93) 154.5,104.57 159.07,109.13 162.8,109.13 v1(163.42,109.75) ; JIRTS1.13 v1(97.92,111.01)
PANEL_BKEN_EC: length 335.4
  TOP w0.127: v1(47.01,107.39) DV2.2 46.24,108.26 v2(45.81,108.68) ; UE1.J9 279.42,84.56 v1(279.46,84.56)
  IN1 w0.084: v1(272.61,90.89) 272.58,90.93 263.91,90.93 263.66,91.18 v1(263.21,91.18)
  IN2 w0.122: v1(272.61,90.89) 272.61,89.9 273.42,89.09 274.07,89.09 275.6,87.56 277.25,87.56 278.98,85.83 278.98,85.04 v1(279.46,84.56)
  IN3 w0.122: v1(263.21,91.18) 263.32,91.08 263.32,90.02 263.23,89.93 263.23,89.09 262.86,88.72 262.86,86.96 263.34,86.48 263.34,84.07 263.61,83.79 263.61,80.53 262.81,79.72 262.81,73.87 266.2,70.48 266.2,68.64 264.82,67.26 264.82,63.36 264.3,62.84 264.3,57.8 263.93,57.43 263.93,57.31 263.29,56.67 261.14,56.67 257.81,53.34 255.38,53.34 252.78,50.74 251.8,50.74 247.06,46 244.91,46 244.22,45.31 240.91,45.31 240.46,44.86 240.46,44.46 240.46,44.46 240.46,44.28 239.88,43.69 234.27,43.69 234.12,43.55 232.45,43.55 230.85,45.15 219.01,45.15 208.8,55.36 196.71,55.36 196.41,55.66 196.41,58.12 191.77,62.76 191.77,74.67 188.86,77.58 188.86,80.99 187.83,82.02 187.83,82.79 187.11,83.51 187.11,84.26 187.16,84.31 187.16,85.15 183,89.31 183,93.87 180.63,96.23 180.63,97.58 180.02,98.2 180.02,100.61 178.05,102.58 178.05,104.08 173.39,108.74 167.61,108.74 166.9,108.04 163.17,108.04 161.85,109.36 161.21,109.36 160.09,110.48 157.42,110.48 156.62,111.28 153.78,111.28 152.55,110.06 151.33,110.06 151.16,110.23 146.75,110.23 145.92,111.06 138.9,111.06 138.82,111.14 136.95,111.14 136.5,111.59 113.72,111.59 111.47,109.34 105.68,109.34 105.25,109.77 103.26,109.77 102.44,108.96 92.65,108.96 92.61,109 90.39,109 89.76,109.63 88.47,109.63 88.38,109.72 82.81,109.72 82.58,109.95 81.57,109.95 81.42,110.09 79.32,110.09 77.87,111.55 67.33,111.55 66.87,111.09 55.13,111.09 54.7,110.66 54.7,110 51.59,106.89 49.79,106.89 49.29,107.39 v1(47.01,107.39)
PANEL_BKLEN: length 138.4
  TOP w0.127: v1(154.86,98.72) v2(154.36,98.23) ; v1(47.1,106.09) DV2.3
  IN2 w0.089: 152.98,92.41 152.98,85.72 152.03,84.77 v1(151.58,84.77)
  IN2 w0.122: v1(154.86,98.72) 154.69,98.56 154.69,94.57 152.98,92.86 152.98,92.41
  IN3 w0.122: v1(150.82,106.4) 148.17,106.4 147.2,107.37 141.37,107.37 140.31,106.3 137.16,106.3 136.76,106.7 123.08,106.7 122.01,105.63 115.24,105.63 114.35,104.73 94.13,104.73 90.77,101.37 81.87,101.37 79.1,104.13 66.62,104.13 64.87,102.39 62.52,102.39 60.78,104.13 54.43,104.13 53.22,102.93 51.03,102.93 47.87,106.09 v1(47.1,106.09)
  BOTTOM w0.076: v1(151.58,84.77) 151.35,85 UC1.CK11
  BOTTOM w0.127: v1(150.82,106.4) 151.38,105.83 151.38,102.99 153.83,100.55 153.83,100.1 154.86,99.07 v1(154.86,98.72)
PANEL_MONITOR: length 279
  TOP w0.102: UE1.M8 281.76,83.7 282.22,83.7 282.67,84.14 283.13,84.14 v1(283.42,83.85)
  TOP w0.127: RV628.2 90.04,102.34 v1(90.21,102.52) 90.21,102.75 v2(89.88,103.09)
  IN1 w0.084: v1(267.02,71.82) 267.34,72.14 267.34,72.5 268.41,73.56 269.16,73.56 269.58,73.13 276.25,73.13 278.09,74.97 281.72,74.97 282.35,74.34 282.94,74.34 283.19,74.59 283.19,76.15 v1(283.11,76.23)
  IN3 w0.122: v1(90.21,102.52) 90.21,102.56 90.83,103.18 92.26,103.18 94.04,104.95 114.25,104.95 115.15,105.85 117.29,105.85 118.37,106.93 136.85,106.93 137.25,106.53 140.21,106.53 141.28,107.59 147.93,107.59 148.73,106.79 149.79,106.79 150.37,107.37 151.33,107.37 151.89,106.81 152.7,106.81 152.99,107.11 158.46,107.11 158.55,107.01 161.26,107.01 162.3,105.98 171.54,105.98 173.27,104.25 173.59,104.25 178.67,99.16 178.67,96.28 180.19,94.77 180.19,93.89 181.65,92.43 181.65,88.51 185.19,84.98 185.19,83.19 185.35,83.03 185.35,81.69 187.68,79.36 187.68,77.5 190.88,74.3 190.88,62.39 195.52,57.75 195.52,55.29 196.34,54.47 208.42,54.47 218.64,44.26 228.9,44.26 230.77,42.39 234.23,42.39 234.64,42.8 241.79,42.8 242.75,43.75 242.75,43.94 242.75,43.98 243.08,44.31 244.49,44.31 245.13,44.96 247.28,44.96 250.47,48.15 252.64,48.15 254.44,49.96 254.44,50.64 255.69,51.89 259.5,51.89 260.05,52.45 261.8,52.45 263.33,53.98 263.33,54.6 265.99,57.25 265.99,59.61 265.19,60.41 265.19,62.47 265.72,62.99 265.72,66.19 267.67,68.14 267.67,70.06 266.58,71.15 266.58,71.37 v1(267.02,71.82)
  BOTTOM w0.127: v1(283.42,83.85) 283.11,84.16 282.64,84.16 281.88,83.4 281.88,82.17 282.4,81.66 282.4,77.59 283.11,76.87 v1(283.11,76.23)
PANEL_PWRGD: length 9.1
  TOP w0.127: v2(88.44,98.77) 88.14,99.07 QV19.1 QV21.1 89.48,101.91 RV628.1 89.19,101.94 88.91,101.66 88.16,101.66 87.83,101.98 RV624.1 CV632.1 87.69,103.23 87.03,102.58 RV623.2
PBAT_CHARGER_SMBCLK: length 339.8
  TOP w0.102: v1(286.09,76.77) 285.99,76.87 285.68,76.87 285.54,76.73 284.83,76.73 283.98,77.58 283.2,77.58 UE1.N2
  TOP w0.127: v1(35.5,42.22) 35.82,42.54 37.66,42.54 38.42,43.3 38.42,46.54 37.74,47.23 37.74,49 38.46,49.73 38.56,49.73 39.15,50.31 39.15,51.32 40.38,52.55 PR715.1 ; PR38.2 235.91,30.66 v1(235.85,30.6) 235.53,30.6 235.35,30.43 PD2.3 235.35,29.87 235.61,29.61 236.67,29.61 236.89,29.83 237.33,29.83 v1(237.72,29.43) ; RE43.1 286.78,76.94 286.27,76.94 v1(286.09,76.77)
  IN2 w0.122: v1(237.72,29.43) 237.33,29.82 236.95,29.82 236.39,29.26 221.12,29.26 219.93,30.45 216.83,30.45 214.59,32.7 204.46,32.7 203.3,31.54 200.81,31.54 199.78,30.51 192.25,30.51 191.11,29.36 183.82,29.36 182.14,27.68 178.13,27.68 175.38,24.94 173.14,24.94 172.19,25.89 172.19,26.5 170.02,28.67 165.88,28.67 163.27,31.28 129.5,31.28 127.76,33.02 123.23,33.02 120.87,30.66 97.01,30.66 95.39,29.05 93.57,29.05 91.41,31.21 58.78,31.21 53.4,36.59 40.63,36.59 35.5,41.71 v1(35.5,42.22)
  IN3 w0.122: v1(235.85,30.6) 238.42,30.6 239.98,29.04 247.02,29.04 248.4,30.42 249.83,30.42 250.12,30.71 256.08,30.71 256.61,31.23 258.83,31.23 259.59,32 260.42,32 261.63,33.2 263.55,33.2 264.82,34.47 266.68,34.47 267.48,35.27 268.39,35.27 269.56,36.44 272.57,36.44 273.22,37.09 273.3,37.09 276.81,40.59 276.81,46.35 276.87,46.41 276.87,47.3 277,47.44 277,48.51 278.61,50.12 279.47,50.12 280.59,51.24 281.39,51.24 282.7,52.55 284.11,52.55 286.09,54.53 286.09,56.72 287.8,58.43 288.35,58.43 288.52,58.6 288.94,58.6 289.79,59.45 289.79,62.81 289.68,62.91 289.68,65.7 290.43,66.45 290.43,68.43 289.92,68.94 289.92,73.37 290.39,73.84 290.39,74.48 289.63,75.24 289.63,77.78 289.49,77.92 287.27,77.92 286.11,76.77 v1(286.09,76.77)
PBAT_CHARGER_SMBDAT: length 346.1
  TOP w0.102: UE1.M3 281.89,78.88 282.35,78.88 282.54,78.69 282.54,78.52 283.28,77.78 284.07,77.78 284.92,76.93 285.45,76.93 285.59,77.07 285.86,77.07 v1(286.12,77.32)
  TOP w0.127: v1(286.12,77.32) 286.24,77.2 286.78,77.2 RE37.1 ; v2(236.73,28.28) 237.12,28.66 v1(237.12,29.43) 237.03,29.34 234.75,29.34 234.19,29.9 PD1.2 234.61,30.6 v1(234.77,30.6) 235.02,30.85 PR39.2 ; PR713.1 40.84,53.34 38.92,51.42 38.92,50.66 38.36,50.1 38.04,50.1 37.34,49.4 37.34,46.86 38.04,46.16 38.04,43.41 37.43,42.79 35.63,42.79 v1(35.5,42.92)
  IN2 w0.122: v1(35.5,42.92) 35.06,42.48 35.06,41.59 40.28,36.37 53.3,36.37 58.69,30.98 91.32,30.98 93.48,28.82 95.49,28.82 97.07,30.41 120.93,30.41 123.32,32.8 127.64,32.8 129.38,31.05 163.18,31.05 165.79,28.44 169.93,28.44 171.96,26.41 171.96,25.8 173.05,24.72 175.48,24.72 178.22,27.46 182.23,27.46 183.91,29.14 191.2,29.14 192.35,30.28 199.87,30.28 200.91,31.32 203.4,31.32 204.53,32.45 214.52,32.45 216.74,30.23 219.83,30.23 221.02,29.04 236.72,29.04 v1(237.12,29.43)
  IN3 w0.122: v1(286.12,77.32) 286.94,78.14 289.71,78.14 289.85,78 289.85,75.33 290.62,74.57 290.62,73.75 290.14,73.28 290.14,69.04 290.65,68.53 290.65,66.35 289.91,65.61 289.91,63.01 290.02,62.9 290.02,59.36 289.03,58.37 288.61,58.37 288.44,58.21 287.89,58.21 286.32,56.63 286.32,54.44 284.2,52.32 282.79,52.32 281.48,51.01 280.68,51.01 279.34,49.68 279.34,49.05 279.35,49.04 279.35,48.71 279.34,48.7 279.34,48.57 277.03,46.26 277.03,38.64 275.58,37.18 274.77,37.18 274.45,36.87 273.31,36.87 272.6,36.16 270.77,36.16 270.04,35.43 268.86,35.43 268.48,35.05 267.57,35.05 266.78,34.25 264.92,34.25 263.65,32.98 261.72,32.98 259.15,30.41 256.23,30.41 256.15,30.48 250.21,30.48 249.93,30.2 248.49,30.2 247.11,28.82 239.89,28.82 238.33,30.38 236.99,30.38 236.82,30.21 235.68,30.21 235.29,30.6 v1(234.77,30.6)
PBAT_PRES#: length 332.8
  TOP w0.127: v1(234.79,32.76) 234.58,32.54 234.58,31.68 234.13,31.24 PR40.2 ; UE1.F9 v1(276.18,84.6)
  TOP w0.254: PR724.1 41.01,49.84 40.02,49.84 39,48.83 39,48.83 v1(38.74,48.57) ; PR40.2 PR1.2 233.31,30.2 233.32,30.18 PD1.3 233.05,30.18 232.31,30.92 v2(232.31,31.99) 232.31,32.4 v1(232.67,32.76)
  IN1 w0.084: v1(276.18,84.6) 276.32,84.6 276.68,84.96 277.18,84.96 278.06,84.08 278.06,83.74 278.6,83.2 282.34,83.2 282.51,83.02 284.07,83.02 284.27,82.82 285.91,82.82 286.85,83.77 288.79,83.77 v1(289.81,84.79)
  IN3 w0.122: v1(232.67,32.76) 232.35,32.44 225.65,32.44 224.93,33.16 220.85,33.16 218.62,35.39 214.36,35.39 209.71,40.04 207.32,40.04 204.63,42.73 140.58,42.73 136.9,46.4 120.27,46.4 120.02,46.16 95.4,46.16 93.63,44.39 68.47,44.39 67.96,43.88 44.5,43.88 41.01,47.36 39.12,47.36 38.68,47.81 38.68,48.51 v1(38.74,48.57) ; v1(234.79,32.76) 235.3,33.27 236.72,33.27 237.51,32.48 238.78,32.48 240.88,30.38 244,30.38 246.38,32.76 254.93,32.76 256.89,34.72 258.61,34.72 259.36,35.47 260.14,35.47 261.81,37.14 263.34,37.14 263.79,37.59 268.44,37.59 272.42,41.56 273.42,41.56 274.82,42.97 274.82,44.39 275.24,44.8 275.24,45.81 274.63,46.41 274.63,47.27 275.04,47.68 275.04,49.16 275.67,49.79 276.22,49.79 277.85,51.42 277.85,51.55 278.89,52.58 280.84,52.58 282.14,53.89 283.08,53.89 283.31,54.12 283.31,55.84 285.2,57.73 285.2,58.25 285.65,58.7 285.65,60.93 285.09,61.49 285.09,62.64 285.32,62.87 285.32,65.53 284.79,66.06 284.79,69.87 285.84,70.92 285.84,73.77 285.9,73.82 285.9,74.77 285.4,75.27 285.4,76.28 285.25,76.42 285.25,78.29 285.82,78.86 290.98,78.86 291.29,79.18 291.29,80.59 291.53,80.82 291.53,81.87 290.14,83.26 290.14,84.47 v1(289.81,84.79)
PBAT_PRES#_C: length 9.8
  TOP w0.127: v1(234.23,32.74) 234.23,33.09 233.38,33.94 v3(233.38,34.59)
  TOP w0.254: v1(234.23,32.74) 234.23,32.24 PR40.1
  BOTTOM w0.254: v1(234.23,32.74) 233.62,32.12 232.66,32.12 231.63,33.15 230.5,33.15 229.48,34.17 PBATT1.6
PBAT_SMBCLK_C: length 6.6
  TOP w0.127: v3(236.31,33.28) 235.93,32.9 v1(235.93,32.75) 235.91,32.72 PR38.1
  BOTTOM w0.127: PBATT1.4 232.48,34.06 232.58,33.95 235,33.95 235.93,33.02 v1(235.93,32.75)
PBAT_SMBDAT_C: length 8.1
  TOP w0.127: v3(234.66,33.5) 235.35,32.81 v1(235.35,32.75) 235.35,32.47 PR39.1
  BOTTOM w0.127: PBATT1.5 230.98,33.87 231.4,33.45 234.79,33.45 235.35,32.89 v1(235.35,32.75)
PCH_3.3V_TS_EN: length 177.3
  TOP w0.127: v1(84.08,105.88) 84.18,105.98 84.18,106.47 RV324.1 ; v1(167.7,60.53) 168.15,60.53 v2(168.31,60.69) 168.56,60.94 169.52,60.94 170.07,60.39 RC747.1
  IN2 w0.122: v1(169.24,100.22) 168.93,100.53 168.93,104.44 164.06,109.31 162.23,109.31 161.54,108.62 v1(159.91,108.62)
  IN3 w0.122: v1(84.08,105.88) 84.14,105.94 84.14,106.74 85.16,107.76 92.27,107.76 92.4,107.63 100.59,107.63 101.35,106.87 111.21,106.87 114.8,110.46 135.43,110.46 136.12,109.77 140.88,109.77 141.05,109.93 145.46,109.93 146.45,108.94 148.55,108.94 148.66,108.83 152.91,108.83 153.39,109.31 159.21,109.31 v1(159.91,108.62) ; v1(169.24,100.22) 169.42,100.04 169.42,98.42 168.76,97.76 168.76,96.88 169.51,96.14 169.51,92.66 170.5,91.66 170.5,89.59 170.93,89.17 170.93,86.9 169.18,85.15 166.47,85.15 165.69,84.37 163.86,84.37 158.53,79.04 158.53,76.4 157.42,75.28 155.3,75.28 154.97,74.95 154.97,73.68 v1(155.23,73.41)
  IN4 w0.076: 148.03,70.92 147.96,70.98 147.96,71.06 147.95,71.07 147.95,72.22 v1(147.58,72.58)
  IN4 w0.084: v1(155.23,73.41) 154.87,73.05 154.02,73.05 153.74,73.34 153.74,74.76 153.66,74.85 147.43,74.85 147.14,74.55 147.14,73.02 147.57,72.58 v1(147.58,72.58)
  IN4 w0.102: v1(167.7,60.53) 167.24,60.53 166.42,61.35 158.98,61.35 152.97,67.35 150.54,67.35 150.12,67.78 150.12,68.01 148.38,69.74 148.38,70.56 148.03,70.92
  BOTTOM w0.089: UC1.CC30 v1(147.58,72.58)
PCH_BATLOW#: length 7.7
  TOP w0.127: v1(145.59,65.76) 145.7,65.76 146.35,65.11 148.24,65.11 RC72.1
  BOTTOM w0.076: UC1.BV36 144.22,67.55 145.59,66.18 v1(145.59,65.76)
PCH_CL_CLK1: length 150.4
  IN1 w0.084: v1(261.62,50.87) 261.26,50.87 260.97,50.58 256.67,50.58 256.05,49.97 255.21,49.97 255.09,49.85 254.23,49.85 252.38,48 249.55,48 248.14,46.59 244.29,46.59 243.79,46.09 242.11,46.09 239.81,43.8 232.5,43.8 231.82,44.48 223.29,44.48 221.99,45.78 217.45,45.78 200.2,63.03 200.2,63.69 199.16,64.73 194.69,64.73 190.76,68.66 190.76,72.36 186.71,76.42 186.71,77.2 185.11,78.8 185.11,79.46 184.74,79.83 182.9,79.83 180.97,81.76 180.97,82.79 178.89,84.88 178.89,86.18 176.18,88.89 172.91,88.89 172.77,89.02 172.19,89.02 172.05,88.89 166.96,88.89 165.36,87.28 162.22,87.28 159.67,84.73 156.18,84.73 155.98,84.53 153.05,84.53 151.88,85.7 151.38,85.7 151.12,85.96 151.12,86.84 v1(150.57,87.4)
  BOTTOM w0.089: v1(150.57,87.4) UC1.CH7
  BOTTOM w0.127: v1(261.62,50.87) 261.35,50.6 261.35,49.84 262.55,48.64 262.55,45.15 263.57,44.13 JNGFF1.42
PCH_CL_DATA1: length 147.1
  IN1 w0.084: v1(261.81,50.1) 259.13,50.1 258.53,49.5 255.41,49.5 255.22,49.32 254.36,49.32 252.57,47.54 249.74,47.54 248.34,46.13 244.48,46.13 243.98,45.63 243.51,45.63 241.21,43.33 232.31,43.33 231.63,44.01 223.09,44.01 221.8,45.31 217.26,45.31 198.81,63.77 194.99,63.77 190.29,68.47 190.29,72.17 186.24,76.22 186.24,77.01 185,78.25 184.88,78.25 183.76,79.36 182.71,79.36 180.5,81.57 180.5,82.6 177.72,85.38 177.72,86.52 177.69,86.54 177.69,86.56 176.11,88.14 166.93,88.14 165.61,86.82 162.14,86.82 161.28,85.96 161.16,85.96 159.77,84.56 156.25,84.56 156.05,84.36 152.98,84.36 151.8,85.53 151.31,85.53 150.93,85.91 150.93,86.68 150.84,86.77 v1(150.57,86.77)
  BOTTOM w0.089: v1(150.57,86.77) UC1.CH8
  BOTTOM w0.127: v1(261.81,50.1) 263.05,48.85 263.05,45.36 263.79,44.63 JNGFF1.40
PCH_CL_RST1#: length 152.1
  IN1 w0.084: v1(267.02,48.93) 267.02,49.54 266.79,49.77 262.7,49.77 262.45,49.52 259.21,49.52 258.73,49.04 255.69,49.04 255.47,48.82 254.51,48.82 252.74,47.05 250.01,47.05 248.62,45.66 244.67,45.66 244.18,45.17 243.7,45.17 241.4,42.87 232.12,42.87 231.44,43.55 222.9,43.55 221.6,44.85 217.07,44.85 198.61,63.3 194.8,63.3 189.77,68.34 189.77,70.34 185.78,74.33 185.78,76.81 184.88,77.71 184.76,77.71 183.57,78.9 182.52,78.9 180.04,81.38 180.04,82.41 178.76,83.69 177.79,83.69 176.94,84.54 176.94,86.65 175.92,87.67 174.55,87.67 173.57,86.7 171.84,86.7 171.63,86.48 170.57,86.48 169.77,85.69 165.11,85.69 164.83,85.96 161.86,85.96 161.68,85.78 161.23,85.78 159.84,84.39 156.32,84.39 156.12,84.18 152.91,84.18 151.81,85.27 151.32,85.27 150.63,85.97 150.63,86.07 v1(150.57,86.13)
  BOTTOM w0.089: v1(150.57,86.13) UC1.CH9
  BOTTOM w0.127: v1(267.02,48.93) 267.47,48.48 267.47,47.71 267.28,47.52 267.28,46.36 266.88,45.97 266.42,45.97 265.59,45.13 JNGFF1.38
PCH_DPWROK: length 265.7
  TOP w0.127: v1(264.62,86.57) 264.32,86.27 RE536.1 ; RC215.1 167.66,55.6 v1(167.66,54.98) v3(167.66,54.44) ; CC266.1 RC220.1 v1(166.84,57.1)
  IN1 w0.084: v1(289.19,87.87) 289.05,88.01 285.89,88.01 285.42,87.54 284.3,87.54 284.07,87.76 283.33,87.76 283.27,87.7 280.03,87.7 279.82,87.91 279.04,87.91 278.88,87.75 277.58,87.75 277.38,87.95 276.62,87.95 275.79,87.12 273.41,87.12 273.18,87.35 272.87,87.35 272.65,87.13 272.65,86.71 272.52,86.58 271.72,86.58 271.54,86.76 270.64,86.76 270.25,87.15 265.51,87.15 264.93,86.57 v1(264.62,86.57)
  IN2 w0.089: 142.99,59.42 142.99,67.06 142.15,67.91 142.15,71.42 142.47,71.75 142.47,72.22 v1(142.11,72.58)
  IN2 w0.122: v1(167.66,54.98) 167.66,55.54 166.89,56.32 166.89,57.06 v1(166.84,57.1) 166.37,57.1 165.14,55.87 157.54,55.87 156.3,54.63 155.49,54.63 154.15,55.97 144.88,55.97 142.99,57.86 142.99,59.42
  IN4 w0.084: v1(289.19,87.87) 289.23,87.83 289.23,85.89 288.87,85.53 288.87,84.17 288.87,84.17 288.87,78.93 287.93,77.98 287.93,74.17 287.56,73.8 287.56,73.19 288.36,72.39 288.36,72.13 288.42,72.07 289.06,72.07 289.24,71.88 289.24,71.54 289.59,71.19 289.59,70.7 289.39,70.49 289.39,69.18 290.9,67.67 290.9,64.71 290.6,64.41 290.6,63.29 290.84,63.05 291.28,63.05 291.92,62.41 291.92,57.53 290.52,56.13 288.93,56.13 288.65,56.41 287.44,56.41 286.77,55.74 283.53,55.74 282.36,54.58 280.91,54.58 280.49,54.16 277.87,54.16 277.23,53.51 272.47,53.51 271.92,52.96 269.76,52.96 267.43,50.63 267.43,48.55 265.68,46.8 260.56,46.8 260.03,46.27 260.03,44.02 262.26,41.79 262.26,38.99 258.74,35.47 258.24,35.47 255.38,32.61 239.13,32.61 238,33.74 231.17,33.74 230.3,32.86 224.85,32.86 224.12,33.59 220.74,33.59 219.27,35.06 216,35.06 213.24,37.83 211.34,37.83 208.47,40.7 208.1,40.7 198.38,50.42 195.73,50.42 195.3,49.99 191.9,49.99 183.82,58.06 174.51,58.06 174.06,57.61 170.41,57.61 169.93,57.13 168.4,57.13 168,56.73 167.22,56.73 v1(166.84,57.1)
  BOTTOM w0.089: UC1.BP30 v1(142.11,72.58)
PCH_DPWROK_EC: length 14.2
  TOP w0.127: UE1.F8 276.62,83.37 v1(276.2,83.79) ; RE536.2 265.06,85.46 v1(265.61,85.46) 265.8,85.27 v2(265.8,84.7)
  IN1 w0.084: v1(265.61,85.46) 265.74,85.6 267.64,85.6 267.89,85.35 269.86,85.35 270,85.21 270.84,85.21 271.81,84.24 272.82,84.24 273.76,83.3 274.07,83.3 274.08,83.31 275.98,83.31 276.2,83.53 v1(276.2,83.79)
PCH_HDD_EN: length 18.8
  TOP w0.127: v1(165.72,81.82) 165.72,82.13 T421.1
  IN1 w0.102: v1(149.59,82.66) 150.04,83.11 151.59,83.11 151.97,82.74 152.47,82.74 153.55,81.65 156.72,81.65 156.78,81.59 162.07,81.59 162.44,81.22 165.12,81.22 v1(165.72,81.82)
  BOTTOM w0.089: v1(149.59,82.66) 149.56,82.74 UC1.CG14
PCH_JTAG_TCK: length 75
  TOP w0.127: v3(103.96,93.91) 103.77,94.1 v1(103.77,94.55) 103.77,94.8 103.42,95.14 RC86.1
  IN2 w0.122: v1(103.77,94.55) 103.96,94.35 103.96,94.17 103.83,94.04 102.18,94.04 101.2,95.02 99.83,95.02 98.61,96.24 93.99,96.24 93.31,96.92 79.05,96.92 78.72,96.59 71.68,96.59 71.37,96.28 67.48,96.28 66.46,95.25 64.32,95.25 63.83,94.77 61.2,94.77 60.67,95.3 59.33,95.3 57.85,96.77 57.85,97.78 58.11,98.04 v1(58.24,98.04)
  IN4 w0.076: 110.24,91.81 110.24,91.47 110.63,91.08 111.01,91.08 111.33,91.39 112.83,91.39 112.83,91.39 117.16,91.39 119.62,88.93 119.62,88.5 v1(120.08,88.04)
  IN4 w0.084: v1(103.77,94.55) 104.05,94.83 107.34,94.83 110.24,91.93 110.24,91.81
  BOTTOM w0.089: v1(120.08,88.04) 119.7,87.85 UC1.W6
  BOTTOM w0.127: v1(58.24,98.04) 58.11,98.04 57.68,97.61 JXDP1.55
PCH_JTAG_TDI: length 74.7
  TOP w0.127: v1(103.13,94.55) 103.13,94.67 102.62,95.18 CC304.1 RC569.1 ; v1(58.87,98.04) 58.87,98.52 v3(58.27,99.12) 58.18,99.21 58.18,100.67 58.47,100.95 58.47,101.6 58.3,101.77 RC736.2
  IN2 w0.122: v1(103.13,94.55) 100.82,96.85 99.64,96.85 97.4,99.09 91.46,99.09 89.79,97.42 87.53,97.42 87.43,97.52 78.3,97.52 78.19,97.63 76.54,97.63 76,98.16 74.17,98.16 73.73,97.72 66.52,97.72 65.5,96.7 60.71,96.7 59.38,98.04 v1(58.87,98.04)
  IN4 w0.076: v1(119.16,88.67) 119.16,89.07 119.1,89.13 117.01,91.21 112.75,91.21 111.4,91.21 111.07,90.88 109.73,90.88 109.3,91.31
  IN4 w0.102: v1(103.13,94.55) 103.13,94.48 103.54,94.07 104.19,94.07 104.48,94.36 107.56,94.36 109.3,92.62 109.3,91.31
  BOTTOM w0.089: v1(119.16,88.67) UC1.U5
PCH_JTAG_TDO: length 76.8
  TOP w0.127: RC568.1 CC303.1 101.82,97.38 102.05,97.15 v1(102.05,96.42) ; RC737.2 59.61,102.13 59.09,102.13 58.7,101.74 58.7,100.86 58.41,100.57 58.41,99.65 59.65,98.42 v3(59.65,98.06) 59.65,97.95 59.9,97.7 61.12,97.7 61.69,97.13 v1(62.18,97.13)
  IN2 w0.122: v1(102.05,96.42) 101.4,97.08 99.73,97.08 96.96,99.84 91.89,99.84 89.7,97.64 87.76,97.64 87.65,97.76 78.59,97.76 78.5,97.85 76.63,97.85 76.1,98.38 74.08,98.38 73.7,98.01 65.67,98.01 65.44,97.78 62.83,97.78 v1(62.18,97.13)
  IN4 w0.076: 110.42,91.77 110.42,91.52 110.65,91.29 110.98,91.29 111.25,91.57 112.9,91.57 117.23,91.57 117.25,91.55 118.04,91.55 119.52,90.07 119.59,90.07 120.08,89.58 v1(120.08,88.67)
  IN4 w0.102: v1(102.05,96.42) 103.17,95.31 107.99,95.31 109.84,93.46 109.84,93.01 110.42,92.42 110.42,91.77
  BOTTOM w0.089: v1(120.08,88.67) 119.7,88.5 UC1.W5
PCH_JTAG_TMS: length 78.9
  TOP w0.127: RC735.2 56.92,102.77 57.15,103 57.58,103 57.93,102.65 v1(57.93,102.56) ; v3(107.68,93.58) 107.76,93.49 v1(107.76,93.05)
  IN2 w0.122: v1(57.93,102.56) 57.93,102.84 58.05,102.97 58.76,102.97 58.88,102.84 58.88,102.59 59,102.47 60.23,102.47 61.29,101.41 70.63,101.41 71.31,100.73 77.08,100.73 77.61,100.2 80.23,100.2 81.06,101.03 94.12,101.03 95.13,102.04 99.39,102.04 100.69,100.74 103.43,100.74 103.58,100.58 105.01,100.58 105.56,100.04 105.56,99.78 105.56,95.29 106.18,94.67 107.19,94.67 107.76,94.1 v1(107.76,93.05)
  IN4 w0.076: v1(107.76,93.05) 107.98,93.05 108.58,92.44 108.58,90.47 109.4,89.66 112.15,89.66 112.29,89.8 112.31,89.8 112.97,90.46 116.23,90.46
  IN4 w0.084: v1(117.3,88.82) 117.48,89 117.48,89.71 116.74,90.46 116.23,90.46
  BOTTOM w0.076: UC1.P5 116.95,88.47 v1(117.3,88.82)
  BOTTOM w0.127: RC130.1 106.97,94.52 107.51,93.98 107.51,93.3 v1(107.76,93.05)
PCH_PCIE_WAKE#: length 381.6
  TOP w0.127: v1(46.3,46.1) 46.3,45.29 v2(46.56,45.03) ; RC67.1 v1(157.8,58.79) ; RE274.2 283.58,55.01 284,55.43 284.49,55.43 v1(284.93,54.98) ; UE1.L1 280.62,77.74 v1(281.21,77.15)
  IN1 w0.084: v1(288.22,73.94) 287.82,73.94 286.81,74.95 286.07,74.95 284.99,76.02 284.99,76.43 283.68,77.74 281.97,77.74 281.38,77.15 v1(281.21,77.15)
  IN2 w0.089: 146.01,60.91 144.71,62.21 144.71,68.21 144.3,68.63 144.3,72.11 143.93,72.47 v1(143.93,72.58)
  IN2 w0.122: v1(157.8,58.79) 157.49,58.79 156.5,59.78 147.14,59.78 146.01,60.91 ; v1(46.3,46.1) 46.67,45.73 47.59,45.73 48.93,47.08 57.78,47.08 58.82,48.11 62.76,48.11 63.18,47.69 79.41,47.69 82.95,51.24 141.24,51.24 143.78,48.7 145.91,48.7 146.74,49.53 147.52,49.53 147.9,49.9 148.81,49.9 149.5,49.22 151.5,49.22 151.83,48.89 155.14,48.89 157.86,51.61 164.34,51.61 164.61,51.89 164.61,53.67 164.93,53.99 166.27,53.99 166.98,54.7 v1(166.98,54.95)
  IN4 w0.084: v1(288.22,73.94) 288.64,73.53 289.19,73.53 289.78,72.93 289.78,71.76 290.13,71.41 290.13,70.47 289.93,70.27 289.93,69.4 290.57,68.76 290.91,68.76 293.89,65.78 293.89,64.13 294.45,63.57 294.45,62.8 292.66,61.01 292.66,57.35 290.61,55.3 287.09,55.3 286.99,55.2 285.15,55.2 v1(284.93,54.98) 284.55,54.6 283.85,54.6 283.28,54.04 281.13,54.04 280.71,53.61 278.09,53.61 277.45,52.97 272.7,52.97 271.9,52.17 269.74,52.17 268.01,50.45 268.01,48.36 265.9,46.25 260.78,46.25 260.57,46.05 260.57,44.25 263.12,41.7 263.12,39.08 258.93,34.89 258.43,34.89 255.61,32.07 238.91,32.07 237.78,33.19 231.4,33.19 230.52,32.32 224.62,32.32 223.89,33.05 220.52,33.05 219.05,34.52 215.78,34.52 213.01,37.29 211.11,37.29 209.42,38.98 209.05,38.98 200.91,47.12 192.88,47.12 188.56,51.43 188.56,51.79 183.37,56.98 174.96,56.98 174.51,56.53 170.86,56.53 170.38,56.05 168.85,56.05 168.28,55.49 168.28,54.79 168.03,54.54 167.26,54.54 166.98,54.82 v1(166.98,54.95) 166.98,55.15 166.11,56.01 159.09,56.01 157.8,57.3 v1(157.8,58.79)
  BOTTOM w0.089: UC1.BU30 v1(143.93,72.58)
  BOTTOM w0.127: RT445.1 39.74,62.3 39.74,61.45 39.01,60.71 39.01,58.55 38.68,58.22 38.68,55.49 39.76,54.41 39.76,51.68 39.69,51.62 39.69,50.48 42.07,48.1 44.66,48.1 46.3,46.46 v1(46.3,46.1)
PCH_PLTRST#: length 95.5
  TOP w0.127: 197.32,74.97 197.31,74.99 RC237.1 194.99,75.69 193.81,75.69 193.11,74.99 v2(193.11,74.91) 193.11,71.62 193.68,71.05 193.68,69.07 v1(194.49,68.26) ; 197.32,74.97 197.73,74.97 RC60.1 ; 197.32,74.97 197.32,74.57 197.15,74.39 UC7.1 197.15,73.65 196.99,73.49 196.66,73.49 196.5,73.65 UC7.2
  BOTTOM w0.076: UC1.BJ35 138.75,69.61 138.75,69.39 138.79,69.28 138.79,69.09 138.75,68.98 138.75,68.74 138.83,68.53 138.83,67.42 139.25,67 139.25,62.18 139.56,61.86 141.4,61.86 141.8,61.46 144.56,61.46 145.91,60.11 145.91,58.86
  BOTTOM w0.127: v1(194.49,68.26) 194.49,65.38 190.68,61.58 186.24,61.58 184.87,60.2 184.87,59.15 181.05,55.34 180.62,55.34 180.3,55.02 180.3,54.51 180.04,54.24 178.93,54.24 178.63,54.54 178.63,55.33 176.82,57.14 175.08,57.14 174.14,56.2 163.28,56.2 162.69,55.62 162.69,54.29 162.25,53.84 156.89,53.84 155.01,55.72 151.33,55.72 149.82,57.23 147.08,57.23 145.91,58.41 145.91,58.41 145.91,58.86
PCH_PLTRST#_AND: length 505
  TOP w0.127: CC196.1 RC65.1 195.4,72.61 195.72,72.61 195.85,72.48 UC7.4 195.85,70.64 196.02,70.47 198.06,70.47 198.21,70.63 RC738.1 199.41,71.86 199.54,71.73 199.54,67.19 200.87,65.85 200.87,61.75 198.58,59.46 192.8,59.46 v1(192.37,59.04) ; v1(288.31,67.48) 288.31,68.1 288.61,68.41 289.37,68.41 289.84,67.94 UR1.1 ; v1(21.3,44.41) 21.05,44.66 21.05,45.5 21.65,46.09 RT492.1 RT496.1 v2(21.68,47.77)
  IN1 w0.076: JNGFF3.50 21.63,20.91
  IN1 w0.084: v1(32.17,44.89) 32.14,44.89 31.18,43.94 31.18,43.11 30.24,42.17 30.24,35.25 30.55,34.94 30.55,33.78 29.84,33.07 27.6,33.07 26.87,32.33 26.87,31.17 25.28,29.58 22.43,29.58 20.24,27.39 19.5,27.39 18.8,26.69 18.8,23.49 19.82,22.47 20.64,22.47 21.07,22.05 21.07,22.03 21.63,21.47 21.63,20.91 ; v1(261.89,41.4) 261.57,41.71 258.64,41.71 258.45,41.52 257.44,41.52 256.98,41.98 252.56,41.98 251.26,40.68 247.62,40.68 246.27,39.33 244.74,39.33 244.6,39.48 243.32,39.48 243.16,39.32 229.27,39.32 228.64,38.7 221.61,38.7 219.21,41.1 215.92,41.1 198,59.03 195.73,59.03 195.3,59.46 192.8,59.46 v1(192.37,59.04)
  IN2 w0.122: v1(192.37,59.04) 192.28,58.95 191.86,58.95 191.28,58.36 191.28,57.29 188.83,54.85 186.29,54.85 184.87,53.42 184.87,50.95 182.29,48.37 158.66,48.37 156.3,46.01 146.11,46.01 145.65,46.48 139.07,46.48 136.05,49.5 83.86,49.5 80.31,45.96 59.12,45.96 58.5,45.34 53.44,45.34 52.1,43.99 45.09,43.99 v1(42.96,46.13) ; v1(89.16,110.99) 89.15,110.99 89.15,110.8 88.34,109.99 87.88,109.99 87.05,109.17 82.46,109.17 82.1,108.81 80.18,108.81 79.94,108.58 67.13,108.58 67.08,108.52 66.09,108.52 63.04,105.48 62.25,105.48 61.7,106.02 61.07,106.02 60.54,106.54 54.03,106.54 52.48,105 52.48,104.39 48.81,100.72 47.76,100.72 45.69,98.65 45.69,97.47 45.38,97.15 42.2,97.15 41.37,96.32 41.37,95.82 39.53,93.97 38.87,93.97 38.42,93.53 38.42,91.75 39.06,91.12 39.06,87.13 41.77,84.41 41.77,77.65 40.27,76.14 40.27,68.76 37.05,65.55 37.05,63.49 36.4,62.84 36.4,52.73 35.7,52.04 35.7,48.95 33.57,46.81 33.57,45.56 32.9,44.89 v1(32.17,44.89) ; v1(271.65,48.9) 271.77,48.9 273.4,50.53 273.4,52.44 273.64,52.68 274.13,52.68 275.19,53.74 276.95,53.74 277.5,54.29 277.5,55.98 279.01,57.49 v1(279.01,57.98)
  IN4 w0.084: v1(21.3,44.41) 21.79,44.89 v1(32.17,44.89) 32.55,44.51 35.5,44.51 35.81,44.82 35.82,44.82 36.26,45.26 36.26,45.27 36.71,45.71 36.71,45.71 37.12,46.13 v1(42.96,46.13)
  BOTTOM w0.127: v1(261.89,41.4) 262.33,40.95 262.96,40.95 263.64,41.63 JNGFF1.52 265.54,41.63 265.94,42.03 268.5,42.03 269.35,42.88 269.35,44.53 269.77,44.95 269.77,48.18 270.49,48.9 271.64,48.9 v1(271.65,48.9) ; v1(89.16,110.99) 88.65,110.99 88.32,111.32 JIRTS1.1 ; v1(279.01,57.98) 278.52,58.47 278.52,59.11 277.98,59.65 277.27,59.65 277.06,59.86 277.06,61.18 279.43,63.55 JNGFF2.50 279.43,65.17 279.72,65.46 279.72,68.08 280.21,68.57 280.52,68.57 281.56,69.61 282.91,69.61 283.09,69.44 285.21,69.44 286.76,67.89 287.88,67.89 288.29,67.48 v1(288.31,67.48)
PCH_POPIRCOMP: length 1.3
  TOP w0.381: v1(144.98,75.32) 145.76,75.32 RC107.1
  BOTTOM w0.2: UC1.BW25 144.96,75.32 v1(144.98,75.32)
PCH_PRIM_EN: length 173.7
  TOP w0.127: RC441.2 RC442.2 172.05,54.83 172.35,54.54 175.39,54.54 177.74,52.19 179.39,52.19 180.32,53.11 v1(180.32,53.22) ; RZ64.1 184.93,96.5 184.35,97.09 184.35,100.13 185.81,101.59 185.81,102.42 185.93,102.55 ; PR406.1 177.13,23.77 v2(177.34,23.97) v1(177.34,24.92)
  TOP w0.254: v1(197.36,104.58) 196.41,104.58 195.27,103.44 194.06,103.44 192.47,101.85 189.78,101.85 189.08,102.55 185.93,102.55 184.51,103.98 v1(179.74,103.98) 179.71,104.01 179.06,104.01 PR504.1
  IN2 w0.122: v1(185.76,25.4) 185.92,25.24 185.92,24.32 185.69,24.09 177.68,24.09 177.34,24.43 v1(177.34,24.92) ; v1(174.38,100.07) 174.38,100.07 174.5,100.2 175.96,100.2 v1(179.74,103.98)
  IN3 w0.122: v1(174.38,100.07) 175.01,100.07 175.82,99.26 175.82,96.01 176.46,95.36 176.46,92.95 178.49,90.92 178.49,89.15 179.93,87.71 179.93,86.59 180.02,86.5 180.02,85.44 182.81,82.65 182.81,81.78 185.95,78.64 185.95,76.78 188.61,74.12 188.61,73.16 188.28,72.83 188.28,71.84 188.97,71.15 188.97,60.1 v1(188.26,59.39)
  IN4 w0.084: v1(180.32,53.22) 181.33,53.22 181.74,52.81 181.74,51.58 181.1,50.94 181.1,49.93 188.3,42.73 188.92,42.73 190.37,41.28 190.37,40 192.79,37.58 192.79,32.96 191.06,31.22 182.15,31.22 180.92,29.99 180.92,29.66 v1(180.37,29.12)
  BOTTOM w0.127: v1(188.26,59.39) 188.64,59.39 188.92,59.11 188.92,57.52 186.24,54.85 181.94,54.85 v1(180.32,53.22) ; v1(185.76,25.4) 185.08,26.08 185.08,28.73 184.56,29.25 180.51,29.25 v1(180.37,29.12)
  BOTTOM w0.254: v1(197.36,104.58) 196.68,104.58 196.16,104.06 PR312.1
PCH_PWROK: length 124.1
  TOP w0.127: v1(58.38,56.93) 58.62,56.93 PR614.1 ; v3(151.02,50.95) 151.54,51.46 v1(151.63,51.46) 151.72,51.37 RC536.1
  IN2 w0.089: v1(142.11,71.95) 141.56,71.4 141.56,67.82 140.63,66.9 140.63,59.42
  IN2 w0.122: 140.63,59.42 140.63,54.19 141.49,53.34 ; v1(58.38,56.93) 60.13,55.18 60.13,52.8 61.46,51.48 61.74,51.48 63.87,49.35 78.72,49.35 82.26,52.9 141.05,52.9 141.49,53.34 ; v1(151.63,51.46) 151.23,51.07 150,51.07 149.29,51.78 146.64,51.78 145.22,50.36 144.47,50.36 141.49,53.34
  BOTTOM w0.089: UC1.BP31 v1(142.11,71.95)
PCH_RSMRST#: length 242.9
  TOP w0.127: RE342.1 286.11,79.7 v1(285.86,79.7) 285.47,79.31 284.68,79.31 283.49,80.49 281.88,80.49 UE1.M5 ; RZ400.1 v1(179.77,58.6) 180.18,58.6 v2(180.41,58.83) ; v1(300.53,11.78) 300.53,10.03 RZ1413.2
  IN3 w0.122: v1(300.53,11.78) 300.53,24.71 294.18,31.06 287.27,31.06 286.59,31.74 284.24,31.74 278.78,37.19 278.78,45.6 280.87,47.69 280.87,47.7 281.05,47.87 282.33,47.87 282.78,48.33 282.78,49.41 282.78,49.41 282.78,49.91 283.49,50.63 283.67,50.63 285.14,50.63 285.49,50.97 287.21,50.97 289.69,53.46 289.69,56.13 290.14,56.57 v1(290.14,56.7)
  IN4 w0.084: v1(179.77,58.6) 184.05,58.6 192.12,50.53 195.08,50.53 195.51,50.96 198.61,50.96 208.32,41.24 208.69,41.24 211.56,38.37 213.46,38.37 216.23,35.6 219.5,35.6 220.96,34.13 224.34,34.13 225.07,33.4 230.08,33.4 230.95,34.28 238.23,34.28 239.35,33.15 255.16,33.15 258.07,36.06 258.57,36.06 261.72,39.21 261.72,41.04 259.49,43.27 259.49,46.5 260.67,47.68 262.02,47.68 264.14,49.8 266.1,49.8 266.48,50.19 266.48,50.45 269.54,53.51 271.64,53.51 272.19,54.05 277,54.05 277.64,54.7 280.26,54.7 280.89,55.32 282.34,55.32 283.31,56.29 286.55,56.29 287.21,56.95 289.25,56.95 289.5,56.7 v1(290.14,56.7) 290.26,56.7 290.53,56.97 290.53,60.79 290.11,61.21 290.11,62.25 289.51,62.84 289.51,64.37 289.24,64.65 289.24,67.69 288.29,68.64 288.29,70.02 287.54,70.77 287.22,70.77 286.19,71.8 286.19,72.65 285.79,73.05 285.79,73.88 286.65,74.73 286.65,74.73 286.65,75.65 286.85,75.84 286.85,78.72 v1(285.86,79.7)
PCH_RSMRST#_AND: length 257.7
  TOP w0.127: RC215.2 167.67,56.93 v1(167.84,57.1) ; RC75.1 144.99,64.57 v1(144.16,65.4) ; v1(63.48,95.29) 63.47,95.3 63.47,96.17 63.44,96.2 63.44,96.62 63.41,96.65 RC124.1 ; UZ6.4 177.16,54.6 178.12,55.56 178.81,55.56 178.81,55.56 v1(178.95,55.56) ; v1(45.9,45.52) v2(45.09,45.52)
  IN2 w0.122: v1(45.9,45.52) 46.27,45.15 47.83,45.15 49.17,46.5 58.02,46.5 59.06,47.53 62.52,47.53 62.94,47.11 79.65,47.11 83.19,50.66 141,50.66 143.54,48.12 147.38,48.12 147.79,48.53 147.79,48.98 148.14,49.33 148.57,49.33 149.26,48.64 151.26,48.64 151.74,48.16 155.23,48.16 157.61,50.54 v1(161.68,50.54) 164.6,50.54 165.97,51.9 165.97,52.87 167.22,54.12 167.98,54.12 168.24,54.38 168.24,55.78 167.47,56.56 167.47,56.73 v1(167.84,57.1) 168,57.26 168.17,57.26 168.92,56.51 169.33,56.51 170.17,57.34 170.17,57.84 169.72,58.29 169.72,59.04 170.62,59.94 172.16,59.94 172.83,59.26 173.14,59.26 173.68,58.73 173.68,57.17 175.9,54.94 177.26,54.94 177.87,55.56 v1(178.95,55.56)
  IN4 w0.084: v1(63.48,95.29) 62.78,94.59 58.97,94.59 58.06,93.69 56.36,93.69 54.26,91.59 54.26,89.37 53.82,88.93 53.82,86.25 52.34,84.78 52.34,82.7 47.64,78 47.64,77.16 44.88,74.39 44.56,74.39 42.79,72.62 42.79,66.87 43.43,66.24 43.43,65.41 43.26,65.24 43.26,58.86 43.53,58.58 43.53,57.04 43.38,56.89 43.38,52.83 43.28,52.73 43.28,51.52 42.85,51.1 42.85,49.89 43.88,48.86 44.71,48.86 45.52,48.05 45.52,46.75 45.9,46.37 v1(45.9,45.52) ; v1(144.16,65.4) 145.28,64.28 145.28,61.92 145.99,61.21 145.99,56.19 146.24,55.94 148.89,55.94 149.9,54.93 149.9,53.3 151.2,52 151.2,51.19 151.61,50.77 153.61,50.77 154.08,50.3 157.64,50.3 157.88,50.54 v1(161.68,50.54)
  BOTTOM w0.076: UC1.BR36 142.35,69.13 142.61,68.65 142.61,68.35 142.44,68.17 142.44,67.66 143.66,66.43 143.66,66.29
  BOTTOM w0.114: 143.66,66.29 143.66,65.53 143.79,65.4 v1(144.16,65.4)
PCH_RTCRST#: length 319.6
  TOP w0.127: RC57.1 CC25.1 154.25,53.85 CMOS1.1 155.38,53.88 155.55,53.71 156.07,53.71 v1(156.08,53.7) ; v1(264.93,87.09) 263.25,87.09 262.63,86.47 RE94.2 262.36,85.01 v3(262.36,83.71)
  IN1 w0.084: v1(287.41,31.68) 287.28,31.55 280.99,31.55 278.64,33.9 v1(277.69,33.9)
  IN2 w0.122: v1(264.93,87.09) 265.35,87.52 265.35,90.54 267.09,92.28 267.09,92.64 267.79,93.35 278.71,93.35 279.41,92.65 286.68,92.65 288.34,90.99 290.01,90.99 v1(290.9,90.1)
  IN4 w0.084: v1(290.9,90.1) 290.04,89.24 290.04,88.91 290.52,88.43 290.52,86.29 290.93,85.88 290.93,83.58 291.51,83 291.51,80.53 291,80.01 291,79.13 289.65,77.78 289.65,75.43 290.36,74.73 290.97,74.73 291.17,74.52 294.9,74.52 295.2,74.22 295.2,73.82 294.44,73.06 294.44,71.79 294.15,71.5 294.15,68.21 294.34,68.02 294.34,67.52 295.99,65.87 295.99,62.15 295.06,61.22 295.06,57.53 291.98,54.45 291.98,53.74 290.95,52.71 290.38,52.71 289.82,53.27 288.17,53.27 287.79,53.65 285.25,53.65 284.55,52.95 281.58,52.95 281.16,52.53 278.54,52.53 277.9,51.89 276.95,51.89 275.87,50.82 273.16,50.82 272.89,51.09 270.18,51.09 269.12,50.02 269.12,50 269.09,49.98 269.09,47.9 269.1,47.9 269.1,45.46 267.61,43.97 266.68,43.97 265.81,43.1 265.81,41.97 264.99,41.16 264.99,38.15 265.93,37.2 266.45,37.2 267.98,35.68 268.83,35.68 269.53,34.98 269.88,34.98 270.06,34.8 v1(270.06,34.46) 270.06,33.83 269.25,33.01 262.39,33.01 262.15,33.25 259.64,33.25 258.94,32.55 257.86,32.55 257.78,32.47 257.78,31.9 257.24,31.36 256.86,31.36 256.1,30.6 251.53,30.6 250.67,29.74 248.06,29.74 247.57,29.25 240.15,29.25 238.32,31.07 224.34,31.07 223.45,31.97 220.07,31.97 218.6,33.44 215.33,33.44 212.56,36.2 210.67,36.2 209.43,37.44 208.41,37.44 206.29,39.55 200.27,45.57 192.23,45.57 187.02,50.79 187.02,51.15 183.34,54.82 182.03,54.82 181.77,54.57 181.36,54.57 181.06,54.27 180.18,54.27 179.61,53.7 178.88,53.7 178.22,53.05 176.28,53.05 175.48,53.85 172.05,53.85 171.68,53.47 171.54,53.34 169.08,50.87 162.45,50.87 161.99,51.33 158.45,51.33 v1(156.08,53.7) 155.84,53.46 150.95,53.46 150.44,53.97 150.44,55.16 149.11,56.49 147.01,56.49 146.53,56.96 146.53,60.91 145.48,61.97 145.48,64.62 v1(144.13,65.96)
  BOTTOM w0.076: v1(144.13,65.96) 144.13,66.2 142.6,67.73 142.6,68.11 142.78,68.28 142.78,68.69 142.65,68.91 142.65,69.86 UC1.BR34
  BOTTOM w0.127: v1(270.06,34.46) 270.13,34.53 271.25,34.53 272.08,35.36 275.79,35.36 275.98,35.55 276.74,35.55 277.36,34.93 277.36,34.23 v1(277.69,33.9) ; v1(287.41,31.68) 287.8,32.07 293.74,32.07 294.45,31.37 JAPS1.9
