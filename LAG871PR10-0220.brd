# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA7: length 79.2
  IN1 w0.076: v1(122,73.22) 121.69,72.92 121.69,71.04
  IN1 w0.089: 121.69,71.04 121.69,67.9 121.15,67.36 121.15,66.35 120.57,65.77 120.57,64.07 120.23,63.74 120.23,58.47 119.72,57.96
  IN1 w0.102: v1(164.7,33.71) 163.61,34.81 163.61,36.63 161,39.23 160.22,39.23 159.48,39.97 158.38,39.97 157.04,41.32 138.92,41.32 138.54,40.94 137.15,40.94 136.33,40.11 133.61,40.11 119.72,54 119.72,57.96
  BOTTOM w0.089: UC1.AC29 122.47,73.49 v1(122,73.22)
  BOTTOM w0.15: v1(164.7,33.71) 165.19,33.22 165.19,32.28 164.9,32 JDIMM2.122
DDR_B_MA8: length 78.4
  IN1 w0.085: v1(122.86,64.77) 121.54,64.77 121.45,64.68
  IN1 w0.089: 121.45,64.68 120.44,63.66 120.44,58.37 120.09,58.03
  IN1 w0.102: v1(164.7,36.76) 164.47,36.53 164.47,36.31 164.37,36.21 164.08,36.21 163.98,36.31 163.98,36.78 163.83,36.93 163.83,37.07 164.05,37.29 164.05,37.43 163.9,37.58 163.76,37.58 163.54,37.36 163.4,37.36 163.26,37.5 163.26,37.65 163.47,37.86 163.47,38.01 163.33,38.15 163.18,38.15 162.97,37.93 162.82,37.93 161.16,39.6 160.89,39.6 160.46,40.03 160.32,40.03 160.2,39.92 160.06,39.92 159.92,40.06 159.92,40.2 160.03,40.32 160.03,40.46 159.54,40.95 159.02,40.95 158.92,40.85 158.92,40.44 158.81,40.34 158.61,40.34 158.51,40.44 158.51,40.85 158.41,40.95 157.93,40.95 157.19,41.68 138.76,41.68 138.38,41.3 137,41.3 136.64,40.95 136.23,40.95 136.13,40.85 136.13,40.58 136.03,40.48 135.83,40.48 135.72,40.58 135.72,40.85 135.62,40.95 134.71,40.95 134.61,40.85 134.61,40.58 134.51,40.48 134.3,40.48 134.2,40.58 134.2,40.85 134.1,40.95 133.3,40.95 120.09,54.16 120.09,58.03
  BOTTOM w0.076: UC1.AE36 123.43,69.13 123.16,68.65 123.16,68.38 123.36,68.18 123.36,67.73 123.19,67.57 123.19,66.85 123.76,66.28 123.76,65.66 122.87,64.77 v1(122.86,64.77)
  BOTTOM w0.15: v1(164.7,36.76) 165.65,37.72 JDIMM2.125
DDR_B_MA9: length 76.2
  IN1 w0.076: 120.77,71.14 120.77,71.15 120.77,72.84 v1(121.15,73.22)
  IN1 w0.089: 118.98,57.87 119.82,58.7 119.82,63.87 120.15,64.21 120.15,67.18 120.77,67.8 120.77,71.14
  IN1 w0.102: 118.98,57.87 118.98,53.7 133.31,39.38 137.32,39.38 137.95,40 156.56,40 157.33,39.24 159.18,39.24 159.92,38.5 160.42,38.5 162.6,36.32 v1(162.86,36.32)
  BOTTOM w0.089: UC1.AB29 v1(121.15,73.22)
  BOTTOM w0.15: JDIMM2.121 164.65,38.12 v1(162.86,36.32)
DDR_B_MA10: length 79.8
  IN1 w0.102: v1(172.2,33.91) 172.99,33.91 173.09,34.01 173.09,34.22 172.99,34.32 172.7,34.32 172.6,34.42 172.6,34.62 172.7,34.72 172.99,34.72 173.09,34.83 173.09,37.91 170.99,40.02 170.99,41.13 165.76,46.35 162.95,46.35 162.13,47.18 160.51,47.18 159.77,47.92 151.55,47.92 151.14,48.34 149.36,48.34 148.94,47.92 147.11,47.92 146.65,48.38 143.09,48.38 142.77,48.7 142.06,48.7 141.67,48.31 136.4,48.31 126.16,58.55 126.16,59.1 125.56,59.71 125.56,63.46 v1(124.65,64.38)
  BOTTOM w0.076: 125.03,64.97 125.03,65.07 125.11,65.14 125.11,67.66 124.96,67.8 124.96,68.12 125.16,68.31 125.16,68.69 125.03,68.92 125.03,69.86 UC1.AG34
  BOTTOM w0.089: 125.03,64.97 125.03,64.76 v1(124.65,64.38)
  BOTTOM w0.15: JDIMM2.146 172.91,31.89 172.81,31.98 171.65,31.98 171.5,32.13 171.5,33.21 v1(172.2,33.91)
DDR_B_MA11: length 80
  IN1 w0.076: v1(122.06,73.85) 121.54,73.33 121.54,71.08 121.43,70.97
  IN1 w0.089: 121.43,70.97 121.43,67.9 120.93,67.4 120.93,66.47 120.38,65.91 120.38,64.14 120.02,63.79 120.02,58.52 119.35,57.85
  IN1 w0.102: 119.35,57.85 119.35,53.85 133.46,39.74 137.17,39.74 137.8,40.37 138.49,40.37 139.07,40.95 156.89,40.95 158.23,39.6 159.33,39.6 160.07,38.87 160.58,38.87 162.74,36.7 163.02,36.7 163.24,36.48 163.24,34.41 v1(162.86,34.03)
  BOTTOM w0.089: UC1.AC28 v1(122.06,73.85)
  BOTTOM w0.15: v1(162.86,34.03) 163.97,32.92 163.97,32.33 164.41,31.9 JDIMM2.120
DDR_B_MA12: length 78.5
  IN1 w0.076: 120.61,71.15 120.61,73.31 v1(121.15,73.85)
  IN1 w0.089: 120.61,71.15 119.79,70.33 119.79,66.17 118.89,65.26 118.89,58.93 118.62,58.66
  IN1 w0.102: v1(161.09,36.32) 161.58,36.32 161.68,36.42 161.68,36.72 161.58,36.82 161.03,36.82 160.65,37.21 160.65,37.69 160.21,38.13 159.76,38.13 159.02,38.87 157.18,38.87 156.41,39.64 138.1,39.64 137.47,39.01 133.15,39.01 118.62,53.55 118.62,58.66
  BOTTOM w0.089: UC1.AB28 v1(121.15,73.85)
  BOTTOM w0.15: v1(161.09,36.32) 162.16,36.32 164.16,38.32 JDIMM2.119
DDR_B_MA13: length 79.5
  IN1 w0.102: v1(175.29,33.93) 173.56,33.93 173.46,34.03 173.46,34.23 173.56,34.33 174.28,34.33 174.38,34.43 174.38,34.64 174.28,34.74 173.56,34.74 173.46,34.84 173.46,38.07 171.98,39.54 171.98,40.79 166.06,46.72 163.11,46.72 162.28,47.55 160.67,47.55 159.92,48.29 151.7,48.29 151.29,48.7 149.2,48.7 148.79,48.29 147.26,48.29 146.8,48.75 143.8,48.75 142.99,49.56 141.84,49.56 141.41,49.13 136.1,49.13 126.52,58.71 126.52,59.94 125.75,60.71 125.75,66.1 v1(126.31,66.66)
  BOTTOM w0.076: UC1.AK35 126.69,69.41 126.86,68.95 126.86,68.77 126.82,68.65 126.82,67.54 126.97,67.38 126.97,67.07 126.56,66.66 v1(126.31,66.66)
  BOTTOM w0.15: JDIMM2.158 175.91,33.31 v1(175.29,33.93)
DDR_B_MA14: length 80.4
  IN1 w0.102: v1(126.31,62.21) 127.26,61.26 127.26,59.01 135.98,50.3 143.3,50.3 144.11,49.48 148.44,49.48 148.48,49.44 151.59,49.44 152.01,49.03 160.23,49.03 160.97,48.28 162.59,48.28 163.41,47.46 166.36,47.46 172.95,40.87 172.95,40.35 172.72,40.12 172.72,39.85 172.88,39.69 173.02,39.69 173.53,40.2 173.68,40.2 173.82,40.05 173.82,39.91 173.31,39.4 173.31,39.26 173.46,39.11 173.6,39.11 174.11,39.62 174.25,39.62 174.4,39.48 174.4,39.33 173.89,38.83 173.89,38.68 174.03,38.54 174.18,38.54 174.68,39.05 174.83,39.05 174.97,38.9 174.97,38.76 174.2,37.99 174.2,37.84 174.34,37.7 174.49,37.7 175.03,38.24 175.17,38.24 175.31,38.1 175.31,37.95 174.89,37.52 174.89,37.38 v1(175.29,36.97)
  BOTTOM w0.076: 125.75,64.74 125.75,64.84 125.77,64.86 125.77,67.16 126.21,67.6 126.21,68.63 126.17,68.74 126.17,68.98 126.21,69.09 126.21,69.28 126.04,69.74 UC1.AJ35
  BOTTOM w0.089: 125.75,64.74 125.75,62.78 v1(126.31,62.21)
  BOTTOM w0.15: v1(175.29,36.97) 175.29,36.81 175.04,36.56 174.62,36.56 174.36,36.82 174.36,38.17 174.16,38.37 JDIMM2.151
DDR_B_MA15: length 79.9
  IN1 w0.102: v1(126.31,62.85) 127.63,61.53 127.63,59.17 136.13,50.66 143.45,50.66 144.26,49.85 145.74,49.85 146.25,50.35 148.06,50.35 148.61,49.81 151.75,49.81 152.16,49.39 160.38,49.39 161.12,48.65 162.74,48.65 163.57,47.82 166.57,47.82 175.68,38.71 175.68,35.27 175.78,35.17 176.26,35.17 176.37,35.06 176.37,34.86 176.26,34.76 175.78,34.76 175.68,34.66 175.68,34.45 175.78,34.35 176.14,34.35 176.24,34.25 176.24,34.05 176.14,33.95 175.78,33.95 175.68,33.84 175.68,33.64 175.78,33.54 176.14,33.54 176.24,33.44 176.24,33.24 176.14,33.13 175.78,33.13 175.68,33.03 175.68,32.5 175.58,32.4 v1(175.29,32.4)
  BOTTOM w0.076: UC1.AK34 126.33,69.9 126.33,69.42 126.37,69.3 126.37,69.07 126.33,68.95 126.33,68.77 126.37,68.65 126.37,67.54 125.93,67.1 125.93,64.8 125.92,64.79 125.92,64.69
  BOTTOM w0.089: v1(126.31,62.85) 125.92,63.23 125.92,64.69
  BOTTOM w0.15: JDIMM2.156 175.41,32.29 v1(175.29,32.4)
DDR_B_MA16: length 79.4
  IN1 w0.102: v1(124.65,63.74) 125.37,63.02 125.37,59.63 125.79,59.2 125.79,58.4 136.25,47.94 141.82,47.94 142.21,48.33 142.61,48.33 142.94,48.01 146.5,48.01 146.95,47.55 149.1,47.55 149.51,47.97 150.98,47.97 151.4,47.55 159.62,47.55 160.36,46.81 161.97,46.81 162.8,45.98 165.61,45.98 169.63,41.97 169.63,41.83 169.26,41.46 169.26,41.32 169.41,41.18 169.55,41.18 169.91,41.54 170.06,41.54 170.62,40.98 170.62,40.83 170.22,40.43 170.22,40.27 172.73,37.76 172.73,35.54 172.62,35.44 v1(172.2,35.44)
  BOTTOM w0.076: 125.21,64.91 125.21,65.01 125.27,65.07 125.27,67.36 125.72,67.8 125.72,68.12 125.52,68.31 125.52,68.69 125.65,68.92 125.65,69.87 UC1.AJ34
  BOTTOM w0.089: 125.21,64.91 125.21,64.31 v1(124.65,63.74)
  BOTTOM w0.15: JDIMM2.152 174.41,32 172.34,35.29 v1(172.2,35.44)
DDR_B_ODT0: length 80.4
  IN1 w0.089: 128.36,62.06 v1(126.31,64.12)
  IN1 w0.102: v1(177.33,35.44) 177.33,35.15 177.23,35.05 176.83,35.05 176.72,35.16 176.72,35.43 176.62,35.53 176.15,35.53 176.05,35.64 176.05,35.84 176.15,35.94 176.82,35.94 176.95,36.07 176.95,36.28 176.85,36.38 176.64,36.38 176.54,36.48 176.54,36.68 176.64,36.78 176.85,36.78 176.95,36.89 176.95,38.49 167.3,48.14 167.3,48.84 166.75,49.39 161.42,49.39 160.69,50.13 154.44,50.13 153.97,50.61 149.66,50.61 149.18,51.09 145.94,51.09 145.44,50.59 144.57,50.59 143.75,51.4 136.44,51.4 128.36,59.47 128.36,62.06
  BOTTOM w0.076: 127.05,66.35 127.05,66.45 127.47,66.86 127.47,67.58 127.31,67.73 127.31,68.18 127.51,68.38 127.51,68.65 127.36,68.93 127.25,69.13 UC1.AL36
  BOTTOM w0.089: 127.05,66.35 127.05,64.86 v1(126.31,64.12)
  BOTTOM w0.15: v1(177.33,35.44) 177.1,35.44 175.77,36.77 175.77,37.36 175.16,37.98 JDIMM2.155
DDR_B_ODT1: length 80
  IN1 w0.089: v1(126.31,66.02) 126.74,65.6 126.74,64.12 128.73,62.12
  IN1 w0.102: v1(177.33,37.22) 177.33,38.63 175.71,40.25 175.71,40.38 175.71,40.38 175.89,40.56 175.89,40.77 175.48,41.18 175.34,41.18 175.13,40.97 174.98,40.97 171.69,44.26 171.69,44.41 171.9,44.62 171.9,44.76 171.76,44.9 171.61,44.9 171.41,44.7 171.26,44.7 171.12,44.84 171.12,44.98 171.33,45.19 171.33,45.34 171.18,45.48 171.04,45.48 170.83,45.27 170.69,45.27 170.54,45.41 170.54,45.56 170.75,45.77 170.75,45.91 170.61,46.05 170.46,46.05 170.26,45.85 170.11,45.85 169.97,45.99 169.97,46.13 170.18,46.34 170.18,46.49 170.03,46.63 169.89,46.63 169.68,46.42 169.54,46.42 169.39,46.56 169.39,46.71 169.6,46.92 169.6,47.06 169.46,47.2 169.31,47.2 169.11,47 168.96,47 168.82,47.14 168.82,47.28 169.03,47.49 169.03,47.64 168.88,47.78 168.74,47.78 168.53,47.57 168.39,47.57 168.24,47.71 168.24,47.86 168.45,48.07 168.45,48.21 168.31,48.35 168.16,48.35 167.96,48.15 167.81,48.15 167.67,48.29 167.67,48.43 167.88,48.64 167.88,48.79 166.9,49.76 161.58,49.76 160.84,50.5 155.36,50.5 154.78,51.08 149.71,51.08 149.33,51.46 144.93,51.46 144.62,51.77 136.59,51.77 128.73,59.63 128.73,62.12
  BOTTOM w0.076: UC1.AL34 126.98,70.22 126.98,69.09 127.02,68.98 127.02,68.74 126.98,68.63 126.98,67.6 127.14,67.45 127.14,67 126.7,66.56 126.7,66.46
  BOTTOM w0.089: 126.7,66.46 126.7,66.41 v1(126.31,66.02)
  BOTTOM w0.15: JDIMM2.161 176.65,37.89 v1(177.33,37.22)
DDR_B_PARITY: length 76.5
  IN1 w0.089: 124.24,58.27 124.24,65.27 v1(123.38,66.13)
  IN1 w0.102: 124.24,58.27 124.24,57.87 133.86,48.24 133.86,48.03 133.36,47.53 133.36,47.34 133.59,47.11 133.73,47.11 134.29,47.67 134.44,47.67 135.19,46.91 135.79,46.32 141.58,46.32 141.73,46.47 145.96,46.47 146.34,46.08 159.01,46.08 159.75,45.34 161.36,45.34 162.19,44.51 163.99,44.51 168.14,40.36 168.14,40.15 170.42,37.86 170.42,36.44 v1(170.69,36.17)
  BOTTOM w0.076: UC1.AE34 123.43,70.28 123.12,69.97 123.12,68.9 123,68.69 123,68.31 123.2,68.12 123.2,67.8 123.03,67.63 123.03,66.78 123.38,66.43 v1(123.38,66.13)
  BOTTOM w0.15: JDIMM2.143 170.16,38.2 170.27,38.08 170.89,38.08 170.99,37.98 170.99,37.72 170.84,37.57 170.3,37.57 170.16,37.42 170.16,36.42 170.4,36.17 v1(170.69,36.17)
DDR_DRAMRST#: length 135.6
  TOP w0.127: RD11.2 143.9,30.92 143.6,30.61 RD12.2 143.6,29.95 v1(143.93,29.62)
  IN1 w0.084: v1(143.93,29.62) 146.04,31.73 162.42,31.73 162.48,31.79 190.89,31.79 191.35,32.25 198.29,32.25 199.41,33.38 199.41,38.06 199.11,38.36 199.11,40.8 197.24,42.66 196.67,42.66 193.28,46.04 189.84,46.04 187.97,47.91 187,47.91 180.66,54.24 180.66,54.46 179.18,55.94 178.97,55.94 172.95,61.96 170.9,61.96 168.41,64.44 161.07,64.44 159.25,66.27 158.23,66.27 153.78,70.72 144.91,70.72 144.3,71.33 144.3,71.58 v1(143.93,71.95)
  BOTTOM w0.089: UC1.BU31 v1(143.93,71.95)
DDR_DRAMRST#_R: length 97.6
  TOP w0.127: v1(83.45,29.2) 83.44,29.2 83.01,29.63 83.01,30.04 83.51,30.54 CD29.1 ; CD61.1 143.07,30.59 RD12.1 142.75,30.54 v2(141.96,29.75) 141.71,29.49 DD1.2 v1(140.56,28.28)
  IN1 w0.084: v1(83.45,29.2) 84,28.65 86.54,28.65 86.87,28.31 90.81,28.31 92.75,26.37 97.01,26.37 101.11,30.47 116.08,30.47 117.23,31.62 120.88,31.62 124.77,33.23 131.25,33.23 138.7,30.14 v1(140.56,28.28) 143.9,28.28 145.26,29.64 145.26,30.4 146.2,31.34 160.94,31.34 162.19,30.09 v1(162.19,29.86)
  BOTTOM w0.127: v1(83.45,29.2) 84.21,29.96 JDIMM1.108 ; v1(162.19,29.86) 161.53,29.86 161.41,29.99 JDIMM2.108
DDR_VTT_CTRL: length 18.3
  BOTTOM w0.076: 104.38,68.76 104.69,69.07 107.02,69.07 107.31,69.35 109.53,69.35 109.63,69.46 110.28,69.46 110.59,69.76 110.59,69.81 UC1.C35
  BOTTOM w0.127: 104.38,68.76 104.02,68.76 v2(102.71,67.44) 100.53,65.26 98.13,65.26 96.15,67.24 UD1.2
DDR_XDP_WAN_SMBCLK: length 338.6
  IN1 w0.084: v1(172.76,73.32) 172.7,73.26 172.7,72.98 172.84,72.84 175.32,72.84 176.64,71.52 176.64,69.35 176.09,68.8 176.09,65.97 176.32,65.75 177.24,65.75 178.36,64.63 178.36,63.35 177.49,62.48 177.49,62.09 178,61.59 178,60.69 179.22,59.46 179.22,58.35 179.75,57.82 182.08,57.82 191.15,48.76 194.07,48.76 196.53,46.3 197.96,46.3 202.98,41.28 202.98,39.43 202.91,39.35 202.91,37.78 203.74,36.95 203.74,33.88 203.88,33.73 204.34,33.73 204.42,33.81 v1(204.42,33.85) ; v1(58.3,97.47) 58.43,97.34 58.43,96.77 58.6,96.6 58.6,94.53 57.04,92.98 55.08,92.98 54.28,92.18 54.28,90.1 52.39,88.21 52.39,82.8 49.62,80.04 49.62,78.79 48.42,77.59 47.17,77.59 46.56,76.97 46.56,75.54 46.4,75.38 46.4,68.64 45.79,68.03 45.79,65.4 44.12,63.73 44.12,58.42 43.66,57.96 43.66,56.28 43.66,55.73 43.99,55.41 43.99,52.07 45.26,50.79 45.26,49.11 45.01,48.86 45.01,47.68 44.66,47.34 44.66,46.13 43.77,45.24 43.77,42.23 43.99,42.01 43.99,36.63 45.03,35.59 45.03,34.76 49.61,30.18 55.65,30.18 57.04,31.57 70.16,31.57 71.57,30.16 71.57,29.33 74.2,26.7 75.63,26.7 76.41,25.93 87.92,25.93 88.95,26.96 90.96,26.96 92.75,25.16 108.62,25.16 112.32,28.86 116.88,28.86 118.43,30.41 130.12,30.41 131.07,31.36 131.07,32.43 130.71,32.79 129.97,32.79 v1(129.91,32.85)
  IN4 w0.084: v1(204.42,33.85) 204.36,33.79 203.76,33.79 203.4,34.16 202.18,34.16 201.81,33.79 199.6,33.79 197.59,31.78 191.88,31.78 191.07,30.98 182.16,30.98 181.1,29.92 181.1,29.59 180.76,29.24 180.76,28.81 180.51,28.57 177.38,28.57 173.94,32.02 171.15,32.02 171.01,32.15 132.4,32.15 131.76,32.79 129.97,32.79 v1(129.91,32.85)
  BOTTOM w0.127: JXDP1.53 58.28,97.21 58.3,97.22 v1(58.3,97.47) ; JDIMM1.253 122.46,35.6 123.01,35.05 123.85,35.05 126.09,32.81 129.88,32.81 v1(129.91,32.85) ; v1(204.42,33.85) 204.35,33.78 203.99,33.78 203.8,33.97 203.8,36.23 202.94,37.09 200.19,37.09 199.66,37.62 JDIMM2.253 ; v1(172.76,73.32) 172.73,73.35 172.73,74.32 173.49,75.09 174.06,75.09 174.48,75.51 174.48,76.71 RC319.1 173.48,77.16 173.18,77.46 QC2.1
DDR_XDP_WAN_SMBDAT: length 338
  IN1 w0.084: v1(129.91,32.26) 129.97,32.32 130.52,32.32 130.61,32.24 130.61,31.56 129.92,30.88 118.24,30.88 116.69,29.33 112.13,29.33 108.43,25.63 92.95,25.63 91.15,27.43 88.76,27.43 87.72,26.39 76.6,26.39 75.83,27.17 74.39,27.17 72.04,29.52 72.04,30.35 70.35,32.03 56.85,32.03 55.46,30.64 49.8,30.64 45.49,34.95 45.49,35.79 44.46,36.82 44.46,42.21 44.23,42.43 44.23,45.05 45.14,45.96 45.14,47.16 45.47,47.49 45.47,48.67 45.73,48.92 45.73,50.98 44.45,52.26 44.45,55.6 44.13,55.93 44.13,56.09 44.13,57.77 44.58,58.22 44.58,63.53 46.26,65.21 46.26,67.83 46.87,68.45 46.87,75.19 47.02,75.34 47.02,76.78 47.37,77.13 48.61,77.13 50.09,78.6 50.09,79.85 52.85,82.61 52.85,88.02 54.74,89.91 54.74,91.98 55.27,92.51 57.23,92.51 59.06,94.34 59.06,96.79 58.89,96.96 58.89,97.46 v1(58.88,97.47) ; v1(172.18,73.32) 172.24,73.26 172.24,72.78 172.65,72.38 175.13,72.38 176.17,71.33 176.17,69.54 175.63,69 175.63,65.78 176.13,65.29 177.05,65.29 177.89,64.44 177.89,63.54 177.03,62.68 177.03,61.9 177.53,61.4 177.53,60.5 178.76,59.27 178.76,58.16 179.56,57.36 181.89,57.36 190.95,48.29 193.88,48.29 196.34,45.84 197.77,45.84 202.52,41.08 202.52,39.62 202.44,39.55 202.44,37.59 203.27,36.76 203.27,33.68 203.69,33.27 v1(204.42,33.27)
  IN4 w0.084: v1(204.42,33.27) 204.36,33.32 203.57,33.32 203.2,33.69 202.37,33.69 202,33.32 199.79,33.32 197.78,31.32 192.07,31.32 191.27,30.51 182.36,30.51 181.57,29.72 181.57,29.39 181.22,29.05 181.22,28.62 180.71,28.1 177.19,28.1 173.74,31.55 170.95,31.55 170.82,31.68 132.21,31.68 131.57,32.32 129.97,32.32 v1(129.91,32.26)
  BOTTOM w0.127: v1(172.18,73.32) 172.22,73.35 172.22,74.42 172.09,74.54 170.87,74.54 170.74,74.67 RC318.1 170.74,76.28 170.92,76.46 171.42,76.46 QC2.4 ; v1(129.91,32.26) 129.88,32.3 125.88,32.3 123.64,34.54 123.17,34.54 122.71,34.08 JDIMM1.254 ; JXDP1.51 v1(58.88,97.47) ; v1(204.42,33.27) 204.42,33.27 203.78,33.27 203.29,33.76 203.29,36.02 202.73,36.58 200.26,36.58 199.91,36.22 JDIMM2.254
DEBUG_TX: length 13.6
  TOP w0.127: RE74.2 v1(293.31,98.36) 294.21,98.36 v2(294.49,98.08) ; v1(293.91,92.37) 293.39,92.89 RE30.2
  IN4 w0.084: v1(293.31,98.36) 295.11,96.55 295.11,92.83 294.66,92.37 v1(293.91,92.37)
  BOTTOM w0.127: v1(293.91,92.37) 293.93,92.35 293.93,91.97 294.31,91.59 JDEG1.9
DGPU_HOLD_RST#: length 4.7
  BOTTOM w0.076: 155.89,78.08 155.81,78.17 155.11,78.17 154.89,77.96 154.82,77.89 154.04,77.89 UC1.CR22
  BOTTOM w0.102: 155.89,78.08 157.69,78.08 157.94,77.83 T420.1
DGPU_PWROK: length 19.6
  TOP w0.127: T419.1 v1(166.69,72.83)
  IN1 w0.102: v1(150.82,75.41) 151.18,75.76 151.64,75.76 154.51,72.89 160.91,72.89 162.05,74.03 165.68,74.03 166.38,73.34 166.38,73.14 v1(166.69,72.83)
  BOTTOM w0.089: UC1.CJ25 150.7,75.82 v1(150.82,75.41)
DIMM1_SA0: length 9.8
  TOP w0.127: v2(123.63,35.21) 124.04,35.62 v1(124.04,35.77) 123.96,35.85 RD4.2 RD5.1
  IN4 w0.084: v1(124.04,35.77) 122.92,34.65 v1(122.92,29.77)
  BOTTOM w0.127: v1(122.92,29.77) 122.98,29.77 123.2,29.99 JDIMM1.256
DIMM1_SA1: length 11.4
  TOP w0.127: v1(124.66,36.38) 124.94,36.66 RD7.1 RD6.2 v2(127.06,36.66)
  IN4 w0.084: v1(123.53,29.75) 123.33,29.95 123.33,34.42 124.53,35.62 124.53,35.81 124.66,35.93 v1(124.66,36.38)
  BOTTOM w0.102: 123.63,29.75 v1(123.53,29.75)
  BOTTOM w0.127: JDIMM1.260 124.2,30.33 123.63,29.75
DIMM1_SA2: length 6.2
  TOP w0.127: v1(100.71,32.37) 101.61,32.37 102.47,31.52 103.08,31.52 RD9.1 RD8.2 v2(104.51,30.78)
  BOTTOM w0.107: JDIMM1.166 v1(100.71,32.37)
DIMM2_SA0: length 3.9
  TOP w0.127: v2(199.46,32.46) 199.52,32.39 v1(200.4,32.39) 200.4,32.61 200.2,32.82 RD21.1 RD20.2
  BOTTOM w0.127: JDIMM2.256 v1(200.4,32.39)
DIMM2_SA1: length 3.1
  TOP w0.127: RD22.2 RD23.1 201.07,32.52 v1(200.97,32.42)
  BOTTOM w0.127: v1(200.97,32.42) 201.4,31.98 JDIMM2.260
DIMM2_SA2: length 10.1
  TOP w0.127: v1(178.65,33) 179.08,32.57 179.97,32.57 180.41,33.01 v2(180.97,33.01) 181.49,33.01 181.87,32.63 182.91,32.63 183.42,33.14 RD25.1 183.56,33.5 183.81,33.75 183.81,34.54 183.65,34.7 RD24.2
  BOTTOM w0.127: v1(178.65,33) 178.26,33 177.91,32.65 JDIMM2.166
DISP_ON: length 23.8
  TOP w0.127: DV2.1 48.14,107.38 RV2.1 48.59,107.69 49.1,107.18 50.04,107.18 50.15,107.28 50.59,107.28 50.83,107.52 v1(50.83,107.78) 50.83,108.05 v3(51.31,108.53)
  IN2 w0.122: v1(66.4,110.01) 66.28,110.01 65.85,109.58 62.84,109.58 60.22,106.97 52.25,106.97 51.44,107.78 v1(50.83,107.78)
  BOTTOM w0.127: JEDP1.22 65.83,110.94 65.96,110.81 66.15,110.81 66.4,110.56 v1(66.4,110.01)
DMIC0: length 357.5
  TOP w0.127: UA1.4 277.05,41.44 RA52.2 276.28,40.67 v1(275.22,40.67) ; v1(55.63,105.82) 56.6,106.78 CA6.1 56.6,107.12 56.51,107.2 56.51,107.93 56.71,108.13 57.15,108.13 57.29,108.27 DV13.3 57.29,109.77 v1(57.36,109.84)
  IN2 w0.122: v1(275.22,40.67) 275.06,40.51 275.06,37.24 274.38,36.56 274.38,30.53 273.44,29.58 270.76,29.58 268.95,27.78 260.31,27.78 259.68,28.41 256.92,28.41 256.3,27.79 240.7,27.79 238.44,30.05 236.86,30.05 236.3,29.49 228.49,29.49 228.19,29.79 220.91,29.79 220.02,30.68 216.92,30.68 213.12,34.48 211.28,34.48 211.08,34.28 207.32,34.28 206.66,34.94 206.66,36.51 205.94,37.23 203.15,37.23 202.87,37.5 200.36,37.5 197.83,40.04 195.16,40.04 192.3,42.89 192.3,44.36 191.09,45.57 190.05,45.57 185.52,41.05 165.85,41.05 162.61,37.8 134.66,37.8 133.58,38.89 125.96,38.89 125.1,38.03 123.95,38.03 123.52,38.46 116.4,38.46 113.33,41.53 97.46,41.53 94.14,38.22 66.68,38.22 65.76,37.3 64.78,37.3 64.09,37.98 56.73,37.98 55.56,36.81 41.16,36.81 36.39,41.59 36.39,44.48 36.13,44.74 36.13,51.86 36.83,52.55 36.83,60.82 37.48,61.47 37.48,65.37 40.72,68.62 40.72,76 46.6,81.87 46.6,87.7 47.47,88.57 47.47,91.36 45.56,93.27 45.56,94.33 46.73,95.5 46.73,98.04 52.91,104.21 52.91,104.82 53.53,105.44 55.26,105.44 v1(55.63,105.82)
  BOTTOM w0.127: v1(57.36,109.84) 57.36,110.12 57.59,110.35 58.16,110.35 58.59,109.91 59.3,109.91 59.64,110.25 59.64,110.81 59.83,111 JEDP1.7
DMIC_CLK0: length 353.7
  TOP w0.127: RA14.2 CA54.1 275.42,38.79 275.06,39.15 v2(274.78,39.15) 274.49,39.15 v1(274.33,38.98) ; v1(57.95,109.84) 57.95,109.44 58.29,109.1 DV13.2 58.29,107.79 58.22,107.72 58.22,106.42 CA5.1 58.46,105.74 58.01,105.74 v1(57.93,105.82)
  IN2 w0.122: v1(274.33,38.98) 274.33,38.98 274.33,37.59 274.07,37.33 274.07,30.54 273.37,29.84 270.7,29.84 268.86,28 267.21,28 266.61,28.6 264.76,28.6 264.35,28.19 262.58,28.19 262.39,28.38 260.03,28.38 259.77,28.63 254.96,28.63 254.83,28.76 253.18,28.76 252.43,28.01 241.51,28.01 239.01,30.51 236.61,30.51 236.09,29.99 228.83,29.99 228.64,30.18 221.28,30.18 220.28,31.18 217.13,31.18 213.32,34.99 211.07,34.99 210.87,34.79 207.52,34.79 207.17,35.14 207.17,36.87 206.31,37.73 203.36,37.73 203.08,38.01 200.57,38.01 197.14,41.44 195.22,41.44 192.81,43.85 192.81,44.57 191.34,46.03 189.79,46.03 185.18,41.42 165.52,41.42 162.4,38.31 134.87,38.31 133.79,39.39 125.75,39.39 124.89,38.53 124.16,38.53 123.87,38.82 116.75,38.82 112.8,42.78 97.59,42.78 93.53,38.72 65.34,38.72 65.11,38.49 56.52,38.49 55.35,37.32 41.37,37.32 38.81,39.87 38.81,42.07 37.64,43.24 37.64,43.94 36.63,44.95 36.63,51.65 37.33,52.35 37.33,60.45 38.57,61.69 38.57,62.65 39.49,63.57 39.49,66.53 41.07,68.1 41.07,74.14 44.1,77.18 44.1,78.89 47.1,81.89 47.1,87.49 47.75,88.14 47.75,92.4 47.46,92.68 47.46,96.3 49.1,97.94 49.1,99.1 54.11,104.11 54.11,104.7 54.37,104.96 55.38,104.96 56.24,105.82 v1(57.93,105.82)
  BOTTOM w0.127: v1(57.95,109.84) 58.38,109.4 59.51,109.4 60.15,110.04 60.15,110.56 60.63,111.04 JEDP1.9
DMIC_CLK0_CODEC: length 5
  TOP w0.127: UA1.5 277.48,41.04 276.75,40.32 RA14.1 276.27,40.16 275.09,40.16 v2(274.63,40.62)
DMIC_CLK0_CPU: length 5.1
  BOTTOM w0.076: 157.83,76.12 157.24,76.7 154.37,76.7 154.09,76.43 153.81,76.43 153.35,76.68 UC1.CP24
  BOTTOM w0.127: T404.1 157.83,76.12
DMIC_DATA0_CPU: length 9.3
  BOTTOM w0.076: UC1.CN24 153,76.41 153.49,76.41 153.76,76.27 154.16,76.27 154.44,76.54 156.95,76.54 158.07,75.42 160.71,75.42
  BOTTOM w0.127: T405.1 160.71,75.42
DPSNK1_DDC_CLK: length 9.5
  TOP w0.076: v1(33.02,77.46) v2(33.62,77.46)
  TOP w0.127: RT128.1 32.24,77.15 32.83,77.15 33.02,77.34 v1(33.02,77.46)
  IN2 w0.122: v1(33.02,77.46) 33.02,77.72 32.71,78.04 31.57,78.04 30.74,78.86 29.49,78.86 v1(29.06,78.43)
  BOTTOM w0.127: v1(29.06,78.43) 29.06,78.88 29.29,79.11 30.37,79.11 UT1.Y8
DPSNK_RBIAS: length 2.3
  TOP w0.076: v2(32,74.47) 31.71,74.75 RT38.1
  TOP w0.102: v1(30.37,74.54) 30.57,74.75 RT38.1
  BOTTOM w0.127: UT1.Y18 30.68,74.85 v1(30.37,74.54)
EDP_AUXN: length 85.4
  TOP w0.104: v1(69.47,106.98) 69.65,107.16 69.65,107.79 CV1.1
  IN4 w0.094: v1(127.64,92.96) 128.59,92.96 128.79,93.16 128.79,94.68 130.37,96.26 130.37,101.18 129.63,101.92 129.63,103.68 125.95,107.36 125.95,107.73 122.69,110.99 111.78,110.99 110.75,109.97 106,109.97 105.35,110.62 89.26,110.62 87.63,108.99 78.8,108.99 78.58,108.77 70.51,108.77 69.47,107.74 v1(69.47,106.98)
  BOTTOM w0.076: UC1.AH4 125.81,90.06 125.81,92.89 125.88,92.96 v1(127.64,92.96)
EDP_AUXN_C: length 3
  TOP w0.104: v1(69.63,110.04) 69.92,109.75 69.92,109.42 69.55,109.05 CV1.2
  BOTTOM w0.104: JEDP1.33 70.23,110.64 v1(69.63,110.04)
EDP_AUXP: length 85.4
  TOP w0.104: v1(70.06,106.98) 69.85,107.19 69.85,107.66 CV2.1
  IN4 w0.094: v1(70.06,106.98) 70.06,107.27 69.96,107.36 69.73,107.36 69.66,107.44 69.66,107.67 70.58,108.59 78.66,108.59 78.87,108.81 87.71,108.81 89.33,110.44 105.27,110.44 105.93,109.78 110.83,109.78 111.85,110.81 122.61,110.81 125.77,107.65 125.77,107.29 129.45,103.61 129.45,101.84 130.19,101.1 130.19,96.33 128.61,94.75 128.61,93.24 128.51,93.14 128.24,93.14 128.15,93.24 128.15,93.69 128.06,93.78 127.82,93.78 v1(127.64,93.6)
  BOTTOM w0.076: v1(127.64,93.6) 127.36,93.6 127.29,93.52 127.29,93.25 127.17,93.13 125.81,93.13 125.64,92.95 125.64,90.3 UC1.AH3
EDP_AUXP_C: length 3
  TOP w0.104: v1(70.9,110.04) 70.48,110.04 70.12,109.68 70.12,109.25 CV2.2
  BOTTOM w0.104: JEDP1.34 70.63,110.31 v1(70.9,110.04)
EDP_BIA_PWM: length 106.2
  TOP w0.127: v2(71.59,105.76) 71.54,105.8 DV1.3 69.33,105.8 68.31,106.83 v1(68.31,106.98)
  IN2 w0.089: v1(150.24,84.71) 150.24,84.83 150.06,85.01 149.17,85.01 149.08,85.1 148.77,85.1 148.71,85.04 146.98,85.04 146.37,85.66 144.79,85.66 144.53,85.91 144.53,89.53 143.2,90.86 143.2,92.41
  IN2 w0.122: 143.2,92.41 143.2,94.93 143.12,95 143.12,100.91 140.5,103.53 135.76,103.53 134.83,104.46 120.62,104.46 118.95,106.13 114.68,106.13 112.73,108.07 104.62,108.07 102.67,110.03 90.83,110.03 89.89,109.09 89.07,109.09 88.82,108.84 88.36,108.84 87.53,108.01 82.94,108.01 82.34,107.42 68.75,107.42 v1(68.31,106.98)
  BOTTOM w0.089: UC1.CH11 150.05,85.22 v1(150.24,84.71)
EDP_COMP: length 8.5
  TOP w0.508: RC8.2 v1(129.44,94.61)
  IN1 w0.2: v1(128.4,88.04) 128.4,88.05 128.83,88.49 128.83,89.16 128.65,89.35 128.65,89.51
  IN1 w0.3: 128.65,89.51 128.65,93.82 v1(129.44,94.61)
  BOTTOM w0.089: v1(128.4,88.04) UC1.AM6
EDP_HPD: length 185.8
  TOP w0.127: v1(155.85,87.47) v3(155.19,87.47) ; v1(66.85,110.42) 66.85,109.98 67.35,109.47 RV7.1
  IN2 w0.102: v1(155.85,87.47) 156.89,88.51 160.9,88.51 162.37,87.04 165.35,87.04 166.76,88.45 169.51,88.45 v1(169.58,88.51)
  IN2 w0.122: v1(169.58,88.51) 170.18,89.12 174.92,89.12 175.45,89.65 176.19,89.65 176.95,88.89 176.95,88.03 181.91,83.07 186.21,83.07 v1(186.47,82.81)
  IN3 w0.122: v1(186.47,82.81) 186.47,83.17 186.08,83.56 186.08,85.59 182.55,89.13 182.55,93.68 180.14,96.09 180.14,97.34 179.57,97.91 179.57,99.53 177.41,101.69 177.41,104.08 173.29,108.2 167.7,108.2 167.09,107.59 162.99,107.59 161.66,108.92 161.02,108.92 159.95,109.98 153.11,109.98 152.74,109.61 146.74,109.61 145.75,110.6 138.72,110.6 138.63,110.69 136.77,110.69 136.31,111.14 114.54,111.14 111.94,108.55 104.65,108.55 104.43,108.33 92.65,108.33 92.43,108.55 90.21,108.55 89.8,108.96 89.72,108.96 89.5,109.18 88.99,109.18 88.8,108.99 82.9,108.99 82.55,109.34 81.47,109.34 81.17,109.65 79.11,109.65 77.65,111.11 67.52,111.11 66.85,110.44 v1(66.85,110.42)
  BOTTOM w0.076: v1(155.85,87.47) 155.57,87.75 155.47,87.85 155.06,87.85 154.84,87.63 154.84,87.63 153.86,87.63 153.85,87.63 153.82,87.63 153.8,87.65 153.71,87.68 153.53,87.68 153.41,87.64 153.18,87.64 153.06,87.68 152.88,87.68 152.76,87.64 152.54,87.64 UC1.CM7
  BOTTOM w0.127: JEDP1.26 67.43,111 v1(66.85,110.42) ; RC2.2 v1(169.58,88.51)
EDP_TXN0: length 81.6
  TOP w0.104: CV4.1 71.88,107.66 71.88,107.12 v1(72.02,106.97)
  IN4 w0.094: v1(127.64,96.77) 127.74,96.87 128.32,96.87 128.78,97.33 128.78,98.87 128.26,99.39 128.26,102.35 125.63,104.98 125.63,105.39 121.19,109.83 112.26,109.83 111.21,108.78 103.98,108.78 103.31,109.46 91.55,109.46 89.48,107.39 82.95,107.39 82.09,106.53 77.66,106.53 77.02,105.89 72.12,105.89 72.02,105.98 v1(72.02,106.97)
  BOTTOM w0.076: v1(127.64,96.77) 127.58,96.83 125.11,96.83 125.04,96.76 125.04,91.66 124.7,91.32 124.7,91.07 124.74,90.98 124.74,90.7 124.7,90.61 124.7,90.42 124.78,90.24 124.78,90.24 124.84,90.18 125.08,90.18 125.08,90.17 125.11,90.17 125.23,90.05 125.23,89.47 124.98,89.21 UC1.AG4
EDP_TXN0_C: length 4.5
  TOP w0.104: CV4.2 72.35,109.27 72.59,109.5 72.59,109.86 72.76,110.04 v1(73.44,110.04)
  BOTTOM w0.104: JEDP1.36 71.43,111.08 72.07,110.43 73.05,110.43 v1(73.44,110.04)
EDP_TXN1: length 78.6
  TOP w0.104: v1(73.89,106.98) 73.89,107.64 CV6.1
  IN4 w0.094: v1(73.89,106.98) 73.82,106.9 73.82,106.57 73.91,106.47 76.67,106.47 77.31,107.12 81.58,107.12 82.44,107.97 89.24,107.97 91.3,110.04 105.11,110.04 105.76,109.38 110.99,109.38 112.02,110.41 121.43,110.41 129.05,102.79 129.05,101.53 129.79,100.79 129.79,97.26 128.84,96.31 128.84,95.55 128.23,94.94 127.71,94.94 v1(127.64,94.87)
  BOTTOM w0.076: v1(127.64,94.87) 127.51,94.99 125.68,94.99 125.48,94.8 125.48,91.03 UC1.AG2
EDP_TXN1_C: length 6.9
  TOP w0.104: v1(75.98,110.04) 75.21,110.04 75.06,109.89 75.06,109.5 74.84,109.27 74.61,109.27 CV6.2
  BOTTOM w0.104: JEDP1.38 72.23,110.94 72.33,110.84 74.18,110.84 74.39,110.63 75.2,110.63 75.4,110.43 75.4,110.11 75.47,110.04 v1(75.98,110.04)
EDP_TXP0: length 81.7
  TOP w0.104: v1(71.44,106.97) 71.68,107.22 71.68,107.79 CV3.1
  IN4 w0.094: v1(127.64,97.41) 127.99,97.05 128.25,97.05 128.6,97.41 128.6,98.79 128.08,99.31 128.08,102.27 125.45,104.9 125.45,105.31 121.11,109.65 112.33,109.65 111.29,108.6 103.9,108.6 103.23,109.27 91.62,109.27 89.55,107.2 83.02,107.2 82.17,106.35 77.74,106.35 77.09,105.71 72.04,105.71 71.84,105.91 71.84,106.57 v1(71.44,106.97)
  BOTTOM w0.076: v1(127.64,97.41) 127.23,97 125.05,97 124.87,96.82 124.87,91.72 124.54,91.39 124.54,91.05 124.57,90.95 124.57,90.73 124.54,90.63 124.54,90.39 124.63,90.18 124.69,90.04 124.69,89.69 124.78,89.59 124.91,89.59 124.97,89.65 UC1.AG3
EDP_TXP0_C: length 4.5
  TOP w0.104: v1(72.17,110.04) 72.39,109.82 72.39,109.58 72.28,109.47 71.76,109.47 CV3.2
  BOTTOM w0.104: v1(72.17,110.04) 72.17,110.06 71.53,110.7 71.39,110.7 71.14,110.44 70.93,110.44 70.84,110.53 70.84,110.72 71.03,110.9 JEDP1.35
EDP_TXP1: length 78.7
  TOP w0.104: CV5.1 73.7,107.81 73.7,107.37 v1(73.31,106.98)
  IN4 w0.094: v1(127.64,95.5) 128.02,95.12 128.15,95.12 128.66,95.62 128.66,96.39 129.61,97.34 129.61,100.72 128.87,101.45 128.87,102.71 121.35,110.23 112.09,110.23 111.07,109.2 105.69,109.2 105.03,109.86 91.38,109.86 89.31,107.79 82.51,107.79 81.66,106.93 77.38,106.93 76.74,106.29 73.83,106.29 73.63,106.49 73.63,106.65 v1(73.31,106.98)
  BOTTOM w0.076: UC1.AG1 125.12,91.01 125.23,91.01 125.32,91.1 125.32,94.87 125.61,95.16 127.29,95.16 v1(127.64,95.5)
EDP_TXP1_C: length 6.9
  TOP w0.104: CV5.2 73.79,109.47 74.76,109.47 74.87,109.58 74.87,109.88 v1(74.71,110.04)
  BOTTOM w0.104: v1(74.71,110.04) 75.11,110.04 75.21,110.14 75.21,110.35 75.12,110.44 74.31,110.44 74.1,110.65 72.25,110.65 71.83,111.07 JEDP1.37
EDRAM_OPIO_RCOMP: length 8.7
  TOP w0.381: RC108.1 112.46,94.22 v2(112.71,93.98) v1(113.22,93.47)
  IN1 w0.2: v1(115.46,88.67) 115.46,89.38 115.7,89.63 115.7,91.37 113.89,93.18 113.5,93.18 v1(113.22,93.47)
  BOTTOM w0.2: v1(115.46,88.67) UC1.L5
EMMC_RCOMP: length 10.4
  TOP w0.381: RC10.1 157.61,83.24 157.37,83 v1(157.37,82.58)
  IN4 w0.2: v1(157.37,82.58) 157.2,82.75 154.98,82.75 154.34,82.1 152.56,82.1 152.08,81.62 v1(151.49,81.62)
  BOTTOM w0.2: v1(151.49,81.62) UC1.CK15
EN_1.05VALWP: length 5
  TOP w0.127: v2(194.18,105.23) 194.11,105.29 v1(194.11,106.01)
  TOP w0.254: PU301.11 194.23,107.14 194.44,106.93 194.44,106.34 v1(194.11,106.01)
  BOTTOM w0.254: PR312.2 PR302.1 PC360.1 194.33,105.8 v1(194.11,106.01)
EN_1.8VALW: length 5.1
  TOP w0.127: PR505.1 177.11,104.58 v2(177.62,104.07)
  TOP w0.254: v1(179.75,104.79) 179.38,105.16 PR504.2 PC505.1 PR505.1
  BOTTOM w0.254: v1(179.75,104.79) 179.57,104.62 PU501.1
EN_1V_PRIM_CORE: length 10.9
  TOP w0.127: PC411.1 v2(173.39,24.69)
  TOP w0.254: v1(182.57,25.2) 182.91,25.55 PU402.13 ; v1(176.81,25.12) 176.81,24.93 176.56,24.68 PR406.2 175.54,24.68 175.54,24.69 PR407.1 174.61,24.69 PC411.1
  IN2 w0.254: v1(176.81,25.12) 177.46,25.77 182.06,25.77 182.57,25.27 v1(182.57,25.2)
EN_1VS_VCCIO: length 9.8
  TOP w0.254: PR402.2 PR403.1 PC402.1 81.73,30.08 v2(81.57,29.92) 81.22,29.57 v1(81.22,29.46) ; v1(85.95,29.63) 85.61,29.29 PU401.13
  IN1 w0.254: v1(85.95,29.63) 85.64,29.32 84.72,29.32 83.79,30.25 82.01,30.25 v1(81.22,29.46)
EN_2.5V_MEM: length 4.8
  TOP w0.127: PR513.2 v2(127.06,26.77)
  TOP w0.254: PR513.2 126.7,25.23 PR514.1 126.24,25.26 PC513.1 125.06,25.26 124.4,24.6 PU503.5
EN_INVPWR: length 266.7
  TOP w0.127: v2(99.43,98.77) 99.85,99.19 v1(100.04,99.19) ; UE1.B2 273,78.14 273,77.66 272.76,77.42 272.07,77.42 v1(271.87,77.22) 271.05,76.4 RE55.1
  IN3 w0.122: v1(100.04,99.19) 101.12,100.27 103.75,100.27 105.03,98.99 112.4,98.99 113.55,97.85 114.72,97.85 116.06,99.18 116.06,99.86 116.69,100.48 122.95,100.48 123.85,101.38 130.09,101.38 130.77,100.7 139.52,100.7 140.47,99.75 140.47,95.43 140.79,95.12 142.18,95.12 143.9,96.83 148.34,96.83 149.68,98.16 150.09,98.16 152.95,101.02 154.58,101.02 157.35,98.25 160.11,98.25 165.11,103.24 170.96,103.24 172.75,101.45 172.75,96.98 174.08,95.65 174.2,95.65 175.41,94.45 175.41,92.51 177.44,90.48 177.44,87.28 178.37,86.35 178.37,85.6 180.58,83.38 180.58,81.53 184.31,77.81 184.31,76.93 185.31,75.93 185.31,73.32 186.69,71.94 186.69,68.63 185.98,67.92 185.98,58.31 186.79,57.5 189.63,57.5 195.23,51.91 207.19,51.91 217.51,41.59 227.52,41.59 229.34,39.77 236.85,39.77 237,39.92 242.56,39.92 242.96,40.32 244.36,40.32 244.97,40.93 246.69,40.93 248.09,42.33 249.68,42.33 252.04,44.7 253.46,44.7 254.18,45.41 256.13,45.41 257.78,47.05 259.1,47.05 260.19,48.15 262.62,48.15 264.59,50.12 264.59,50.43 265.43,51.27 266.27,51.27 266.49,51.05 267.12,51.05 268.42,52.35 268.42,53.46 269.03,54.08 269.03,56.05 268.55,56.53 268.55,58.71 270.5,60.67 270.5,62.25 271.1,62.85 271.1,64.33 271.36,64.59 271.36,66.8 272.76,68.2 272.76,72.2 273.12,72.57 273.12,75.97 v1(271.87,77.22)
  BOTTOM w0.127: QV2.2 100.21,99.37 v1(100.04,99.19)
EN_LCDPWR: length 5
  BOTTOM w0.127: UV24.4 101.61,97.28 101.4,97.07 101.4,96.34 101.54,96.2 101.54,95.83 RV3.1 102.13,95.24 DV3.1 103.32,95.53 v2(102.85,96.01)
EN_PD_HV_1: length 95.6
  TOP w0.127: v1(32.46,50.99) 32.65,51.17 v2(33.15,51.17) 34.04,51.17 34.61,51.75 38.74,51.75 40.2,53.21 v1(40.2,53.27)
  TOP w0.203: v1(45.55,84.67) 45.46,84.67 45.07,85.06 PQ813.2
  TOP w0.254: PR834.1 36.72,100.03 v1(36.72,99.01) ; v1(45.79,63.94) 45.79,63.76 46.18,63.37 46.7,63.37 PR736.1 ; PR846.1 42.67,95.19 42.37,94.89 v1(42.02,94.89) 42.02,94.54 41.53,94.05 40.32,94.05 39.95,93.68 39.95,92.77 40.39,92.32 41.03,92.32 41.37,91.98 43.12,91.98 43.3,92.16 43.87,92.16 44.01,92.3 44.69,92.3 45.15,92.77 45.15,93.34 44.88,93.62 44.48,93.62 44.23,93.87 PR853.1 43.92,94.43 PR820.2 43.92,95.24 44.32,95.63 PR857.1
  IN2 w0.122: v1(45.55,84.67) 45.14,85.07 45.14,85.43 45.76,86.06 45.76,91.77 42.64,94.89 v1(42.02,94.89)
  IN3 w0.122: v1(40.2,53.27) 40.58,53.65 40.58,56.37 43.88,59.67 43.88,61.45 44.52,62.09 44.52,63.36 45.1,63.94 v1(45.79,63.94) 45.79,64.45 44.93,65.31 44.93,74.31 47.57,76.96 47.89,76.96 48.67,77.74 48.67,83.6 47.6,84.67 45.55,84.67 v1(45.55,84.67)
  IN3 w0.254: v1(36.72,99.01) 36.16,98.45 36.16,95.62 36.9,94.89 v1(42.02,94.89)
  BOTTOM w0.076: 33.49,54.7 33.49,55.11 33.02,55.58 33.02,56.24 UT5.C2
  BOTTOM w0.102: 33.49,54.7 33.49,54.24 33.7,54.04 33.7,52.04 33.75,51.98 33.75,51.47 33.27,50.99 v1(32.46,50.99)
EN_PD_HV_1#: length 9.9
  TOP w0.127: PQ802.3 42.12,98.7 v2(40.99,97.57)
  TOP w0.254: PQ802.3 42.12,99.83 42.43,100.14 42.77,100.14 ; PR851.2 44.68,102.94 PR810.2 45.36,101.93 45.13,101.7 45.13,100.93 44.33,100.14 42.77,100.14 ; PQ802.2 42.77,100.14
ENABLE_DS#: length 9.2
  TOP w0.102: RE549.2 283.3,75.51 282.71,76.1 282.71,76.7 281.81,77.6 281.81,77.83 281.5,78.15 281.03,78.15 UE1.L2
  TOP w0.127: v2(283.58,71.48) 283.58,72.89 RE550.1 284.11,75.06 RE549.2
ENLDO_3V5V: length 226.8
  TOP w0.127: v1(59.72,49.69) 59.72,49.52 v2(59.05,48.85)
  TOP w0.254: v1(45.56,33.03) 45.8,33.03 46.2,32.63 46.2,30.98 45.34,30.13 PU102.11 ; v1(188.28,95.24) 189.52,95.24 189.78,95.5 PU100.11
  IN2 w0.122: v1(188.28,95.24) 187.78,94.74 185.06,94.74 184.05,93.72 180.92,93.72 177.39,97.24 172.63,97.24 171.77,98.1 170.88,98.1 v1(170.44,98.55)
  IN3 w0.122: v1(59.72,49.69) 60.54,49.69 60.98,50.12 65.92,50.12 66.55,50.76 71.34,50.76 72.03,51.44 73,51.44 73.19,51.63 87.15,51.63 90.62,55.1 133.1,55.1 136.27,58.28 136.27,67.39 136.5,67.62 136.83,67.62 138.07,66.37 138.07,65.96 139.29,64.73 139.29,64.13 139.63,63.8 140.73,63.8 142.55,61.98 142.55,60.45 144.56,58.44 145.82,58.44 149.09,61.72 149.09,63.63 149.43,63.96 149.43,66.42 149.66,66.65 149.66,68.29 150.17,68.8 152.1,68.8 155.88,72.57 159.46,72.57 159.97,73.08 160.71,73.08 160.99,73.36 160.99,74.98 160.6,75.37 159.59,75.37 158.98,75.98 158.98,77.94 159.51,78.47 161.09,78.47 161.45,78.82 161.45,81.31 164.05,83.92 165.87,83.92 166.64,84.69 169.94,84.69 170.5,85.25 170.94,85.69 172.04,86.79 172.04,87.73 171.64,88.14 171.64,89.1 171.03,89.7 171.03,91.77 169.96,92.84 169.96,96.67 169.3,97.33 169.3,97.56 170.28,98.55 v1(170.44,98.55)
  IN4 w0.084: v1(45.56,33.03) 45.56,33.11 44.32,34.35 43.44,34.35 42.35,35.44 42.35,37.5 43.52,38.67 44.54,38.67 52.43,46.55 54.36,46.55 56.39,48.57 58.81,48.57 59.72,49.48 v1(59.72,49.69)
  BOTTOM w0.254: PR102.1 185.62,94.77 PR103.1 186.99,93.88 188.28,95.18 v1(188.28,95.24)
ENVDD_PCH: length 65.8
  IN3 w0.122: v1(129.55,93.97) 128.91,93.97 128.72,94.16 128.72,98.3 128.47,98.55 123,98.55 120.67,96.22 119.01,96.22 117.67,94.88 117.67,93.95 116.36,92.64 115.76,92.64 111.9,96.5 107.17,96.5 v1(106.56,95.89)
  IN4 w0.084: v1(149.61,84.64) 149.14,84.16 143.42,84.16 142.54,85.04 140.19,85.04 140.02,85.21 140.02,85.63 139.65,86.01 138.34,86.01 138.12,86.23 138.12,89.41 137.47,90.06 130.37,90.06 129.74,90.69 129.74,93.78 v1(129.55,93.97)
  BOTTOM w0.089: v1(149.61,84.64) 149.62,84.65 UC1.CG11
  BOTTOM w0.127: DV3.2 104.15,95.27 104.15,94.65 104.42,94.38 105.56,94.38 106.24,95.05 106.24,95.58 v1(106.56,95.89)
EOPIO_RCOMP: length 8.1
  TOP w0.381: v1(116.27,93.11) 116,93.11 v2(115.51,93.6) 115.07,94.04 RC109.1
  IN1 w0.2: v1(116.27,93.11) 115.9,92.73 115.9,92.32 116.47,91.75 116.47,88.75 v1(116.38,88.67)
  BOTTOM w0.2: v1(116.38,88.67) UC1.N5
ESPI_ALERT#: length 222.2
  TOP w0.127: UE1.H7 278.52,82.25 v1(278.62,82.25) ; v1(161.19,60.94) 161.5,60.63 RC244.2
  IN2 w0.089: 146.01,61.73 144.89,62.86 144.89,66.84 145.87,67.81 145.87,68.63 144.48,70.01 144.48,73.48 144.85,73.84 v1(144.85,73.85)
  IN2 w0.122: 146.01,61.73 146.06,61.69 147.3,60.44 153.54,60.44 153.82,60.72 157.14,60.72 157.81,60.04 160.03,60.04 160.92,60.94 v1(161.19,60.94) 161.46,60.94 162.1,60.31 164.42,60.31 164.54,60.43 166.79,60.43 167.34,60.98 167.91,60.98 169.45,62.52 173.54,62.52 176.79,59.27 176.79,58.6 177.22,58.16 178.51,58.16 179.35,59 179.93,59 180.32,58.6 183.27,58.6 183.59,58.28 187.04,58.28 187.67,58.92 187.67,59.52 189.77,61.61 193.85,61.61 194.13,61.33 194.45,61.33 200.44,55.34 200.44,46.04 203.58,42.9 205.94,42.9 207.85,40.99 211.72,40.99 218.3,34.41 239.55,34.41 241.72,32.23 243.99,32.23 245.34,33.59 247.85,33.59 248.37,34.1 253.11,34.1 253.53,34.52 257.4,34.52 257.94,35.06 260.82,35.06 261.86,34.01 262.79,34.01 263.68,34.91 266.8,34.91 269.17,37.27 269.17,40.49 269.71,41.04 269.71,41.54 271.14,42.97 271.14,47.4 270.23,48.32 270.23,50.05 271.97,51.8 271.97,53.04 273.05,54.11 273.54,54.11 274.62,55.19 274.62,56.41 275.47,57.25 275.47,59.48 276.22,60.23 276.22,61.05 277.75,62.58 277.75,64.83 277.51,65.07 277.51,65.43 276.37,66.57 276.37,69.27 276.04,69.6 276.04,70.75 276.37,71.07 276.37,73.1 278.54,75.27 278.54,76.89 277.47,77.95 277.47,80.89 277.19,81.18 277.19,82.14 277.72,82.67 278.07,82.67 278.49,82.25 v1(278.62,82.25)
  BOTTOM w0.089: UC1.BV28 v1(144.85,73.85)
ESPI_CLK: length 25
  TOP w0.127: RC19.1 v1(159.48,60.94)
  IN2 w0.102: 146.26,68.8 146.26,68.97 144.85,70.38 144.85,71.03 v1(144.85,71.32)
  IN2 w0.122: v1(159.48,60.94) 159.09,60.55 158.02,60.55 157.35,61.22 153.61,61.22 153.34,60.94 147.7,60.94 146.26,62.37 146.26,68.8
  BOTTOM w0.089: UC1.BV32 144.4,71.53 v1(144.85,71.32)
ESPI_CLK_5105: length 239.8
  TOP w0.127: v1(276.74,70.44) 277.84,71.55 RE350.1 ; RC19.2 CC316.1 160.92,58.89 v1(160.92,58.84) ; UE1.G7 277.75,82.23 v1(277.83,82.23)
  IN1 w0.084: v1(277.83,82.23) 278.07,82.23 278.63,82.79 281.43,82.79 282.74,81.49 284.1,81.49 284.1,81.49 285.89,81.49 286.78,82.37 288.71,82.37 290.29,83.95 290.91,83.95 291.79,84.84 v1(293.31,84.84)
  IN2 w0.122: v1(295.79,72.38) 295.79,72.59 296.22,73.02 296.22,73.44 295.87,73.79 295.87,77.1 296.1,77.33 296.1,85.23 295.6,85.73 294.02,85.73 293.31,85.02 v1(293.31,84.84) ; v1(160.92,58.84) 161.53,58.84 162.5,59.81 164.63,59.81 164.75,59.92 167.67,59.92 169.76,62.02 173.33,62.02 176.28,59.07 176.28,58.39 177.01,57.66 178.72,57.66 179.16,58.1 183.06,58.1 183.66,57.5 187.53,57.5 188.87,58.84 188.87,59.63 190.35,61.11 193.64,61.11 193.92,60.83 194.24,60.83 199.93,55.14 199.93,45.84 203.37,42.39 205.73,42.39 207.64,40.49 211.51,40.49 218.21,33.79 224.63,33.79 225.09,33.33 231.34,33.33 231.92,33.9 239.34,33.9 241.74,31.51 243.97,31.51 245.37,32.9 249.09,32.9 249.33,33.14 259.05,33.14 260.13,34.22 260.95,34.22 261.87,33.29 263.82,33.29 264.93,34.41 267.01,34.41 269.67,37.07 269.67,40.29 270.22,40.83 270.22,41.34 271.64,42.76 271.64,47.61 270.73,48.52 270.73,49.84 272.47,51.59 272.47,52.83 273.26,53.61 273.75,53.61 275.12,54.99 275.12,55.97 276.79,57.64 276.79,59.65 277.11,59.96 277.11,61.23 278.01,62.13 278.01,62.13 278.25,62.37 278.25,65.04 278.01,65.28 278.01,65.65 276.87,66.79 276.87,69.48 276.74,69.61 v1(276.74,70.44)
  BOTTOM w0.127: v1(295.79,72.38) 295.79,71.62 295.54,71.37 293.88,71.37 293.46,71.79 290.95,71.79 290.67,72.07 288.64,72.07 287.94,72.76 286.77,72.76 286.56,72.56 280.1,72.56 279.1,71.55 279.1,69.81 278.71,69.41 277.17,69.41 276.74,69.84 v1(276.74,70.44) ; JESPI.10 295.47,83.13 293.77,84.84 v1(293.31,84.84)
ESPI_CS#: length 252.7
  TOP w0.127: v1(278.61,81.45) 278.3,81.76 UE1.H6
  IN1 w0.084: v1(290.3,82.51) 289.5,82.51 288.84,81.85 287.72,81.85 287.22,81.34 287.22,80.77 286.91,80.46 284.47,80.46 283.9,81.02 282.41,81.02 282.33,81.11 282.33,81.63 281.35,82.61 279.94,82.61 279.8,82.46 279.8,82.09 279.55,81.85 279.31,81.85 278.91,81.45 v1(278.61,81.45) ; v1(294.02,73.34) 294.3,73.34 294.48,73.16 294.48,72.35 294.07,71.94 294.07,67.3 291.82,65.05 290,65.05 289.91,64.97 289.91,61.58 288.22,59.89 285.18,59.89 284.93,60.14 282.57,60.14 281.07,61.65 279.22,61.65 277.36,63.51 274.6,63.51 274.22,63.12 274.22,62.46 v1(272.85,61.1)
  IN2 w0.089: 149.06,66.66 149.06,67.93 147.03,69.96 147.03,73.49 v1(146.67,73.85)
  IN2 w0.122: v1(294.02,73.34) 293.7,73.66 293.7,74.33 295.12,75.75 295.12,76.42 294.52,77.02 294.52,78.64 295.16,79.29 295.16,80.82 294.35,81.64 293.33,81.64 292.46,82.51 v1(290.3,82.51) ; v1(272.85,61.1) 272.19,61.1 271.28,60.19 271.28,57.23 271.86,56.66 271.86,54.86 270.14,53.14 270.14,52.98 269.9,52.74 269.9,51.62 268.95,50.67 268.95,47.81 269.88,46.88 269.88,45.54 269.6,45.26 269.6,43.25 263.94,37.58 261.26,37.58 260.62,36.94 256.62,36.94 255.99,36.31 254,36.31 253.82,36.13 252.86,36.13 252.85,36.14 247.54,36.14 243.88,32.48 241.83,32.48 239.65,34.65 218.41,34.65 216.89,36.17 211.82,41.24 207.95,41.24 206.05,43.15 203.69,43.15 200.69,46.15 200.69,55.45 194.62,61.51 194.62,62.04 194.39,62.27 192.4,62.27 191.99,61.86 189.67,61.86 187.43,59.62 187.43,59.03 186.93,58.53 183.69,58.53 183.38,58.85 180.43,58.85 180.03,59.24 179.24,59.24 178.41,58.41 177.32,58.41 177.03,58.7 177.03,59.38 173.79,62.62 173.65,62.77 169.34,62.77 167.9,61.32 166.5,61.32 164.84,62.98 160.36,62.98 159.99,63.35 151.86,63.35 151.4,63.81 149.75,63.81 149.06,64.5 149.06,66.66
  BOTTOM w0.089: UC1.CA28 146.29,74.08 v1(146.67,73.85)
  BOTTOM w0.127: v1(290.3,82.51) 291.44,82.51 292.32,81.63 JESPI.7
ESPI_IO0: length 230.3
  TOP w0.127: UE1.K5 280.2,80.58 v1(280.2,80.56) ; v2(165.04,58.15) 164.49,58.7 v1(164.49,58.86) RC366.2
  IN1 w0.084: v1(291.74,78.75) 291.59,78.61 284.83,78.61 283.47,79.97 281.47,79.97 281.31,80.13 280.63,80.13 v1(280.2,80.56) ; v1(292.31,73.7) 292.31,73.63 292.77,73.17 292.77,72.6 293.17,72.19 293.17,68.74 290.73,66.3 289.61,66.3 289.28,65.97 289.28,62.8 287,60.52 285.45,60.52 285.19,60.78 282.83,60.78 281.33,62.28 280.36,62.28 v1(279.55,63.09)
  IN2 w0.122: v1(292.31,73.7) 292.31,73.98 292.56,74.22 292.56,77.93 v1(291.74,78.75) ; v1(279.55,63.09) 279.75,62.89 279.75,61.87 279.44,61.56 279.44,60.15 279.72,59.87 279.72,57.33 279.9,57.16 279.9,55.65 279.47,55.23 279.47,54.75 278.03,53.31 275.37,53.31 274.45,52.4 274.45,50.98 272.45,48.97 272.45,42.26 271.22,41.04 271.22,40.56 270.83,40.16 270.83,37.14 271.21,36.77 271.21,36.59 271.01,36.39 270.84,36.39 270.54,36.69 270.37,36.69 270.19,36.52 270.19,36.35 270.49,36.05 270.49,35.88 269.84,35.23 269.67,35.23 269.37,35.53 269.2,35.53 269.03,35.36 269.03,35.18 269.37,34.84 269.37,34.43 268.6,33.65 265.24,33.65 264.13,32.54 261.8,32.54 261.39,32.13 259.4,32.13 258.96,31.69 257.01,31.69 256.89,31.81 256.89,32.26 256.76,32.38 256.52,32.38 256.4,32.26 256.4,31.81 256.28,31.69 256.03,31.69 255.91,31.81 255.91,32.26 255.79,32.38 255.54,32.38 255.42,32.26 255.42,31.81 255.3,31.69 255.07,31.69 254.89,31.87 254.89,32.26 254.77,32.38 253.69,32.38 249.63,32.38 249.37,32.13 245.65,32.13 244,30.47 241.71,30.47 239.03,33.15 232.23,33.15 231.65,32.57 224.78,32.57 224.32,33.03 217.9,33.03 211.24,39.7 204.61,39.7 204.49,39.82 204.49,40.74 204.22,41.01 201.99,41.01 198.48,44.52 198.48,45.32 196.58,47.22 196.58,48.25 196.71,48.38 197.11,48.38 197.23,48.5 197.23,48.74 197.11,48.86 196.71,48.86 196.58,48.98 196.58,49.23 196.71,49.35 197.11,49.35 197.23,49.47 197.23,49.72 197.11,49.84 196.71,49.84 196.58,49.96 196.58,50.2 196.71,50.33 197.11,50.33 197.23,50.45 197.23,50.69 197.11,50.81 196.71,50.81 196.58,50.94 196.58,51.18 196.71,51.3 197.11,51.3 197.23,51.42 197.23,51.67 197.11,51.79 196.71,51.79 196.58,51.91 196.58,52.15 196.71,52.28 197.11,52.28 197.23,52.4 197.23,52.64 197.11,52.76 196.71,52.76 196.58,52.89 196.58,53.13 196.71,53.25 197.11,53.25 197.23,53.37 197.23,53.62 197.11,53.74 196.71,53.74 196.58,53.86 196.58,54.11 196.71,54.23 197.11,54.23 197.23,54.35 197.23,54.59 197.11,54.72 196.71,54.72 196.58,54.84 196.58,55.08 196.71,55.2 197.11,55.2 197.23,55.32 197.23,55.57 197.11,55.69 196.71,55.69 196.58,55.81 196.58,57.1 194.86,58.83 193.33,60.36 190.66,60.36 189.62,59.32 189.62,58.53 187.84,56.75 183.35,56.75 182.75,57.35 179.47,57.35 179.03,56.91 176.7,56.91 176.1,57.51 175.53,58.08 175.53,58.75 173.02,61.26 170.07,61.26 167.73,58.92 166.87,58.92 166.62,59.17 165.06,59.17 164.74,58.86 v1(164.49,58.86)
  BOTTOM w0.127: JESPI.3 295.02,79.63 294.71,79.32 293.03,79.32 292.47,78.75 v1(291.74,78.75)
ESPI_IO0_R: length 30.1
  TOP w0.127: RC366.1 v1(164.49,60.94) 164.49,61.22 164.74,61.46 v2(164.74,61.93)
  IN2 w0.089: 148.81,66.66 148.81,67.93 146.77,69.96 146.77,70.47 146.3,70.94 146.3,72.85 v1(146.67,73.22)
  IN2 w0.122: 148.81,66.66 148.81,64.39 149.64,63.56 151.3,63.56 151.58,63.28 151.58,62.41 151.8,62.19 152.82,62.19 153.1,62.47 159.62,62.47 160.01,62.08 163.35,62.08 v1(164.49,60.94)
  BOTTOM w0.089: UC1.CA29 v1(146.67,73.22)
ESPI_IO1: length 231.9
  TOP w0.127: v2(163.91,57.47) 163.67,57.72 v1(163.67,58.86) RC367.2 ; UE1.L4 281.02,79.76 v1(281.1,79.76)
  IN1 w0.084: v1(292.27,73.14) 292.39,73.01 292.39,72.68 292.96,72.11 292.96,68.82 290.65,66.51 289.52,66.51 289.07,66.06 289.07,62.89 286.91,60.73 285.53,60.73 285.28,60.99 282.92,60.99 281.16,62.75 v1(281.15,62.75) ; v1(291.54,78.23) 290.01,78.23 289.84,78.39 284.74,78.39 283.38,79.76 v1(281.1,79.76)
  IN2 w0.122: v1(281.15,62.75) 281.15,61.94 281.02,61.81 280.29,61.81 280.17,61.69 280.17,61.45 280.29,61.33 281.02,61.33 281.15,61.21 281.15,60.32 281.41,60.06 281.41,59.69 281.28,59.57 280.16,59.57 280.04,59.44 280.04,59.2 280.16,59.08 281.28,59.08 281.41,58.96 281.41,57.51 281.28,57.38 280.27,57.38 280.15,57.26 280.15,57.02 280.27,56.9 281.28,56.9 281.41,56.77 281.41,56.03 279.79,54.41 279.49,54.41 278.13,53.06 275.47,53.06 274.7,52.29 274.7,50.88 272.7,48.87 272.7,42.16 271.47,40.93 271.47,40.45 271.08,40.06 271.08,37.25 271.46,36.87 271.46,36.49 269.63,34.66 269.63,34.33 268.7,33.41 265.35,33.41 264.23,32.29 261.9,32.29 261.49,31.88 259.5,31.88 259.06,31.44 254.97,31.44 254.28,32.13 253.8,32.13 249.73,32.13 249.47,31.88 245.76,31.88 244.1,30.22 241.61,30.22 239.58,32.24 232.92,32.24 232.8,32.12 232.8,31.74 232.68,31.62 232.35,31.62 232.22,31.74 232.22,32.26 232.1,32.38 231.86,32.38 231.74,32.26 231.74,31.74 231.61,31.62 231.34,31.62 231.18,31.78 231.18,32.25 231.12,32.32 224.69,32.32 224.22,32.79 217.8,32.79 212.29,38.29 210.92,38.29 210.8,38.41 210.8,39.33 210.68,39.45 210.44,39.45 210.32,39.33 210.32,38.41 210.19,38.29 209.95,38.29 209.83,38.41 209.83,39.33 209.71,39.45 209.46,39.45 209.34,39.33 209.34,38.41 209.22,38.29 208.97,38.29 208.85,38.41 208.85,39.33 208.73,39.45 208.49,39.45 208.36,39.33 208.36,38.41 208.24,38.29 208.02,38.29 207.78,38.54 207.78,39.3 207.63,39.45 204.36,39.45 204.24,39.57 204.24,40.64 204.12,40.76 201.89,40.76 198.23,44.42 198.23,45.22 196.34,47.12 196.34,57 194.06,59.27 193.23,60.11 190.76,60.11 189.87,59.22 189.87,58.43 187.94,56.5 183.24,56.5 182.65,57.1 179.58,57.1 179.14,56.66 176.6,56.66 175.28,57.97 175.28,58.65 172.92,61.01 170.17,61.01 167.69,58.54 167.46,58.54 167.31,58.38 165.85,58.38 165.78,58.31 164.21,58.31 v1(163.67,58.86) ; v1(292.27,73.14) 292.27,73.15 291.92,73.5 291.92,73.94 292.31,74.33 292.31,77.46 v1(291.54,78.23)
  BOTTOM w0.127: v1(291.54,78.23) 291.34,78.42 291.34,79.02 291.47,79.15 292.39,79.15 292.9,79.66 294.61,79.66 295.08,80.13 JESPI.4
ESPI_IO1_R: length 29.8
  TOP w0.127: RC367.1 v1(163.67,60.94) 163.67,61.34 v2(163.48,61.53)
  IN2 w0.089: v1(145.76,73.22) 146.12,72.86 146.12,70.87 146.6,70.39 146.6,69.89 148.56,67.92 148.56,66.66
  IN2 w0.122: 148.56,66.66 148.56,62.26 148.88,61.94 152.92,61.94 153.2,62.22 159.52,62.22 159.91,61.83 162.78,61.83 v1(163.67,60.94)
  BOTTOM w0.089: UC1.BY29 145.3,73.48 v1(145.76,73.22)
ESPI_IO2: length 231.2
  TOP w0.127: UE1.G6 277.75,81.42 v1(277.81,81.42) ; v2(162.84,58.27) v1(162.84,58.86) RC368.2
  IN1 w0.084: v1(291.8,80.25) 291.23,80.25 290.86,79.88 289.63,79.88 288.78,79.03 285.01,79.03 283.64,80.39 281.8,80.39 281.25,80.95 278.4,80.95 277.92,81.42 v1(277.81,81.42) ; v1(293.14,73.02) 293.14,72.53 293.38,72.28 293.38,68.65 290.82,66.09 289.69,66.09 289.49,65.88 289.49,62.72 287.09,60.31 285.36,60.31 285.11,60.57 282.74,60.57 281.24,62.07 279.78,62.07 v1(279.19,62.65)
  IN2 w0.122: v1(162.84,58.86) 163.29,59.3 164.84,59.3 164.95,59.42 166.72,59.42 166.98,59.17 167.62,59.17 169.97,61.51 173.12,61.51 175.78,58.86 175.78,58.18 176.8,57.16 178.93,57.16 179.37,57.6 182.86,57.6 183.45,57 187.74,57 189.37,58.64 189.37,59.43 190.55,60.61 193.43,60.61 194.49,59.55 194.81,59.55 199.43,54.93 199.43,54.56 199.31,54.43 198.31,54.43 198.19,54.31 198.19,54.07 198.31,53.95 199.31,53.95 199.43,53.82 199.43,53.58 199.31,53.46 198.24,53.46 198.12,53.34 198.12,53.09 198.24,52.97 199.31,52.97 199.43,52.85 199.43,52.61 199.31,52.48 198.24,52.48 198.12,52.36 198.12,52.12 198.24,52 199.31,52 199.43,51.87 199.43,51.63 199.31,51.51 198.24,51.51 198.12,51.39 198.12,51.14 198.24,51.02 199.31,51.02 199.43,50.9 199.43,50.65 199.31,50.53 198.87,50.53 198.75,50.41 198.75,50.17 198.87,50.05 199.31,50.05 199.43,49.92 199.43,45.63 203.17,41.89 205.52,41.89 207.43,39.98 211.3,39.98 218,33.28 224.42,33.28 224.88,32.82 231.55,32.82 232.13,33.4 239.13,33.4 241.81,30.72 243.9,30.72 245.58,32.4 249.29,32.4 249.52,32.63 253.59,32.63 259.05,32.63 259.3,32.38 261.29,32.38 261.7,32.79 264.03,32.79 265.14,33.9 267.22,33.9 270.18,36.86 270.18,40.08 270.72,40.62 270.72,41.13 272.18,42.59 272.18,47.78 271.23,48.73 271.23,49.04 271.82,49.63 271.82,49.8 271.7,49.93 271.7,50.1 271.87,50.27 272.04,50.27 272.17,50.15 272.34,50.15 272.98,50.79 272.98,52.62 273.46,53.11 273.96,53.11 275.01,54.16 276.74,54.16 277.07,54.49 277.07,56.15 278.5,57.58 278.5,59.93 278.77,60.19 278.77,61.08 279.19,61.51 v1(279.19,62.65) ; v1(293.14,73.02) 293.14,73.19 293.45,73.51 293.45,74.27 292.8,74.92 292.8,79.25 v1(291.8,80.25)
  BOTTOM w0.127: JESPI.5 292.18,80.63 v1(291.8,80.25)
