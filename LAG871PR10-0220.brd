# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_CORE_G0: length 2.8
  TOP w0.127: v1(134.05,84.89) 133.61,84.45 133.61,84.07 T371.1
  BOTTOM w0.2: v1(134.05,84.89) 133.94,85.01 UC1.BB9
+VCC_CORE_G1: length 1.5
  TOP w0.127: T372.1 v1(134.82,76.91)
  BOTTOM w0.2: T372.1 v1(134.82,76.91)
+VCC_CORE_G2: length 1.8
  TOP w0.127: T373.1 132.91,84.7 v1(132.91,84.96)
  BOTTOM w0.2: UC1.AY9 133.02,85.06 v1(132.91,84.96)
+VCC_CORE_G3: length 1.4
  TOP w0.127: T374.1 133.91,76.2 v1(133.91,76.9)
  BOTTOM w0.2: UC1.BB24 v1(133.91,76.9)
+VCC_GT: length 96.3
  TOP w0.381: PC1107.1 93.8,81.97 v1(93.73,81.91)
  TOP w0.508: 110.04,92.5 110.04,96.08 109.54,96.58 v1(109.54,97.11) ; PC1122.1 99,75.5 v1(99,76.07)
  BOTTOM w0.1: 109.74,86.99 109.96,86.76 ; 109.96,86.76 109.74,86.54 ; 109.96,86.76 UC1.B8 110.19,86.99 ; 109.96,86.76 110.19,86.54 ; 118.46,85.84 UC1.T9 ; UC1.T9 118.01,86.28 ; UC1.T9 118.46,86.28 ; UC1.T9 118.01,85.84 ; UC1.N9 116.61,86.28 ; UC1.N9 116.16,85.84 ; UC1.N9 116.16,86.28 ; UC1.N9 116.61,85.84 ; UC1.T10 118,85.83 ; UC1.T10 117.55,85.83 ; UC1.T10 118.05,85.32 ; UC1.T10 117.49,85.32 ; UC1.U10 118.92,85.83 ; UC1.U10 118.42,85.32 ; UC1.U10 118.47,85.83 ; UC1.U10 118.98,85.32 ; UC1.C8 110.83,87.07 ; UC1.C8 110.83,86.62 ; UC1.C8 110.39,87.07 ; UC1.C8 110.39,86.62 ; 114.78,85.83 UC1.L10 ; UC1.L10 115.23,85.38 ; UC1.L10 114.78,85.38 ; UC1.L10 115.23,85.83 ; UC1.N10 115.65,85.32 ; UC1.N10 115.7,85.83 ; UC1.N10 116.15,85.83 ; UC1.N10 116.2,85.32 ; 110.61,88.07 UC1.C6 ; 110.61,88.07 110.84,87.84 ; 110.61,88.07 110.39,87.84 ; 110.61,88.07 110.39,88.29 ; 109.31,86.76 109.09,86.54 ; 109.31,86.76 109.54,86.54 ; 109.31,86.76 UC1.A8 109.54,86.99 ; 109.31,86.76 109.09,86.99 ; 110.63,90.31 UC1.C2 110.18,90.31 ; UC1.R9 117.09,85.84 ; UC1.R9 117.09,86.28 ; UC1.R9 117.54,85.84 ; UC1.R9 117.54,86.28 ; 114.74,85.4 UC1.K11 114.74,84.95 ; UC1.C7 110.07,87.64 ; UC1.C7 110.07,87.19 ; UC1.C7 110.51,87.64 ; UC1.C7 110.51,87.19 ; 109.96,88.07 UC1.B6 ; 109.96,88.07 110.19,88.29 ; 109.96,88.07 109.74,87.84 ; 109.96,88.07 110.19,87.84 ; 109.96,88.07 109.74,88.29 ; UC1.M9 115.24,85.84 ; UC1.M9 115.24,86.28 ; UC1.M9 115.69,86.28 ; UC1.M9 115.69,85.84 ; UC1.V9 119.38,86.28 ; UC1.V9 118.93,86.28 ; UC1.V9 118.93,85.84 ; UC1.V9 119.38,85.84 ; 119.86,86.28 UC1.W9 119.86,85.84
  BOTTOM w0.18: UC1.K2 114.54,91.48 v1(113.56,92.47) ; UC1.P2 116.99,92.04 116.74,92.29 v1(116.74,92.47)
  BOTTOM w0.2: 111.26,79.52 v1(110.94,79.99) ; 111.26,79.52 UC1.D20 UC1.F20 ; 111.26,79.52 UC1.C20 110.61,79.52 ; v1(110.94,79.99) 111.26,80.46 ; v1(110.94,79.99) 110.61,80.46 ; v1(110.94,79.99) 110.61,79.52 ; UC1.H11 v1(112.89,84.7) ; UC1.H11 UC1.J11 ; UC1.H11 UC1.G11 ; v1(112.89,84.7) UC1.G12 ; v1(112.89,84.7) UC1.G11 ; v1(112.89,84.7) UC1.H12 UC1.G12 ; v1(112.89,81.88) UC1.H17 ; v1(112.89,81.88) UC1.G17 ; v1(112.89,81.88) UC1.G15 ; v1(112.89,81.88) UC1.H15 ; UC1.H17 v1(113.54,81.88) ; UC1.H17 UC1.J17 v1(113.54,81.88) ; UC1.H17 UC1.G17 ; UC1.G12 v1(112.24,84.7) ; 109.96,79.52 UC1.A20 109.31,79.52 v1(108.99,79.99) 109.31,80.46 UC1.A18 ; 109.96,79.52 UC1.B20 110.61,79.52 ; 109.96,79.52 v1(110.29,79.99) ; UC1.G20 v1(112.24,79.99) ; UC1.G20 UC1.H20 ; UC1.G20 v1(112.89,79.99) ; UC1.G20 UC1.F20 ; v1(112.24,79.99) UC1.F20 ; v1(112.24,79.99) UC1.G18 ; UC1.G17 UC1.F17 ; UC1.G17 v1(112.24,81.88) ; UC1.F17 v1(112.24,81.88) ; UC1.F17 UC1.D17 111.26,81.4 ; UC1.G15 UC1.H15 ; UC1.G15 v1(112.24,82.82) ; UC1.G15 v1(112.24,81.88) ; UC1.G15 v1(112.89,82.82) ; UC1.H15 v1(113.54,81.88) ; UC1.H15 v1(112.89,82.82) ; UC1.G14 UC1.H14 ; UC1.G14 UC1.F14 ; UC1.G14 v1(112.89,82.82) ; UC1.H14 UC1.J14 ; UC1.H14 v1(112.89,82.82) ; 111.26,80.46 UC1.C18 110.61,80.46 ; 111.26,80.46 UC1.D18 ; 111.26,83.29 UC1.C14 110.61,83.29 ; 111.26,83.29 111.07,83.01 v1(110.94,82.82) ; 111.26,83.29 UC1.D14 UC1.F14 ; 110.61,80.46 v1(110.29,79.99) ; UC1.H20 v1(112.89,79.99) ; UC1.H20 UC1.J20 ; UC1.C12 110.61,84.23 ; 110.61,84.23 v1(110.29,84.7) ; 110.61,84.23 v1(110.94,84.7) ; 110.61,84.23 111.26,84.23 ; 109.96,83.29 v1(110.29,82.82) ; 109.96,83.29 UC1.B14 110.61,83.29 ; 109.96,83.29 UC1.A14 109.31,83.29 109.12,83.01 v1(108.99,82.82) 109.31,82.35 ; v1(110.29,82.82) 110.42,83.01 110.61,83.29 ; v1(110.29,82.82) 110.61,82.35 ; 109.96,81.4 UC1.B17 110.61,81.4 ; 109.96,81.4 v1(109.64,81.88) ; 109.96,81.4 v1(110.29,81.88) ; 109.96,81.4 UC1.A17 109.31,81.4 ; 111.26,82.35 UC1.D15 ; 111.26,82.35 v1(110.94,82.82) ; 111.26,82.35 v1(110.94,81.88) ; 111.26,82.35 v1(111.59,82.82) UC1.F14 ; 111.26,82.35 UC1.C15 110.61,82.35 ; 110.61,83.29 110.81,83.01 v1(110.94,82.82) ; 109.96,85.17 109.31,85.17 ; 109.96,85.17 v1(110.29,84.7) ; 109.96,85.17 UC1.B11 ; 109.96,85.17 110.61,85.17 ; 109.31,85.17 UC1.A11 ; 109.31,85.17 v1(108.99,84.7) 109.31,84.23 UC1.A12 ; UC1.G18 UC1.H18 v1(112.89,79.99) ; UC1.G18 v1(112.89,79.99) ; v1(110.29,84.7) 110.61,85.17 ; 110.61,82.35 v1(110.94,82.82) ; 110.61,82.35 v1(110.29,81.88) ; 110.61,82.35 v1(110.94,81.88) ; v1(110.29,81.88) 110.61,81.4 ; 109.31,81.4 v1(108.99,81.88) 109.31,82.35 ; 109.31,81.4 v1(109.64,81.88) ; UC1.G11 UC1.F11 ; UC1.G11 v1(112.24,84.7) ; UC1.F11 v1(112.24,84.7) ; UC1.F11 111.26,85.17 ; v1(110.94,81.88) 111.26,81.4 ; v1(110.94,81.88) 110.61,81.4 ; 110.61,85.17 v1(110.94,84.7) ; 110.61,85.17 111.26,85.17 ; 110.61,85.17 UC1.C11 ; v1(110.94,84.7) 111.26,85.17 ; v1(110.94,84.7) 111.26,84.23 ; 110.61,81.4 UC1.C17 111.26,81.4 ; v1(109.64,81.88) 109.31,82.35 ; 111.26,85.17 UC1.D11 ; 110.61,79.52 v1(110.29,79.99) ; 109.31,82.35 UC1.A15 ; 111.26,84.23 UC1.D12
  BOTTOM w0.203: UC1.D14 v1(111.59,82.82) ; UC1.F14 v1(112.24,82.82) UC1.G14
  BOTTOM w0.508: v1(109.54,97.11) 109.05,97.6 RC160.1
  vias: v1(87.13,72.51) v1(87.13,71.94) v1(87.76,72.51) v1(87.76,71.94) v1(88.4,72.51) v1(88.4,71.94) v1(89.03,70.73) v1(89.03,70.16) v1(89.03,68.95) v1(89.03,68.32) v1(89.03,67.74) v1(89.67,72.51) v1(89.67,71.94) v1(89.67,71.37) v1(89.67,70.8) v1(89.67,70.22) v1(90.3,72.57) v1(90.3,72) v1(90.3,71.37) v1(90.3,70.8) v1(90.3,70.22) v1(90.3,68.83) v1(90.99,73.79) v1(90.99,73.21) v1(90.94,72.57) v1(90.94,72) v1(90.94,71.37) v1(90.94,70.8) v1(91.57,73.79) v1(91.57,73.21) v1(91.57,72.57) v1(91.57,72) v1(91.57,71.37) v1(91.57,70.8) v1(91.54,69.48) v1(92.14,73.79) v1(92.14,73.21) v1(92.21,72.57) v1(92.21,72) v1(104.97,85.59) v1(108.35,88.27) v1(108.39,79.72) v1(108.48,86.76) v1(111.77,88.67) v1(111.77,88.04) v1(111.77,87.4) v1(111.77,86.77) v1(112.69,88.67) v1(112.69,88.04) v1(112.69,87.4) v1(112.69,86.77) v1(113.61,88.69) v1(113.61,88.06) v1(113.61,87.42) v1(113.61,86.84) v1(114.54,87.4) v1(115,84.7) v1(115.46,87.4) v1(115.46,86.77) v1(115.53,85.15) v1(115.93,84.73) v1(116.39,87.4) v1(116.39,86.77) v1(116.43,85.11) v1(117.31,86.77) v1(117.37,85.11) v1(117.84,84.73) v1(118.23,86.77) v1(118.3,85.11) v1(118.76,84.73) v1(119.16,86.77) v1(119.19,85.09) v1(120.08,86.77) v1(120.15,85.11) v3(93.62,72.98)
+VCC_SA: length 27.5
  TOP w0.254: v1(133.55,98.24) 133.6,98.29 RC166.1
  IN3 w0.508: 138.12,91.94 137.31,92.75 137.31,93.53 136.78,94.05 136.78,95.62 138.18,97.02 138.18,98.78 137.53,99.43 135.19,99.43 133.99,98.24 v1(133.55,98.24)
  BOTTOM w0.1: 139.26,85.84 UC1.BL9 ; UC1.BL9 139.71,85.84 ; UC1.BL9 139.71,86.28 ; UC1.BL9 139.26,86.28 ; 140.52,75.48 UC1.BN25 140.52,75.93 ; UC1.BL8 140.17,86.29 ; UC1.BL8 140.17,86.74 ; UC1.BL8 139.72,86.74 ; UC1.BL8 139.72,86.29 ; UC1.BJ8 138.32,86.29 ; UC1.BJ8 137.87,86.74 ; UC1.BJ8 138.32,86.74 ; UC1.BJ8 137.87,86.29 ; 139.72,85.38 UC1.BL10 139.72,85.83 ; UC1.BJ10 138.32,85.83 ; UC1.BJ10 137.87,85.83 ; UC1.BJ10 137.87,85.38 ; UC1.BJ10 138.32,85.38 ; 137.4,86.74 UC1.BG8 137.4,86.29 ; 137.4,85.38 UC1.BG10 137.4,85.83 ; UC1.BK8 138.8,86.74 ; UC1.BK8 139.24,86.74 ; UC1.BK8 139.24,86.29 ; UC1.BK8 138.8,86.29 ; 139.38,76.17 139.15,76.4 ; 139.38,76.17 139.15,75.95 ; 139.38,76.17 UC1.BL24 ; 137.86,86.28 UC1.BH9 ; UC1.BH9 137.41,86.28 ; UC1.BH9 137.41,85.84 ; UC1.BH9 137.86,85.84 ; 138.33,85.84 UC1.BJ9 ; UC1.BJ9 138.78,86.28 ; UC1.BJ9 138.78,85.84 ; UC1.BJ9 138.33,86.28 ; 139.15,75.93 UC1.BK25 139.15,75.48 ; 140.51,76.4 UC1.BM24 140.51,75.95
  vias: v1(92.97,87.62) v1(93.54,87.62) v1(93.54,86.99) v1(93.54,86.35) v1(93.54,85.72) v1(93.54,85.1) v1(94.11,87.62) v1(94.11,86.99) v1(94.11,86.35) v1(94.11,85.72) v1(137.17,84.74) v1(137.63,86.77) v1(137.63,85.4) v1(138.13,84.73) v1(138.56,86.77) v1(138.56,85.4) v1(139.05,76.51) v1(139.38,77.06) v1(139.48,86.77) v1(139.48,85.4) v1(139.78,84.74) v1(140.29,77.04) v1(140.41,86.77) v3(138.73,86.07)
+VCCDPHY_1P24:
  vias: v3(159.34,74.64)
+VCCPDSW_1P05: length 2.1
  TOP w0.356: CC65.1 146.26,76.45 v2(146.26,76.27) 146.11,76.12 v1(145.64,76.12)
  BOTTOM w0.2: UC1.BT24 v1(143.04,76.12)
+VCCPLL_OC: length 1.2
  BOTTOM w0.2: v1(139.38,74.49) UC1.BL27 UC1.BM26
  vias: v1(139.92,70.97) v3(141.89,55.52)
+VDDA_AVDD1: length 4.3
  TOP w0.203: CA8.1 283.08,44.69 282.32,43.93 UA1.40
  TOP w0.254: 283.22,46.9 282.59,46.27 282.59,45.9 282.67,45.83 282.67,45.18 282.87,44.98 CA8.1
GND: length 4607.3
  TOP w0.127: v1(103.28,26.49) v3(103.28,25.46) ; RC751.1 154.32,96.4 v1(155.2,97.28) 155.26,97.34 156.15,97.34 156.47,97.02 161.11,97.02 162.5,98.42 162.5,98.67 162.19,98.99 161.93,98.99 160.47,97.53 156.79,97.53 156.42,97.9 154.23,97.9 v1(154.1,97.76) 154.06,97.72 153.23,97.72 152.91,97.4 152.91,94.29 154.32,92.88 154.64,92.88 v1(155.14,93.38) ; v1(174.82,105.33) v3(174.82,106.41)
  TOP w0.203: v1(179.27,94.42) 179.35,94.34 UZ3.11 ; v1(294.54,52.92) 294.63,52.83 UZ5.11 ; UZ43.11 259.39,55.7 259.15,55.94 258.37,55.94 257.8,56.51 CZ109.2 ; UZ47.11 v1(266.54,41.37)
  TOP w0.254: DT18.2 12.81,88.58 v1(12.52,88.28) ; DT18.2 v1(13.15,88) ; DT18.2 13.49,88.58 v1(13.79,88.28) ; CE31.2 280.93,74.77 v1(280.57,74.41) ; QE2.4 280.6,66.63 281.36,67.39 v1(281.88,67.39) ; v1(219.4,28.82) 219.82,28.82 220.09,29.1 PU200.15 ; v1(184.73,82.45) 184.91,82.63 UZ12.32 ; v1(13.91,83.52) DT14.2 ; DT14.2 13.57,82.95 v1(13.28,83.24) ; DT14.2 14.25,82.95 v1(14.55,83.24) ; v1(11.44,81.02) 11.69,81.27 RT219.2 ; v1(140.34,108.13) 140.48,108.27 UZ19.5 ; v1(13.15,90.67) DT17.2 ; DT17.2 13.49,90.15 v1(13.79,90.44) ; DT17.2 12.81,90.15 v1(12.52,90.44) ; v1(12.53,81.08) 12.35,81.27 RT219.2 ; PR846.2 v1(42.68,93.59) ; RT219.2 v1(11.98,80.73) ; UZ12.16 179.95,79.13 v1(179.85,79.03) ; UI3.14 294.09,78.24 293.59,78.74 v1(293.58,78.74) 293.58,79.02 RI14.1 ; v1(13.91,80.8) DT13.2 ; DT13.2 13.57,81.38 v1(13.28,81.08) ; DT13.2 14.25,81.38 v1(14.55,81.08) ; CE15.2 279.85,74.29 279.34,73.78 278.71,73.78 v1(278.45,74.05) ; UZ12.23 184.41,77.59 184.66,77.34 v1(184.73,77.34) ; v1(11.77,90.42) 11.61,90.26 RT491.2 ; RT490.2 10.8,88.47 v1(10.59,88.26) ; RT490.2 11.56,88.47 v1(11.77,88.26) ; RT490.2 v1(11.22,87.92) ; v1(184.72,84.22) 184.41,83.91 UZ12.2 ; v1(242.63,36.57) 242.63,38.98 242.14,39.47 242.14,40.46 242.96,41.27 243.47,41.27 243.55,41.36 UZ29.20 ; RT491.2 10.84,90.26 v1(10.68,90.42) ; RT491.2 v1(11.22,90.8) ; v1(12.58,83.24) 12.39,83.06 RT220.2 ; v1(11.98,83.6) RT220.2 ; RT220.2 11.56,83.06 v1(11.44,83.18) ; v1(144.53,107.98) 145.52,107.98 UZ21.5 ; UE1.H4 278.55,79.83 v1(278.55,79.74) ; CT87.2 29.63,59.31 v1(29.8,59.31) ; UE1.A6 272.22,81.36 ; v1(29.8,57.56) 29.44,57.2 RT377.2 ; UZ29.11 243.55,46.52 v1(243.02,47.05) ; v1(30.68,86.16) 30.23,85.72 RT28.2 ; UZ29.2 245.1,41.77 245.29,41.57 v1(245.52,41.57) ; v1(281.63,74.42) 281.69,74.48 CE23.2 ; v1(295.45,23.32) 295.22,23.32 294.88,22.98 UZ8.5 ; UZ29.5 v1(245.93,43.67) ; PC219.2 224.89,28.63 224.88,28.65 v1(224.22,28.65) PU200.4 ; v1(92.22,95.24) 91.47,95.99 PU614.4 ; 84.31,24.97 v1(84.45,25.11) ; UE1.C4 v1(273.82,79.76) ; v1(141.74,82) 141.74,82.13 CC52.2 ; UZ53.5 24.36,33.91 24.12,34.14 24.12,34.94 v1(24.28,35.1) ; PQ1.1 68.39,92.22 67.8,91.62 67.34,91.62 67.09,91.37 PQ1.4 ; v1(181.58,82.45) 181.41,82.63 UZ12.9 ; UE1.A13 272.21,86.95 v1(272.2,86.95) ; v1(279.1,65.45) 279.41,65.45 279.6,65.25 QE2.1 ; CA10.2 276.74,42.54 276.45,42.83 CA31.2 ; JUSBC1.A1 7.28,88.47 6.85,88.91 v1(6.72,88.91) ; 84.26,24.84 84.31,24.78 84.31,24.42 PR412.1 ; UE1.E6 v1(275.42,81.36)
  TOP w0.279: JUSBC1.B12 6.34,88.72 6.5,88.88 6.67,88.88 6.7,88.91 v1(6.72,88.91) ; JUSBC1.B1 6.13,83.22 6.52,82.84 6.64,82.84 6.74,82.73 v1(6.8,82.73) 6.8,82.77 6.86,82.83 7.11,82.83 7.25,82.97 JUSBC1.A12
  TOP w0.305: CT39.2 27.2,77.89 v1(27.1,77.79)
  TOP w0.356: v1(302.37,98.33) 302.68,98.63 CZ308.2 CZ234.2 ; CC1463.2 143.16,75.36 v1(143.09,75.29) ; RC624.2 119.41,97.4 118.89,97.4 v1(118.88,97.39) ; v1(144.99,76.12) 144.99,76.22 CC65.2 ; v1(27.75,79.09) 27.72,79.06 CT26.2 ; PQ806.1 46.78,97.01 v1(47.19,97.42) 47.55,97.42 48.08,97.94 PQ806.4 ; PQ811.4 53.84,104.72 v1(53.52,104.39) 52.54,103.42 PQ811.1 ; RC106.2 142.14,75.53 141.92,75.31 v1(141.74,75.31) ; PC1139.2 113.79,79.74 v1(113.54,79.99) ; v1(25.15,76.49) 24.95,76.29 CT48.2 24.63,75.73 CT64.2 ; v1(29.7,80.39) 29.57,80.26 CT41.2 29.56,79.73 CT40.2 29.65,78.96 30.59,78.96 31.1,78.46 CT29.2 ; CZ233.2 CZ307.2 v1(304.33,95.28) ; PQ802.1 43.42,98.9 43.2,98.69 v1(42.96,98.69) 42.69,98.69 42.12,98.11 PQ802.4 ; v1(30.36,75.19) 30.55,75.19 30.97,75.61 CT31.2 ; v1(29.05,80.39) 28.93,80.52 CT25.2 ; 22.37,33.2 22.37,32.77 CZ305.2 21.93,32.05 20.5,32.05 v1(19.53,31.07) ; v1(106.93,112.87) 106.48,112.42 CC1466.2 ; PC1138.2 113.63,84.61 v1(113.54,84.7) ; v1(303.23,94.72) RZ1461.1
  TOP w0.381: v1(101.87,29.75) 102.05,29.93 102.05,31.18 101.67,31.56 CD26.2 100.81,31.56 CD25.2 ; PR720.2 41.59,69.34 PQ703.3 40.94,69.04 40.05,69.93 v1(39.36,69.93) ; v1(102.29,33.21) 102.45,33.21 103.1,32.55 103.1,32.07 RD9.2 ; v1(298.01,69.97) 297.74,69.7 297.29,69.7 296.79,69.21 CR15.2 ; PC812.2 PR843.2 42.41,77.51 42.67,77.25 v1(42.67,77.21) 42.67,77.17 42.57,77.07 PC805.2 42.19,76.16 v1(41.69,76.16) ; CR21.2 298.21,63.86 297.83,64.24 v1(297.02,64.24) 296.95,64.31 CR22.2 ; CT30.2 25.23,80.47 v1(25.15,80.39) ; v1(35.21,94.13) 35.39,93.95 36.5,93.95 PR819.2 ; DZ10.1 91.89,106.99 v1(91.76,106.86) 91.56,106.66 CV55.2 ; v1(26.3,47.56) 26.03,47.56 25.2,46.73 RT494.1 ; CZ93.2 v1(309.4,70.73) ; CZ106.2 v1(144.53,107.98) ; v1(159.43,40.52) 159.43,39.68 160.23,38.88 CD46.2 CD43.2 ; CZ64.2 267.55,30.87 v1(267.76,30.66) ; v1(167.24,33.73) 167.44,33.73 167.91,33.26 167.91,31.87 ; RT128.2 31.74,75.92 31.43,75.61 CT31.2 ; CZ156.2 242.06,47.19 242.32,46.92 242.89,46.92 v1(243.02,47.05) ; CC306.2 59.32,100.4 v1(59.36,100.36) 59.8,99.92 CC326.2 ; v1(140.41,85.4) 140.44,85.44 PC1166.2 ; CE22.2 287.56,80.13 v1(287.92,79.78) 287.92,79.62 287.66,79.37 RE342.2 ; v1(195.02,112.31) 195.21,112.13 PC314.1 ; v1(90.04,33.73) 90.62,33.14 CD8.2 ; CD60.2 199.06,40.2 v1(198.73,40.52) ; v1(27.77,73.89) 27.77,74.49 CT37.2 ; PD902.1 38.63,41.68 v1(38.32,41.99) ; RA45.2 286.44,59.3 v1(286.78,59.3) 287.1,59.3 CA62.2 ; CV652.2 86.72,103.09 87.45,103.82 88.94,103.82 CV651.2 ; JSD1.17 315.59,58.68 314.9,59.37 v1(314.71,59.37) ; v1(11.58,85.89) 11.58,85.89 DT40.3 ; CZ105.2 143.46,111.67 v1(143.3,111.82) ; v1(119.77,41.14) 119.83,41.08 CD12.2 ; PQ1.4 66.82,91.05 66.58,91.28 v1(66.58,91.51) ; v1(142.04,61.91) 141.9,61.77 RC848.1 ; v1(292.29,57.51) 292.15,57.65 RZ334.2 ; v1(30.36,75.19) 30.3,75.24 CT32.2 ; v1(56.89,95.7) 56.57,96.02 RC139.2 ; PC219.2 225.32,28.37 PC218.2 225.69,27.5 PC227.2 ; PC739.1 42.74,56.2 PC736.2 41.84,55.3 41.37,55.3 41.06,55.62 v1(41.04,55.62) ; PR420.2 182.51,30.09 v1(182.06,29.65) ; CE66.2 287.8,82.53 v1(288.02,82.75) ; PR8.2 50.77,80.61 PQ3.3 51.76,80.61 52.21,80.16 v1(52.21,79.18) ; v1(275.89,38.11) 274.97,38.11 CA33.2 ; CT62.2 25.28,77.27 v1(25.15,77.14) ; DI5.1 293.5,87.5 v1(293.19,87.18) ; v1(98.88,106.57) 98.88,106.29 99.47,105.7 CZ3.2 ; DZ21.1 96.84,106.87 v1(96.54,106.57) ; CC269.2 62.92,95.47 63.08,95.63 v1(63.08,95.78) 63.08,95.78 CC307.2 ; v1(53,93.21) 53,92.99 52.62,92.61 PU3.3 ; v1(199.23,29.83) 199.36,29.97 CD72.2 CD71.2 ; v1(297.17,80.22) 296.95,80.22 CI17.2 296.06,79.88 CI44.2 ; v1(149.61,107.18) 149.45,107.35 CZ101.2 ; v1(87.24,65.65) 87.24,64.55 87.53,64.26 RC420.1 ; CC73.2 152.02,52.27 v1(152.15,52.13) ; CA55.2 278.12,35.6 v1(277.76,35.24) ; v1(201.82,29.68) 201.82,30.44 CD55.2 ; CZ83.2 249.57,32.4 CZ90.2 ; v1(147.39,75.22) 147.29,75.32 RC107.2 ; v1(203.39,38.9) 203.39,39.07 CD51.2 CD50.2 ; PQ813.1 45.7,85.84 45.7,85.38 v1(45.55,85.22) ; CZ82.2 179.15,52.65 179.46,52.95 v1(179.46,52.95) ; CZ92.2 246.68,29.55 v1(246.45,29.77) ; v1(142.39,84.49) 142.12,84.22 CC1462.2 ; v1(235.4,28.12) 235.85,28.58 PD2.1 ; v1(198.16,33.73) 198.37,33.73 198.77,33.32 RD21.2 ; CD56.2 201.7,32.26 v1(201.55,32.41) 201.56,32.41 201.56,33.22 RD23.2 ; RZ1472.1 27.43,30.36 27.98,29.8 v1(27.98,29.55) ; CE11.2 270.17,73.93 v1(270.52,73.59) ; v1(122.87,63.5) 123.08,63.5 CC1457.2 ; v1(172.95,25.94) 173.04,26.03 CD57.2 172.48,26.85 CD58.2 ; CA31.2 276.38,43.05 v1(275.66,43.05) ; v1(114.01,98.38) 114.01,98.24 RC405.1 114.52,97.78 RC406.1 RC412.1 ; CZ124.2 259.58,56.97 259.17,57.37 CZ119.2 v1(257.63,57.59) ; CA5.2 58.68,107.49 v1(58.62,107.56) ; PR116.2 189.5,93.64 v1(189.11,94.04) ; CC288.2 86.56,108.22 87.59,108.22 87.84,107.97 87.84,107.19 87.72,107.07 CV54.2 v1(87.72,105.86) ; CE57.2 278.83,71.15 278.71,71.02 v1(278.71,70.89) ; v1(297.38,54.48) 296.81,54.48 296.35,54.02 CZ128.2 295.6,54.44 CZ127.2 ; v1(47.77,75.64) 47.64,75.51 47.3,75.51 47.15,75.66 PU800.4 ; v1(102.61,96.44) 102.76,96.44 103.26,95.94 RC86.2 103.28,95.75 CC305.2 ; CA7.2 54.2,109.57 v1(53.88,109.9) ; CT360.2 27.16,46.26 v1(27.37,46.48) ; v1(297.25,56.38) 297,56.38 296.88,56.5 DZ13.3 ; v1(35.06,52.84) 34.74,53.16 CT72.2 ; v1(184.38,33.47) 184.97,32.88 PR419.2 ; RT100.2 29.71,52.01 29.33,51.63 v1(29.21,51.63) ; v1(103.07,97.47) 103,97.4 CC303.2 ; RT101.2 33.89,57.99 v1(34.26,58.36) ; CZ71.2 258.45,32.85 CZ66.2 ; v1(164.7,36) 163.59,37.11 CD42.2 163.58,38.87 CD45.2 ; v1(284.74,73.16) 284.68,73.1 284.68,72.89 284.28,72.5 RE550.2 ; CR2.2 v1(294.53,70.1) ; CE30.2 272.9,97.31 v1(272.87,97.28) ; v1(122.87,60.32) 123.38,60.32 CC1455.2 ; v1(102.5,94.55) 102.39,94.55 102.01,94.93 CC304.2 ; RT129.2 RT23.2 26.42,82.74 v1(26.72,83.03) ; CC25.2 153.55,52.85 v1(153.55,52.13) ; PC814.1 44.38,91.07 44.06,91.38 v1(43.91,91.38) ; v1(59.44,97.23) 59.44,97.21 59.66,97 CC334.2 ; v1(290.51,75.84) 290.52,75.85 290.52,75.9 290.87,76.26 CI19.2 ; v1(116.45,98.71) 116.13,98.71 115.77,99.07 RC120.1 ; v1(166.91,80.32) 166.69,80.11 CC95.1 ; v1(65.44,37.98) 65.48,38.02 CD9.2 ; v1(271.66,81.25) 271.68,81.27 272.14,81.27 272.22,81.36 ; v1(126.03,38.33) 125.9,38.46 CD19.2 125.31,37.29 RD7.2 ; PQ804.4 35.33,96.04 v1(35.21,96.16) ; v1(63.32,106.33) 63.25,106.4 63.25,106.8 63.06,106.99 61.79,106.99 61.6,107.18 DV14.1 ; v1(248.23,31.43) 248.23,32.12 247.55,32.8 CZ91.2 ; v1(146.94,80.32) 146.94,79.93 CC98.2 ; RT38.2 30.82,73.9 v1(30.34,73.9) 30.24,73.9 29.53,74.61 RT34.2 ; QV7.3 81.5,107.29 80.71,108.07 v1(80.71,108.42) ; v1(269.06,82.04) 269.06,81.96 269.04,81.94 269.04,81.51 269.06,81.5 269.06,81.4 269.4,81.06 CE14.2 269.4,80.64 269.75,80.28 CE13.2 ; CD13.2 88.92,32.96 v1(88.28,33.6) ; PQ808.4 36.8,102.06 36.12,101.39 v1(36.12,100.77) ; v1(293.7,82.28) DI4.3 296.31,82.28 296.55,82.04 v1(297.16,82.04) ; v1(85.9,36.41) 85.12,37.19 CD11.2 85.13,38.16 CD10.2 ; CC430.2 140.04,64.22 v1(140.19,64.37) ; UZ27.5 146.83,49.26 v1(147.4,48.69) ; CC24.2 151.29,53.28 151.07,53.07 v1(151.07,53.07) ; v1(33.91,61.69) 33.75,61.53 RT71.1 ; v1(194.32,112.28) 194.63,111.96 PC312.1 ; v1(122.31,33.84) 122.54,33.61 CD23.2 CD70.2 125.1,33.61 CD22.2 ; PQ809.4 43.3,106.47 43.5,106.67 44.33,106.67 44.6,106.94 PQ809.1 44.6,108.24 v1(44.01,108.83) ; v1(300.5,57.21) 300.45,57.21 300.11,57.55 CR17.1 ; v1(146.94,82.82) 146.96,82.84 CC66.2 ; PQ10.1 53.57,88.89 54.87,90.19 PQ10.4 55.32,90.43 v1(55.54,90.66) ; CT22.2 30.64,60.52 v1(30.64,59.95) ; v1(124.42,29.83) 124.42,30.6 CD69.2 CD24.2 ; PR706.2 39.02,54.13 38.74,53.84 38.74,53.54 PR709.1 38.51,53.46 v1(38.07,53.91) ; PQ6.3 62.99,90.56 v1(63.38,90.95) ; PC428.2 190.4,30 v1(190.63,29.76) ; CE60.2 274.14,68.62 v1(274.26,68.75) CE59.2 ; v1(113.75,96.27) 114.52,96.27 RC109.2 ; RT65.2 RT64.2 33,59.31 v1(32.74,59.31) ; v1(41.28,42.73) 41.28,42.71 41.05,42.48 PD901.1 ; CZ303.1 146.56,50.26 v1(146.91,49.92) ; RV319.1 89.76,109.79 v1(89.49,110.06) ; UZ35.3 151.91,110.48 v1(151.63,110.75) ; v1(116.53,97.59) 116.82,97.3 RC407.1 RC414.1 ; v1(93.2,33.3) 93.77,32.73 93.77,31.79 CD16.2 ; RD25.2 182.81,34.08 v1(182.52,33.79) ; v1(42.68,92.45) 42.96,92.45 43.2,92.69 PR855.2 ; v1(269.65,54.63) 269.65,53.77 269.52,53.65 QZ17.3 ; RZ1460.1 305.48,105.43 305.95,104.96 v1(306.08,104.96) ; CA49.2 CA77.2 286.42,36.16 v1(286.71,35.87) ; PC865.2 49.96,103.05 v1(49.18,103.83) ; CC68.2 CC67.2 145.23,80.05 145.64,79.64 v1(145.64,79.48) ; RC122.2 68.48,96.64 v1(68.48,97.23) ; v1(45.68,83.13) 44.78,83.13 44.42,83.5 PQ813.4 44.42,84.29 43.96,84.75 PC813.2 ; v1(46.15,93.76) 46.15,93.42 PU801.3 ; v1(219.4,28.82) 219.2,28.62 PC207.2 218.5,28.62 218.36,28.76 218.14,28.76 PR206.2 217.87,29.23 218.07,29.42 v1(218.07,29.71) 218.07,30.07 PC206.2 PC226.2 ; CD44.2 169.17,32.59 v1(169.06,32.7) ; v1(265.3,72.06) 265.96,72.06 CE10.2 ; CC299.2 61.26,96.93 60.98,97.22 v1(60.78,97.22) ; PC754.1 44.77,63.38 45.22,62.93 v1(45.35,62.93) ; v1(275.66,47.96) 275.69,47.96 CA48.2 276.36,47.3 276.36,46.98 276.89,46.45 CA47.2 ; v1(62.39,92.51) 62.03,92.16 RC236.2 ; v1(24.01,44.44) 23.94,44.37 UT34.3 ; CV40.2 15.03,69.31 v1(14.38,69.96) ; RC337.2 152.47,96.23 152.47,96.34 v1(152.09,96.71) ; RD5.2 v1(122.88,36.93) ; v1(51.66,79.21) 50.81,79.21 49.76,80.26 PR842.2 PC811.2 ; CT38.2 27.79,77.18 v1(27.75,77.14) 27.75,76.62 CT33.2 ; v1(32.52,78.51) 32.39,78.65 RT35.1 RT29.2 ; DD1.1 v1(142.95,24.89) ; CC28.2 139.52,95.23 139.24,95.5 v1(138.95,95.5) ; CD14.2 75.92,37.56 v1(74.94,36.58) ; PC427.2 188.84,29.83 v1(188.25,29.83) 187.85,29.83 PR424.2 187.6,30.16 187.6,30.16 187.6,30.73 187.6,30.73 PR428.2 ; CT28.2 29.01,75.88 v1(29.05,75.84) ; CE21.2 284.89,79.7 v1(285.3,79.7) ; UZ10.3 v1(307.22,70.86) ; v1(71.33,101.89) 71.33,100.87 CV634.2 ; RC165.2 95.76,77.84 95.49,78.11 v1(95.49,79.48) ; v1(112.99,94.63) 113.14,94.78 113.14,95.52 112.87,95.79 RC108.2 ; CC1464.2 159.99,78.69 v1(159.99,77.46) ; CC195.2 117.21,64.25 v1(117.74,64.25) ; CZ54.2 178.17,78.66 v1(178.14,78.69) ; v1(148.1,111.96) 148.8,111.96 CZ100.2 ; v1(292.61,54.54) 292.71,54.54 CZ125.2 ; v1(144.1,86.77) 143.94,86.77 143.64,86.47 CC31.2 ; v1(262.77,89.34) 263.05,89.34 263.13,89.26 RE93.2 ; CZ75.2 179.45,85.3 CZ50.2 ; CC77.2 169.4,78.12 v1(169.49,78.04) ; RT81.2 RT82.2 30.41,52.14 v1(30.36,52.19) ; 293.78,24.94 CZ120.2 ; v1(39.26,83.74) 39.5,84 PC801.1 ; PC1169.2 PC1168.2 v1(91.19,88.03) ; v1(38.87,104.26) 38.42,104.26 38.28,104.12 PQ808.1 ; v1(133.35,96.36) 133.74,95.97 RC164.2 ; v1(283.68,93.44) 282.93,93.44 282.56,93.06 CE25.2 ; v1(36.88,96.11) 36.63,96.36 PQ804.1 ; v1(92.37,32.95) 91.94,32.52 CD4.2 ; PC1096.2 v1(131.9,97.21) ; UZ6.3 176.87,56 176.72,56 v1(176.49,55.77) ; PC1167.2 136.94,86.54 v1(136.71,86.77) ; RC48.2 155.03,54.95 CC93.1 154.35,54.95 154.1,55.2 v1(154.06,55.2) ; CT70.2 v1(29.66,46.09) ; RE56.2 278.62,74.22 v1(278.45,74.05) ; CD18.2 v1(123.78,37.65) ; v1(114.19,85.64) 113.85,85.99 PC1141.2 ; v1(27.1,77.79) 27.08,77.77 CT27.2 27.08,76.66 CT34.2 ; DI1.3 v1(21.34,41.26)
  TOP w0.406: DV13.1 57.63,107.53 v1(56.99,107.53)
  TOP w0.457: v1(51.06,49.21) 51.09,49.17 PC755.2 ; PC629.1 75.37,57.19 v1(74.82,57.19) 74.4,57.19 PC636.1 ; PQ12.3 56.84,95.65 v1(56.89,95.7) ; v1(233.67,28.04) 233.69,28.06 PD1.1 ; v1(224.29,36.9) 224.29,36.57 223.65,35.93 v3(223.65,35.26) PC209.2 ; v1(141.05,97.51) 140.72,97.51 140.33,97.12 CC96.2 ; v1(274.82,73.93) 274.79,73.96 CE54.2 ; RA51.2 284.74,57.84 v1(284.81,57.91)
  TOP w0.508: v1(168.89,58.39) 169.27,58.77 RC53.2 ; v1(155.44,53.02) 155.33,52.91 CMOS1.2 ; CD6.2 97.34,41.89 v1(97.67,42.22) ; v1(166.57,25.65) 166.69,25.65 168.41,27.36 RD31.2 ; CR18.2 298.55,57.31 297.76,58.1 v1(297.5,58.1) ; v1(150.67,57.4) 151.05,57.4 151.44,57 CC23.2 ; v1(150.67,57.4) 150.67,56.89 151.17,56.38 156.19,56.38 156.38,56.57 156.38,58.99 155.19,60.17 v1(154.77,60.17) ; v1(150.67,57.4) 150.16,57.91 148.77,57.91 147.87,58.81 144.77,58.81 144.41,59.16 ; CC85.2 146.69,100.9 146.32,100.52 v1(145.97,100.52) ; RC116.2 159.8,65.18 v1(159.09,65.89) ; CE3.2 277.69,68.63 v1(277.69,67.24) 277.66,67.21 QE17.3 ; v1(295.47,24.31) 295.47,24.64 295.17,24.94 CZ121.2 293.78,24.94 ; PC12.2 65.67,95.33 v1(65.22,95.78) ; CV755.2 CV756.2 78.62,100.18 79.13,100.69 v1(79.13,101.26) ; 144.41,59.16 v1(144.43,59.18) ; 144.41,59.16 143.92,59.16 143.7,59.38 143.7,60.73 144.06,61.09 v1(144.43,61.09) 148.3,61.09 149.24,60.14 151.53,60.14 152.47,61.09 154.42,61.09 154.76,60.75 154.76,60.18 v1(154.77,60.17) ; CD38.2 159.16,30.28 v1(158.73,29.86) ; v1(55.85,56.28) 56.02,56.11 PC605.1 57.04,57.06 PC602.2 ; v1(48.56,73.67) 48.48,73.59 47.9,73.59 PC804.2 PR817.2 ; v1(303.22,108.22) 303.55,107.89 CZ228.2 ; CI43.2 294.93,80.12 v1(294.1,80.12) ; RC751.1 CC1477.2 154.32,94.98 155.14,94.16 v1(155.14,93.38) ; QV21.3 90.87,101.61 v1(90.87,102.52) 90.87,102.94 90.13,103.68 RV629.2 CV651.2 ; v1(46.53,47.74) 46.53,48.2 PC749.2 ; SW3.1 v1(309.66,104.4) ; v1(174.85,85.02) 175.19,84.69 RC832.2 ; v1(141.2,72.58) 140.39,72.58 140.17,72.8 140.17,72.87 RC7.2 ; CC34.2 128.74,62.78 v1(129.1,62.78) ; RA35.2 v1(295.21,45.2) ; v1(314.78,53.4) 314.96,53.22 JSD1.23 ; CZ21.2 v1(283.91,65.48) 283.43,65.48 282.92,64.97 CZ23.2 ; CC27.2 148.66,50.31 v1(148.65,50.3) ; CA12.2 306.54,48.03 v1(306.54,48.72) ; PC313.2 v1(193.93,111.62) ; UC5.9 195.05,61.88 v1(196.28,60.64) ; v1(154.77,60.17) 153.95,60.17 153.79,60.33 CC26.2 ; RC536.2 152.24,49.97 v1(152.34,49.86) ; v1(176.47,68.54) 176.47,68.53 RC640.1 ; v1(89.67,68.83) 89.67,68.45 PC1102.2 ; v1(92.1,86.58) 92.09,86.57 PC1157.2 ; v1(126.86,24.67) 126.86,24.67 126.51,24.32 PR514.2 126.24,24.35 PC513.2 ; CI31.2 290.92,78.99 v1(290.63,79.28) 290.02,79.28 CI33.2 ; CC280.2 CC279.2 166.46,66.02 v1(166.84,66.39) ; CZ126.2 294.37,54.57 v1(294.52,54.41) ; RC833.2 177.62,62 v1(177.87,62.25) ; v1(118.41,74.49) 118.7,74.77 CC1479.2 ; PC414.2 178.23,28.37 PC416.2 176.85,28.85 v1(176.85,29.71) ; JSD1.14 v1(314.81,61.74) ; v1(74.47,106.97) 74.47,106.67 75.17,105.97 CV635.2 ; PC604.2 56.94,63.1 56.43,63.61 v1(56.43,63.63) ; v1(268.04,84.14) 267.35,83.46 CE67.2 ; PC1107.2 v1(93.73,83.37) ; CZ109.2 256.88,56.69 v1(256.67,56.89) ; CE29.2 269.56,79.11 v1(269.2,79.47) ; v1(87.27,98.98) 86.45,99.8 QV19.3 ; v1(157.38,54.27) 157.85,54.75 RC761.2 CC1471.2 ; PC1110.2 114.63,85.64 v1(114.19,85.64) ; v1(252.42,30.09) 252.69,29.83 CZ89.2 253.05,28.96 CZ81.2 ; UZ54.3 32.12,35.62 v1(32.12,36.19) ; v1(196.66,37.88) 196.57,37.97 196.48,37.97 CD35.2 ; v1(171.42,90.28) 171.47,90.23 RC757.2 RC760.2 ; PR739.2 46.84,68.93 v1(47.25,69.34) ; v1(72.31,64.83) 72.31,65.36 72.44,65.48 PC643.2 PR651.2 ; v1(168.69,54.98) 168.69,54.99 168.69,55.5 RC230.2 CC1465.2 ; CZ102.2 143.29,46.45 v1(142.74,45.9) ; v1(20.01,62.6) 17.81,62.6 QV4.3 ; v1(290.69,75.1) 289.91,75.1 CI34.2 ; PR45.2 PC13.1 56.09,94.71 56.28,94.9 PQ12.3 58.83,92.9 PC7.2 ; PR407.2 174.61,23.77 PC411.2 v1(173.99,23.77) ; CA13.1 301.61,47.38 v1(301.28,47.71) ; v1(48.57,72.47) 47.97,72.47 47.62,72.12 46.5,72.12 45.8,72.82 PR815.2 45.77,73.69 PC800.2 ; v1(138.36,63.77) 138.55,63.77 138.99,63.33 CC38.2 ; v1(99.61,26.48) 100.24,26.48 100.75,26.98 RD16.2 ; v1(201.47,36.13) 201.81,36.13 202.38,36.7 CD52.2 ; PC745.2 52.76,52.34 v1(53.04,52.07) 53.04,51.85 52.62,51.43 PC748.2 ; RC759.2 RC758.2 171.51,93.59 v1(171.27,93.35) ; CZ63.2 270.34,28.69 v1(270.86,28.69) ; v1(50.24,107.7) 49.37,107.7 RV2.2 ; RA37.2 296.25,32.37 v1(296.55,32.06) ; CC37.2 CC1454.2 120.28,64.84 v1(119.7,65.42) ; v1(269.88,35.82) 269.86,35.79 RZ752.2 ; 75.72,62.17 75.31,62.58 PC651.1 75.03,62.57 PC654.1 ; 75.72,62.17 75.98,62.44 PR653.1 ; 75.72,62.17 v1(75.72,61.72) ; CE62.2 274.83,73.92 v1(274.82,73.93) ; v1(163.77,85.59) 163.85,85.51 CC71.2 ; PR716.2 55.43,57.74 v1(55.81,58.12) ; CE8.2 286.01,87.6 v1(286.04,87.62) ; PC738.2 52.74,59.19 v1(52.83,59.28) ; PC124.2 v1(38.96,23.35) ; CD63.2 v1(126.09,30.02) ; PC810.2 v1(33.07,100.6) ; RE313.2 289.54,81.85 CE4.2 289.54,80.93 289.24,80.63 v1(289.24,80.38) ; CD36.2 193,29.95 v1(192.87,29.82) ; RE86.2 293.82,94.42 294.2,94.8 v1(294.2,95.5) ; v1(85.9,33.36) 86.27,33.36 86.75,32.89 ; v1(148.36,98.7) 148.91,98.15 CC104.2 ; PR207.2 216.86,25.7 v1(216.86,24.84) ; RR4.2 288.03,62.35 v1(287.39,62.99) ; v1(284.3,50.1) 283.9,50.49 RA36.2 ; v1(73.35,67.13) 73.07,67.42 PC631.2 ; RE810.1 v1(288.13,96.96) ; PR415.2 88.89,24.49 89.01,24.61 v1(89.29,24.61) 89.57,24.61 89.68,24.49 PR416.2 ; RC452.1 v1(153,49.86) ; v1(63.32,106.33) 63.91,106.92 CV11.2 63.91,107.96 63.51,108.36 CV753.2 CV25.2 ; PC644.2 63.88,68.62 63.88,68.38 63.63,68.13 v1(63.63,67.94) ; v1(92.37,37.52) 94.15,37.52 CD5.2 ; PC1088.2 v1(125.23,107.4) ; v1(292.29,57.51) CZ40.2 ; CD61.2 142.15,32.77 v1(142.73,33.35) ; v1(272.42,97.91) 272.71,98.2 RE65.2 ; v1(271.11,31.52) 270.97,31.66 RZ10.1 ; PR310.2 v1(196.93,105.2) ; CZ197.2 v1(295.18,18.19) ; PC3.2 239.06,30.3 237.28,30.3 236.86,30.72 236.86,32.57 v1(236.67,32.76) ; PQ814.3 40.62,95.66 v1(40.19,96.09) ; v1(65.28,68.26) 64.74,67.72 PC652.2 64.76,67.5 PC649.2 ; CD53.2 203,38.12 v1(203.52,38.12) ; JSD1.20 315.55,55.95 315.16,55.56 314.33,55.56 313.82,55.05 v1(313.82,53.71) ; v1(86.81,25.2) 86.85,25.16 PR427.2 ; v1(283.79,95.52) 283.72,95.46 CE47.2 ; PR403.2 PC402.2 81.73,32.06 81.8,32.13 81.8,33.54 81.29,34.04 v1(81.21,34.04) ; RC234.2 v1(164.94,55.02) ; RV21.2 17.93,67.86 v1(18.1,67.68) ; v1(88.28,36.65) 87.89,36.65 87.13,37.41 CD2.2 ; v1(267.76,30.66) 267.76,30.57 CZ69.2 ; PC628.2 69.33,66.58 PC601.2 v1(70.04,67.47) ; v1(159.9,82.56) 160.93,82.56 161.18,82.81 RC10.2 ; CC32.2 119.53,58.61 v1(119.37,58.77) ; RZ38.1 266.05,46.52 v1(266.74,46.52) ; JSD1.6 v1(301.79,56.53) ; CC340.2 175.04,63.23 175.04,62.74 v1(174.92,62.62) 174.44,62.14 QC6.3 ; v1(58.63,65.83) 59.18,65.28 PR611.2 PR608.2 ; v1(61.62,52.24) PR631.1 61.58,52.89 PC613.1 ; v1(95.77,36.2) 96.22,36.2 96.82,36.8 CD7.2 ; RC232.2 v1(161.38,55.02) ; v1(91.29,88.64) 91.57,88.92 PC622.2 ; v1(175.65,86.35) 175.14,86.86 RC63.2 ; JTAG1.2 v1(273.08,95.43) ; PR693.1 60.65,53.03 v1(60.72,53.09) 60.73,53.11 PR613.1 ; RE811.1 287.97,94.11 287.98,94.1 v1(288.04,94.1) ; PR658.1 68.83,51.68 v1(68.43,52.08) 68.72,52.36 PC619.1 ; CZ229.2 v1(302.43,96.64) ; v1(44.79,97.62) 45.1,97.3 PD4.1 ; v1(132.07,63.18) 132.29,63.4 CC33.2 ; PC1122.2 100.78,75.18 v1(101.51,75.91) ; v1(44.5,47.7) 44.7,47.91 PR725.2 ; v1(264.36,93.02) 265.12,92.26 RE812.1 ; CZ306.2 22.37,33.2 ; PC737.1 40.14,57.63 39.55,57.03 v1(39.09,57.03) ; CC1469.2 162.27,55.04 162.28,55.03 v1(162.28,55.02) ; CZ230.2 304.89,99.49 v1(305.47,98.91) ; PC126.2 42.65,32.09 v1(42.26,32.48) ; CC86.2 143.53,94.7 v1(143.85,94.38) ; PC1105.2 87.98,73.88 v1(87.97,73.87) ; CZ218.2 v1(298.38,5.51) ; v1(273.6,73.98) RE20.2 ; PC1015.2 v1(128.78,100.96) ; v1(188.28,68.01) 188.75,67.54 188.75,66.02 CC1453.2 ; v1(126.1,33.98) 125.75,33.98 125.6,33.83 CD22.2 ; v1(75.79,55.53) 75.52,55.26 PR647.1 75.01,55.29 PC625.1 PR629.1 ; v1(270.77,70.47) 270.77,71.14 270.63,71.28 RE95.1 ; CE40.2 278.72,94.91 v1(278.45,95.18) ; v1(262.36,88.79) 262.36,88.79 262.87,88.29 QE12.3 ; v1(248.3,41.67) 248.3,43.33 CZ154.2 248.06,44.12 CZ155.2 ; CA6.2 55.68,107.02 56.05,107.39 v1(56.05,107.55) ; CZ227.2 305.42,108.01 v1(304.89,108.53) ; v1(74.17,75.62) 74.16,75.61 PC675.2 ; CZ83.2 249.33,32.08 248.93,31.68 v1(248.93,31.49) ; PR311.2 v1(196.3,107.59) ; CE16.2 274.71,71.49 v1(274.28,71.49) 273.9,71.11 RE802.2 ; CE12.2 267.54,73.42 v1(267.55,73.41) ; v1(152.79,100.13) 152.16,99.51 RC47.2 ; v1(300.56,61.63) 299.87,61.63 299.85,61.64 CZ41.2 299.4,61.63 CZ37.2 ; PC684.2 v1(75.3,83.13) ; v1(137.06,60.88) 136.56,61.37 CC35.2 ; PC641.2 72.91,50.51 v1(72.58,50.18) ; RC233.2 v1(163.16,55.02) ; CA54.2 276.75,38.44 276.43,38.11 v1(275.89,38.11) ; v1(179.4,86.18) 179.4,85.84 CZ75.2 ; PC753.2 54.11,48.7 54.17,48.63 v1(54.17,48.27) ; QR1.3 285.93,51.82 v1(286.39,51.37) ; v1(201.67,26.57) 201.67,26.63 201.77,26.73 CD66.2 ; v1(240.26,36.56) 240.26,37.11 239.94,37.43 PR9.2 238.53,37.43 PQ13.3 ; v1(152.09,96.71) 151.58,96.2 RC49.2 ; v1(72.65,86.8) 72.66,86.8 PC658.2 ; v1(168.77,69.42) 169.31,69.96 RC448.1 ; v1(272.23,92.65) RE77.2 CE38.2 ; RE85.2 277.08,91.83 v1(276.96,91.95) ; RE58.2 RE55.2 271.05,74.1 v1(271.02,74.07) ; v1(199.26,64.08) 198.96,63.78 UC5.4 ; CC316.2 v1(160.37,60.94) ; v1(79.76,101.28) 79.76,99.63 78.79,98.65 PR24.2 78.79,97.66 79.37,97.08 PQ7.3 ; v1(268.55,75.64) 269.02,75.64 CE28.2 ; PC618.1 66.36,49.87 v1(65.15,51.07) PC621.1 ; PR212.2 227.41,26.16 PC222.2 227.41,27.42 v1(227.42,27.43) ; RV626.2 70.83,102.39 v1(71.33,101.89) 71.72,102.28 CV633.2 ; PC1082.2 v1(125.18,109.71) ; v1(165.8,55.02) 165.8,55.45 CC266.2 RC220.2 ; v1(66.49,107.55) 66.49,107.33 66.92,106.9 RV1.2 ; v1(292.61,54.54) 292.61,55.19 CZ39.2 ; RD18.2 v1(103.28,26.49) ; v1(141.09,83.68) 140.86,83.92 PC1159.2 ; PQ812.3 57.08,106.02 57.79,106.73 DV13.1 ; v1(92.1,85.25) 92.09,85.26 PC1156.2 ; CC102.2 147.52,100.26 147.87,100.61 v1(148.36,100.61) ; v1(83.26,32.88) 83.51,32.63 CD29.2 ; CD59.2 198.87,37.28 198.36,36.78 v1(198.16,36.78) ; v1(42.39,88.91) 42.53,88.77 PR823.2 42.8,88.21 43.26,88.67 43.4,88.67 43.41,88.68 PC808.2 43.44,88.67 PC809.2 ; v1(137.06,64.63) 136.56,64.63 CC36.2 ; v1(145.86,63.52) 145.27,63.52 RC75.2 ; CE68.2 285.06,73.48 v1(284.74,73.16) ; CA72.2 RA51.2 ; v1(63.97,52.18) 64.24,52.44 PC614.1 64.17,52.94 PC616.1 ; v1(176.03,89.26) 175.95,89.34 CC78.2 ; CC1478.2 134.79,60.21 v1(135.39,60.21) ; PR723.2 42.1,48.3 PC744.2 42.11,47.9 v1(41.92,47.71) ; v1(48.33,47.77) 48.03,48.07 PC750.2 ; RZ40.1 258.65,50.89 v1(258.26,51.27) ; PC1084.2 v1(128.78,109.71) ; CC1467.2 v1(160.49,55.02) ; CZ71.2 258.06,33.57 v1(257.83,33.57) ; PC645.2 v1(76.96,64.18) ; RV624.2 CV632.2 89.01,103.23 89.55,102.69 v1(89.55,102.52) ; CC1470.2 v1(164.05,55.02) ; RA52.1 275.72,41.26 v1(275.19,41.26) 274.81,41.26 274.25,41.82 CA61.2 ; PR516.2 119.18,24.19 119.66,24.66 v1(119.89,24.66) 120.24,24.66 120.31,24.6 PU503.4 ; CD33.2 153.25,40.17 v1(152.89,40.54) ; RD29.2 CD58.2 ; v1(182.19,54.45) 182.19,54.48 182.25,54.54 RC454.1 ; 82.81,112.52 v1(82.81,111.82) ; PC128.2 186.44,92.89 v1(185.87,92.89) ; PC1104.2 91.46,68.73 v1(90.88,69.31) ; PC1014.2 v1(125.67,100.96) ; v1(251.78,30.09) 251.35,29.66 CZ88.2 CZ80.2 ; SW3.2 v1(311.46,104.4) ; v1(170.4,54.98) RC229.2 ; v1(92.46,41.14) 92.97,41.65 CD1.2 ; v1(158.87,33.28) 158.7,33.45 CD37.2 ; RC752.1 176.29,64.24 v1(175.71,64.83) ; CZ220.2 v1(50.51,105.17) ; v1(201.03,26.74) 200.5,27.28 CD54.2 ; PC685.2 v1(90.62,91.89) ; PC603.2 v1(57.63,61.97) ; PC1086.2 v1(128.82,107.4) ; PC647.2 v1(75.93,59.09) ; PC1018.2 v1(122.56,100.96) ; RC397.2 v1(168.19,82.73)
  GND1 w0.203: 304.23,102.45 H29.1 ; H29.1 305.65,104.25 ; H29.1 305.65,102.45 ; H29.1 304.23,104.25 ; H29.1 304.23,100.65 ; H29.1 304.94,104.25 ; H29.1 305.65,100.65 ; H29.1 304.94,100.65 ; 264.73,109.85 H15.1 ; H15.1 265.98,112.8 ; H15.1 264.73,113.25 ; H15.1 265.98,110.3 ; H15.1 263.48,112.8 ; H15.1 263.48,110.3 ; H15.1 266.43,111.55 ; H15.1 263.03,111.55 ; 274.96,103.82 H21.1 ; H21.1 274.43,102.35 ; H21.1 276.44,100.34 ; H21.1 277.91,100.88 ; H21.1 277.91,103.82 ; H21.1 274.96,100.88 ; H21.1 276.44,104.36 ; H21.1 278.44,102.35 ; JUSB1.13 310.06,91.73 ; JUSB1.13 311.21,91.73 ; JUSB1.13 308.9,91.73 ; JUSB1.13 308.9,90.93 ; JUSB1.13 311.21,90.93 ; JUSBC1.2 6.85,90.92 ; JUSBC1.2 5.54,90.92 ; JUSBC1.2 6.85,89.42 ; JUSBC1.2 8.16,90.17 ; JUSBC1.2 5.54,90.17 ; JUSBC1.2 8.16,90.92 ; 99.43,66.99 H3.1 ; H3.1 101.69,69.25 ; H3.1 97.17,69.25 ; H3.1 97.78,67.6 ; H3.1 101.08,67.6 ; H3.1 101.08,70.9 ; H3.1 99.43,71.51 ; H3.1 97.78,70.9 ; JUSB1.4 301.91,86.73 ; JUSB1.4 300.49,87.35 ; JUSB1.4 300.49,86.11 ; JUSB1.4 300.3,86.73 ; JUSB1.4 301.72,86.11 ; JUSB1.4 301.11,87.53 ; JUSB1.4 301.11,85.93 ; JUSB1.4 301.72,87.35 ; JUSB1.10 302.11,76.03 ; JUSB1.10 299.5,76.83 ; JUSB1.10 299.5,77.63 ; JUSB1.10 302.11,76.83 ; JUSB1.10 302.11,77.63 ; JUSB1.10 300.81,77.63 ; JUSB1.10 299.5,76.03 ; JUSB1.10 300.81,76.03 ; 302.29,65.23 JSD1.11 ; JSD1.11 302.29,64.54 ; JSD1.11 303.4,65.93 ; JSD1.11 304.51,64.54 ; JSD1.11 304.51,65.93 ; JSD1.11 304.51,65.23 ; JSD1.11 302.29,65.93 ; JSD1.11 303.4,64.54 ; 5.54,81.53 JUSBC1.4 ; JUSBC1.4 6.85,80.78 ; JUSBC1.4 5.54,80.78 ; JUSBC1.4 8.16,81.53 ; JUSBC1.4 8.16,80.78 ; 3.18,76.6 H12.1 ; H12.1 5.68,76.6 ; H12.1 6.13,77.85 ; H12.1 5.68,79.1 ; H12.1 4.43,79.55 ; H12.1 2.73,77.85 ; H12.1 3.18,79.1 ; H12.1 4.43,76.15 ; JHDMI1.22 13.06,58.35 ; JHDMI1.22 10.54,58.35 ; JHDMI1.22 13.06,56.65 ; JHDMI1.22 11.8,58.35 ; JHDMI1.22 13.06,57.5 ; JHDMI1.22 10.54,56.65 ; JHDMI1.22 11.8,56.65 ; JUSBC1.1 1.8,90.97 ; JUSBC1.1 0.35,89.37 ; JUSBC1.1 3.25,90.97 ; JUSBC1.1 3.25,89.37 ; JUSBC1.1 3.25,90.17 ; JUSBC1.1 1.8,89.37 ; JUSBC1.1 0.35,90.97 ; JUSBC1.1 0.35,90.17 ; H8.1 160.48,26.9 ; H8.1 156.98,26.9 ; H8.1 156.33,25.15 ; H8.1 158.73,27.55 ; H8.1 158.73,22.75 ; H8.1 161.13,25.15 ; H8.1 160.48,23.4 ; H8.1 156.98,23.4 ; JHDMI1.11 12.16,65.25 ; JHDMI1.11 12.05,65.7 ; JHDMI1.11 12.05,64.8 ; JHDMI1.11 11.04,65.25 ; JHDMI1.11 11.15,65.7 ; JHDMI1.11 11.15,64.8 ; 16.66,34.55 JUSB2.12 ; JUSB2.12 15.35,34.55 ; JUSB2.12 16.66,36.15 ; JUSB2.12 17.96,36.15 ; JUSB2.12 15.35,35.35 ; JUSB2.12 17.96,34.55 ; JUSB2.12 15.35,36.15 ; JUSB2.12 17.96,35.35 ; H11.1 6.98,95.55 ; H11.1 4.03,94.3 ; H11.1 5.73,92.6 ; H11.1 4.48,93.05 ; H11.1 7.43,94.3 ; H11.1 4.48,95.55 ; H11.1 5.73,96 ; H11.1 6.98,93.05 ; H2.1 165.48,67.6 ; H2.1 161.57,69.25 ; H2.1 162.18,67.6 ; H2.1 162.18,70.9 ; H2.1 163.83,71.51 ; H2.1 165.48,70.9 ; H2.1 166.09,69.25 ; H2.1 163.83,66.99 ; 315.09,65.93 JSD1.12 ; JSD1.12 316.2,64.54 ; JSD1.12 316.2,65.93 ; JSD1.12 315.09,65.23 ; 14.85,40.95 JUSB2.7 ; JUSB2.7 14.24,41.13 ; JUSB2.7 15.47,41.13 ; JUSB2.7 14.24,42.37 ; JUSB2.7 14.85,42.55 ; JUSB2.7 15.66,41.75 ; JUSB2.7 15.47,42.37 ; 310.72,23.65 H18.1 ; H18.1 312.68,21.69 ; H18.1 314.11,22.22 ; H18.1 314.64,23.65 ; H18.1 311.25,22.22 ; H18.1 312.68,25.61 ; H18.1 314.11,25.08 ; H18.1 311.25,25.08 ; 162.18,92.1 H1.1 ; H1.1 165.48,88.8 ; H1.1 165.48,92.1 ; H1.1 163.83,92.71 ; H1.1 162.18,88.8 ; H1.1 161.57,90.45 ; H1.1 163.83,88.19 ; H1.1 166.09,90.45 ; 311.43,27.7 H28.1 ; H28.1 313.93,27.7 ; H28.1 312.68,30.65 ; H28.1 314.38,28.95 ; H28.1 310.98,28.95 ; H28.1 311.43,30.2 ; H28.1 312.68,27.25 ; H28.1 313.93,30.2 ; JUSBC1.6 6.95,80.78 ; JUSBC1.6 5.55,80.78 ; JUSBC1.6 5.55,82.73 ; JUSBC1.6 6.25,80.78 ; JUSBC1.6 5.55,81.85 ; JHDMI1.8 13.6,63.3 ; JHDMI1.8 13.6,64.2 ; JHDMI1.8 13.71,63.75 ; JHDMI1.8 12.7,63.3 ; JHDMI1.8 12.7,64.2 ; JHDMI1.8 12.59,63.75 ; 7.63,92.65 H30.1 ; H30.1 7.63,94.3 ; H30.1 9.15,94.3 ; H30.1 8.39,92.65 ; H30.1 7.63,95.95 ; H30.1 9.15,95.95 ; H30.1 8.39,95.95 ; H30.1 9.15,92.65 ; JSD1.10 303.4,52.33 ; JSD1.10 302.29,50.94 ; JSD1.10 302.29,52.33 ; JSD1.10 304.51,50.94 ; JSD1.10 303.4,50.94 ; JSD1.10 304.51,51.63 ; JSD1.10 304.51,52.33 ; JSD1.10 302.29,51.63 ; JSD1.13 314.11,51.63 ; JSD1.13 311.89,50.94 ; JSD1.13 313,52.33 ; JSD1.13 311.89,51.63 ; JSD1.13 314.11,52.33 ; JSD1.13 314.11,50.94 ; JSD1.13 313,50.94 ; JSD1.13 311.89,52.33 ; H17.1 313.5,72.55 ; H17.1 315.2,70.85 ; H17.1 312.25,72.1 ; H17.1 311.8,70.85 ; H17.1 313.5,69.15 ; H17.1 314.75,72.1 ; H17.1 314.75,69.6 ; H17.1 312.25,69.6 ; JUSB2.10 16.66,48.95 ; JUSB2.10 15.35,48.95 ; JUSB2.10 17.96,47.35 ; JUSB2.10 15.35,48.15 ; JUSB2.10 17.96,48.95 ; JUSB2.10 15.35,47.35 ; JUSB2.10 17.96,48.15 ; JUSB2.10 16.66,47.35 ; 10.54,71.15 JHDMI1.20 ; JHDMI1.20 13.06,72 ; JHDMI1.20 13.06,72.85 ; JHDMI1.20 13.06,71.15 ; JHDMI1.20 10.54,72.85 ; JHDMI1.20 11.8,72.85 ; JHDMI1.20 11.8,71.15 ; 49.23,110.39 H14.1 ; H14.1 50.39,110.79 ; H14.1 50.39,113.11 ; H14.1 48.07,110.79 ; H14.1 47.67,111.95 ; H14.1 49.23,113.51 ; H14.1 48.07,113.11 ; H14.1 50.79,111.95 ; 12.59,60.75 JHDMI1.2 ; JHDMI1.2 13.71,60.75 ; JHDMI1.2 13.6,61.2 ; JHDMI1.2 12.7,61.2 ; JHDMI1.2 13.6,60.3 ; JHDMI1.2 12.7,60.3 ; 3.35,25.08 H13.1 ; H13.1 4.78,21.69 ; H13.1 6.74,23.65 ; H13.1 3.35,22.22 ; H13.1 4.78,25.61 ; H13.1 2.82,23.65 ; H13.1 6.21,25.08 ; H13.1 6.21,22.22 ; 300.81,88.83 JUSB1.12 ; JUSB1.12 302.11,88.83 ; JUSB1.12 302.11,89.63 ; JUSB1.12 300.81,90.43 ; JUSB1.12 299.5,90.43 ; JUSB1.12 299.5,89.63 ; JUSB1.12 299.5,88.83 ; JUSB1.12 302.11,90.43 ; JUSB2.4 16.97,38.87 ; JUSB2.4 16.36,37.45 ; JUSB2.4 17.16,38.25 ; JUSB2.4 15.74,38.87 ; JUSB2.4 16.97,37.63 ; JUSB2.4 15.55,38.25 ; JUSB2.4 16.36,39.05 ; JUSB2.4 15.74,37.63 ; H27.1 4.78,30.65 ; H27.1 2.57,27.25 ; H27.1 2.57,30.65 ; H27.1 6.99,27.25 ; H27.1 2.57,28.95 ; H27.1 6.99,30.65 ; H27.1 4.78,27.25 ; H27.1 6.99,28.95 ; 6.25,34.05 JUSB2.13 ; JUSB2.13 7.41,33.25 ; JUSB2.13 8.56,34.05 ; JUSB2.13 8.56,33.25 ; JUSB2.13 6.25,33.25 ; 156.33,101.57 H5.1 ; H5.1 158.73,99.17 ; H5.1 160.48,103.32 ; H5.1 158.73,103.97 ; H5.1 161.13,101.57 ; H5.1 156.98,99.82 ; H5.1 160.48,99.82 ; H5.1 156.98,103.32 ; 288.57,45.13 H20.1 ; H20.1 290.58,43.12 ; H20.1 289.11,46.6 ; H20.1 290.58,47.14 ; H20.1 289.11,43.66 ; H20.1 292.58,45.13 ; H20.1 292.05,43.66 ; H20.1 292.05,46.6 ; 1.8,73.5 JHDMI1.21 ; JHDMI1.21 5.1,73.5 ; JHDMI1.21 5.1,74.5 ; JHDMI1.21 1.8,74.5 ; JHDMI1.21 3.45,74.5 ; 301.8,83.23 JUSB1.7 ; JUSB1.7 302.61,82.43 ; JUSB1.7 302.61,84.03 ; JUSB1.7 303.22,83.85 ; JUSB1.7 301.99,82.61 ; JUSB1.7 301.99,83.85 ; JUSB1.7 303.22,82.61 ; JHDMI1.5 12.05,62.7 ; JHDMI1.5 11.15,61.8 ; JHDMI1.5 11.04,62.25 ; JHDMI1.5 12.16,62.25 ; JHDMI1.5 11.15,62.7 ; JHDMI1.5 12.05,61.8 ; H4.1 101.08,88.8 ; H4.1 99.43,92.71 ; H4.1 101.69,90.45 ; H4.1 97.78,92.1 ; H4.1 101.08,92.1 ; H4.1 97.17,90.45 ; H4.1 99.43,88.19 ; H4.1 97.78,88.8 ; 6.25,49.45 JUSB2.11 ; JUSB2.11 8.56,49.45 ; JUSB2.11 8.56,50.25 ; JUSB2.11 6.25,50.25 ; JUSB2.11 7.41,50.25 ; H31.1 7.08,79.5 ; H31.1 6.32,79.5 ; H31.1 6.32,76.2 ; H31.1 7.08,76.2 ; H31.1 7.84,76.2 ; H31.1 7.84,79.5 ; H31.1 7.84,77.85 ; H31.1 6.32,77.85 ; 5.55,90.92 JUSBC1.5 ; JUSBC1.5 6.95,90.92 ; JUSBC1.5 6.25,90.92 ; JUSBC1.5 5.55,89.84 ; 301.59,100.75 H16.1 ; H16.1 300.34,101.2 ; H16.1 302.84,103.7 ; H16.1 302.84,101.2 ; H16.1 303.29,102.45 ; H16.1 300.34,103.7 ; H16.1 299.89,102.45 ; H16.1 301.59,104.15 ; 11.15,67.8 JHDMI1.17 ; JHDMI1.17 11.15,68.7 ; JHDMI1.17 12.05,67.8 ; JHDMI1.17 12.16,68.25 ; JHDMI1.17 11.04,68.25 ; JHDMI1.17 12.05,68.7 ; 1.8,56 JHDMI1.23 ; JHDMI1.23 5.1,56 ; JHDMI1.23 5.1,55 ; JHDMI1.23 1.8,55 ; JHDMI1.23 3.45,55 ; 308.9,74.73 JUSB1.11 ; JUSB1.11 310.06,74.73 ; JUSB1.11 308.9,75.53 ; JUSB1.11 311.21,75.53 ; JUSB1.11 311.21,74.73 ; JUSBC1.3 3.25,81.53 ; JUSBC1.3 0.35,81.53 ; JUSBC1.3 3.25,80.73 ; JUSBC1.3 0.35,80.73 ; JUSBC1.3 1.8,80.73 ; JUSBC1.3 0.35,82.33 ; JUSBC1.3 3.25,82.33 ; JUSBC1.3 1.8,82.33
  IN1 w0.254: 25.32,93.86 25.32,93.95 24.48,94.79 18.51,94.79 16.83,93.11 13.84,93.11 12.84,94.11 11.51,94.11 10.78,93.38 10.78,92.44 9.33,91 4.94,91 4.02,90.08 4.02,81.7 5.03,80.69 8.96,80.69 13.82,75.82 13.82,71.09 v1(13.66,70.92) 13.66,70.68 v1(14.38,69.96) 14.79,69.55 14.79,60 14.9,59.88 14.9,54.58 14.62,54.3 14.24,54.3 v1(14.1,54.16) 13.94,54.32 13.94,59.48 13.82,59.6 13.82,68.98 12.55,70.25 12.55,71.25 JHDMI1.20 ; 35.5,105.52 35.5,105.11 34.52,104.13 34.52,104.13 32.84,102.45 32.84,100.83 v1(33.07,100.6) 32.84,100.37 32.84,99.01 34.56,97.28 34.56,93.33 33.75,92.51 33.32,92.51 33.01,92.82 v1(33.01,93.33) 33.14,93.33 33.53,93.72 33.53,96.94 32.4,98.08 ; 35.5,105.52 35.91,105.52 36.19,105.24 39.93,105.24 40.49,105.8 41.61,105.8 42.96,107.14 ; 35.5,105.52 35.15,105.87 v1(35.02,105.87) 34.89,105.87 31.87,102.85 31.87,98.61 32.4,98.08 ; 12.86,72.64 12.86,75.42 8.56,79.72 7.08,79.72 ; 32.4,98.08 31.97,97.66 31.97,93.84 29.53,91.4 26.82,91.4
  IN1 w0.508: v1(283.29,38.47) 283.29,38.04 285.45,35.87 v1(286.71,35.87)
  GND2 w0.203: 301.11,85.93 JUSB1.4 ; JUSB1.4 301.11,87.53 ; JUSB1.4 301.72,87.35 ; JUSB1.4 300.3,86.73 ; JUSB1.4 300.49,86.11 ; JUSB1.4 300.49,87.35 ; JUSB1.4 301.91,86.73 ; JUSB1.4 301.72,86.11 ; 10.54,72.85 JHDMI1.20 ; JHDMI1.20 11.8,72.85 ; JHDMI1.20 13.06,72 ; JHDMI1.20 11.8,71.15 ; JHDMI1.20 13.06,72.85 ; JHDMI1.20 10.54,71.15 ; JHDMI1.20 13.06,71.15 ; JUSB2.4 16.36,39.05 ; JUSB2.4 16.97,38.87 ; JUSB2.4 15.74,37.63 ; JUSB2.4 15.74,38.87 ; JUSB2.4 16.36,37.45 ; JUSB2.4 17.16,38.25 ; JUSB2.4 16.97,37.63 ; JUSB2.4 15.55,38.25 ; 3.45,55 JHDMI1.23 ; JHDMI1.23 5.1,56 ; JHDMI1.23 1.8,55 ; JHDMI1.23 1.8,56 ; JHDMI1.23 5.1,55 ; 11.8,56.65 JHDMI1.22 ; JHDMI1.22 10.54,56.65 ; JHDMI1.22 13.06,58.35 ; JHDMI1.22 11.8,58.35 ; JHDMI1.22 13.06,57.5 ; JHDMI1.22 10.54,58.35 ; JHDMI1.22 13.06,56.65 ; 313,50.94 JSD1.13 ; JSD1.13 314.11,51.63 ; JSD1.13 314.11,52.33 ; JSD1.13 311.89,50.94 ; JSD1.13 311.89,51.63 ; JSD1.13 313,52.33 ; JSD1.13 311.89,52.33 ; JSD1.13 314.11,50.94 ; 299.5,88.83 JUSB1.12 ; JUSB1.12 302.11,88.83 ; JUSB1.12 299.5,90.43 ; JUSB1.12 300.81,88.83 ; JUSB1.12 299.5,89.63 ; JUSB1.12 302.11,90.43 ; JUSB1.12 300.81,90.43 ; JUSB1.12 302.11,89.63 ; H11.1 5.73,96 ; H11.1 4.03,94.3 ; H11.1 4.48,93.05 ; H11.1 5.73,92.6 ; H11.1 7.43,94.3 ; H11.1 6.98,93.05 ; H11.1 6.98,95.55 ; H11.1 4.48,95.55 ; 274.96,100.88 H21.1 ; H21.1 276.44,100.34 ; H21.1 277.91,103.82 ; H21.1 277.91,100.88 ; H21.1 276.44,104.36 ; H21.1 274.43,102.35 ; H21.1 278.44,102.35 ; H21.1 274.96,103.82 ; 12.7,63.3 JHDMI1.8 ; JHDMI1.8 12.7,64.2 ; JHDMI1.8 13.6,64.2 ; JHDMI1.8 13.71,63.75 ; JHDMI1.8 13.6,63.3 ; JHDMI1.8 12.59,63.75 ; H28.1 312.68,30.65 ; H28.1 311.43,27.7 ; H28.1 314.38,28.95 ; H28.1 313.93,27.7 ; H28.1 313.93,30.2 ; H28.1 312.68,27.25 ; H28.1 311.43,30.2 ; H28.1 310.98,28.95 ; JUSB1.13 310.06,91.73 ; JUSB1.13 308.9,91.73 ; JUSB1.13 311.21,91.73 ; JUSB1.13 308.9,90.93 ; JUSB1.13 311.21,90.93 ; 5.55,81.85 JUSBC1.6 ; JUSBC1.6 6.95,82.73 ; JUSBC1.6 6.25,80.78 ; JUSBC1.6 5.55,82.73 ; JUSBC1.6 6.25,82.73 ; JUSBC1.6 6.95,80.78 ; JUSBC1.6 5.55,80.78 ; H15.1 265.98,112.8 ; H15.1 264.73,109.85 ; H15.1 263.03,111.55 ; H15.1 264.73,113.25 ; H15.1 266.43,111.55 ; H15.1 263.48,110.3 ; H15.1 263.48,112.8 ; H15.1 265.98,110.3 ; 315.09,65.93 JSD1.12 ; JSD1.12 316.2,64.54 ; JSD1.12 316.2,65.93 ; JSD1.12 315.09,65.23 ; 5.54,81.53 JUSBC1.4 ; JUSBC1.4 8.16,82.28 ; JUSBC1.4 6.85,80.78 ; JUSBC1.4 5.54,80.78 ; JUSBC1.4 8.16,81.53 ; JUSBC1.4 8.16,80.78 ; JUSBC1.4 6.85,82.28 ; JUSB1.11 311.21,74.73 ; JUSB1.11 310.06,74.73 ; JUSB1.11 311.21,75.53 ; JUSB1.11 308.9,75.53 ; JUSB1.11 308.9,74.73 ; H3.1 101.69,69.25 ; H3.1 97.78,70.9 ; H3.1 97.17,69.25 ; H3.1 97.78,67.6 ; H3.1 99.43,66.99 ; H3.1 99.43,71.51 ; H3.1 101.08,70.9 ; H3.1 101.08,67.6 ; 15.35,35.35 JUSB2.12 ; JUSB2.12 16.66,36.15 ; JUSB2.12 17.96,36.15 ; JUSB2.12 16.66,34.55 ; JUSB2.12 15.35,36.15 ; JUSB2.12 17.96,35.35 ; JUSB2.12 17.96,34.55 ; JUSB2.12 15.35,34.55 ; 99.43,88.19 H4.1 ; H4.1 101.08,92.1 ; H4.1 97.78,92.1 ; H4.1 101.69,90.45 ; H4.1 97.78,88.8 ; H4.1 101.08,88.8 ; H4.1 99.43,92.71 ; H4.1 97.17,90.45 ; H1.1 166.09,90.45 ; H1.1 161.57,90.45 ; H1.1 163.83,92.71 ; H1.1 163.83,88.19 ; H1.1 165.48,92.1 ; H1.1 165.48,88.8 ; H1.1 162.18,92.1 ; H1.1 162.18,88.8 ; 0.35,81.53 JUSBC1.3 ; JUSBC1.3 1.8,80.73 ; JUSBC1.3 1.8,82.33 ; JUSBC1.3 3.25,82.33 ; JUSBC1.3 0.35,80.73 ; JUSBC1.3 0.35,82.33 ; JUSBC1.3 3.25,80.73 ; JUSBC1.3 3.25,81.53 ; JHDMI1.11 12.16,65.25 ; JHDMI1.11 11.15,64.8 ; JHDMI1.11 11.04,65.25 ; JHDMI1.11 11.15,65.7 ; JHDMI1.11 12.05,65.7 ; JHDMI1.11 12.05,64.8 ; 156.33,101.57 H5.1 ; H5.1 160.48,99.82 ; H5.1 161.13,101.57 ; H5.1 156.98,99.82 ; H5.1 160.48,103.32 ; H5.1 158.73,99.17 ; H5.1 158.73,103.97 ; H5.1 156.98,103.32 ; 1.8,73.5 JHDMI1.21 ; JHDMI1.21 5.1,74.5 ; JHDMI1.21 3.45,74.5 ; JHDMI1.21 1.8,74.5 ; JHDMI1.21 5.1,73.5 ; H29.1 305.65,100.65 ; H29.1 304.23,104.25 ; H29.1 305.65,102.45 ; H29.1 305.65,104.25 ; H29.1 304.23,100.65 ; H29.1 304.94,104.25 ; H29.1 304.23,102.45 ; H29.1 304.94,100.65 ; 6.32,79.5 H31.1 ; H31.1 7.84,76.2 ; H31.1 7.84,77.85 ; H31.1 6.32,76.2 ; H31.1 7.08,79.5 ; H31.1 7.08,76.2 ; H31.1 7.84,79.5 ; H31.1 6.32,77.85 ; JHDMI1.5 12.16,62.25 ; JHDMI1.5 11.04,62.25 ; JHDMI1.5 11.15,62.7 ; JHDMI1.5 12.05,61.8 ; JHDMI1.5 11.15,61.8 ; JHDMI1.5 12.05,62.7 ; 303.4,64.54 JSD1.11 ; JSD1.11 304.51,64.54 ; JSD1.11 304.51,65.23 ; JSD1.11 304.51,65.93 ; JSD1.11 302.29,65.93 ; JSD1.11 302.29,64.54 ; JSD1.11 302.29,65.23 ; JSD1.11 303.4,65.93 ; 14.24,42.37 JUSB2.7 ; JUSB2.7 15.66,41.75 ; JUSB2.7 14.85,40.95 ; JUSB2.7 15.47,42.37 ; JUSB2.7 14.85,42.55 ; JUSB2.7 14.24,41.13 ; JUSB2.7 15.47,41.13 ; 313.5,69.15 H17.1 ; H17.1 312.25,69.6 ; H17.1 312.25,72.1 ; H17.1 315.2,70.85 ; H17.1 313.5,72.55 ; H17.1 311.8,70.85 ; H17.1 314.75,69.6 ; H17.1 314.75,72.1 ; H18.1 314.11,22.22 ; H18.1 311.25,25.08 ; H18.1 311.25,22.22 ; H18.1 314.64,23.65 ; H18.1 310.72,23.65 ; H18.1 312.68,25.61 ; H18.1 314.11,25.08 ; H18.1 312.68,21.69 ; H8.1 158.73,27.55 ; H8.1 158.73,22.75 ; H8.1 160.48,26.9 ; H8.1 160.48,23.4 ; H8.1 156.33,25.15 ; H8.1 156.98,23.4 ; H8.1 156.98,26.9 ; H8.1 161.13,25.15 ; 289.11,46.6 H20.1 ; H20.1 288.57,45.13 ; H20.1 292.05,43.66 ; H20.1 292.58,45.13 ; H20.1 290.58,43.12 ; H20.1 292.05,46.6 ; H20.1 289.11,43.66 ; H20.1 290.58,47.14 ; 301.8,83.23 JUSB1.7 ; JUSB1.7 303.22,83.85 ; JUSB1.7 302.61,84.03 ; JUSB1.7 301.99,82.61 ; JUSB1.7 303.22,82.61 ; JUSB1.7 302.61,82.43 ; JUSB1.7 301.99,83.85 ; JUSB2.10 17.96,47.35 ; JUSB2.10 15.35,48.15 ; JUSB2.10 16.66,47.35 ; JUSB2.10 16.66,48.95 ; JUSB2.10 15.35,47.35 ; JUSB2.10 17.96,48.15 ; JUSB2.10 15.35,48.95 ; JUSB2.10 17.96,48.95 ; 49.23,110.39 H14.1 ; H14.1 48.07,113.11 ; H14.1 50.39,113.11 ; H14.1 47.67,111.95 ; H14.1 48.07,110.79 ; H14.1 50.79,111.95 ; H14.1 49.23,113.51 ; H14.1 50.39,110.79 ; 303.4,50.94 JSD1.10 ; JSD1.10 302.29,50.94 ; JSD1.10 302.29,51.63 ; JSD1.10 304.51,51.63 ; JSD1.10 304.51,50.94 ; JSD1.10 304.51,52.33 ; JSD1.10 302.29,52.33 ; JSD1.10 303.4,52.33 ; 6.85,89.42 JUSBC1.2 ; JUSBC1.2 6.85,90.92 ; JUSBC1.2 8.16,90.92 ; JUSBC1.2 8.16,90.17 ; JUSBC1.2 8.16,89.42 ; JUSBC1.2 5.54,90.92 ; JUSBC1.2 5.54,90.17 ; H27.1 6.99,27.25 ; H27.1 4.78,27.25 ; H27.1 2.57,27.25 ; H27.1 4.78,30.65 ; H27.1 2.57,28.95 ; H27.1 6.99,30.65 ; H27.1 6.99,28.95 ; H27.1 2.57,30.65 ; 8.39,92.65 H30.1 ; H30.1 9.15,92.65 ; H30.1 8.39,95.95 ; H30.1 9.15,95.95 ; H30.1 7.63,94.3 ; H30.1 7.63,95.95 ; H30.1 7.63,92.65 ; H30.1 9.15,94.3 ; H12.1 4.43,79.55 ; H12.1 3.18,76.6 ; H12.1 2.73,77.85 ; H12.1 5.68,79.1 ; H12.1 5.68,76.6 ; H12.1 4.43,76.15 ; H12.1 3.18,79.1 ; H12.1 6.13,77.85 ; 4.78,21.69 H13.1 ; H13.1 3.35,25.08 ; H13.1 4.78,25.61 ; H13.1 2.82,23.65 ; H13.1 6.74,23.65 ; H13.1 6.21,25.08 ; H13.1 6.21,22.22 ; H13.1 3.35,22.22 ; JUSB1.10 302.11,76.03 ; JUSB1.10 300.81,77.63 ; JUSB1.10 300.81,76.03 ; JUSB1.10 299.5,77.63 ; JUSB1.10 299.5,76.03 ; JUSB1.10 302.11,76.83 ; JUSB1.10 302.11,77.63 ; JUSB1.10 299.5,76.83 ; JUSBC1.1 3.25,90.97 ; JUSBC1.1 1.8,90.97 ; JUSBC1.1 0.35,90.97 ; JUSBC1.1 1.8,89.37 ; JUSBC1.1 3.25,89.37 ; JUSBC1.1 0.35,90.17 ; JUSBC1.1 0.35,89.37 ; JUSBC1.1 3.25,90.17 ; JUSB2.11 8.56,50.25 ; JUSB2.11 7.41,50.25 ; JUSB2.11 6.25,50.25 ; JUSB2.11 6.25,49.45 ; JUSB2.11 8.56,49.45 ; 163.83,66.99 H2.1 ; H2.1 163.83,71.51 ; H2.1 166.09,69.25 ; H2.1 161.57,69.25 ; H2.1 165.48,70.9 ; H2.1 165.48,67.6 ; H2.1 162.18,67.6 ; H2.1 162.18,70.9 ; JHDMI1.2 13.6,61.2 ; JHDMI1.2 13.71,60.75 ; JHDMI1.2 12.7,60.3 ; JHDMI1.2 12.7,61.2 ; JHDMI1.2 13.6,60.3 ; JHDMI1.2 12.59,60.75 ; JUSB2.13 8.56,33.25 ; JUSB2.13 8.56,34.05 ; JUSB2.13 7.41,33.25 ; JUSB2.13 6.25,33.25 ; JUSB2.13 6.25,34.05 ; JUSBC1.5 6.95,90.92 ; JUSBC1.5 6.25,88.97 ; JUSBC1.5 6.25,90.92 ; JUSBC1.5 6.95,88.97 ; JUSBC1.5 5.55,89.84 ; JUSBC1.5 5.55,90.92 ; JUSBC1.5 5.55,88.97 ; 301.59,100.75 H16.1 ; H16.1 300.34,101.2 ; H16.1 302.84,103.7 ; H16.1 302.84,101.2 ; H16.1 299.89,102.45 ; H16.1 300.34,103.7 ; H16.1 303.29,102.45 ; H16.1 301.59,104.15 ; JHDMI1.17 12.05,67.8 ; JHDMI1.17 12.05,68.7 ; JHDMI1.17 11.15,67.8 ; JHDMI1.17 12.16,68.25 ; JHDMI1.17 11.15,68.7 ; JHDMI1.17 11.04,68.25
  IN2 w0.127: v1(261.85,44.47) 260.39,44.47 260.03,44.83 249.9,44.83 249.43,44.36 245.54,44.36 244.28,43.1 243.39,43.1 241.49,41.21 230.57,41.21 228.88,42.9 219.87,42.9 201.29,61.49 201.29,65.47 199.65,69.82 199.65,70.16 199.06,70.75 199.06,73.17 195.95,76.28 194.48,76.28 188.6,82.15 188.6,84.24 187.74,85.1 186.26,85.1 184.91,83.75 182.19,83.75 181.21,84.73 181.21,86.57 180.5,87.28 179.52,87.28 176.47,90.33 174.98,90.33 174.45,89.79 173.1,89.79 171.38,91.52 167.91,91.52 163.99,95.44 163.81,95.44 162.74,96.5 162.74,97.92 162.57,98.1 162.57,98.74 162.12,99.18 161.8,99.18 161.49,98.86 161.49,97.85 161.87,97.47 161.87,96.64 v1(162.06,96.45) 163.52,94.99 163.8,94.99 167.72,91.07 171.19,91.07 172.91,89.34 174.64,89.34 175.17,89.87 176.28,89.87 177.17,88.98 177.17,88.82 179.17,86.83 180.31,86.83 180.76,86.38 180.76,84.54 182.01,83.3 185.1,83.3 186.29,84.48 v1(186.77,84.48) 187.72,84.48 188.15,84.05 188.15,81.96 194.29,75.82 195.77,75.82 198.61,72.98 198.61,70.56 199.15,70.02 199.15,69.86 200.84,65.39 200.84,61.3 219.69,42.45 228.69,42.45 230.39,40.75 241.68,40.75 243.57,42.65 244.47,42.65 245.49,43.67 v1(245.93,43.67) 246.06,43.54 253.69,43.54 254.53,44.38 259.84,44.38 260.43,43.79 262.06,43.79 262.15,43.88 v1(262.36,43.88)
  IN2 w0.254: v1(81.15,28.14) 82.59,26.69 84.69,26.69 v1(84.86,26.86) 85.03,26.69 85.92,26.69 87.6,28.36 90.78,28.36 94.37,24.78 113.73,24.78 118.05,29.1 123.77,29.1 124.42,29.76 v1(124.42,29.83) 124.61,30.02 v1(126.09,30.02) 126.38,30.02 126.89,29.51 126.89,28.12 126.4,27.63 118.66,27.63 114.34,23.31 93.53,23.31 v1(90.68,26.16) 90.33,26.51 v1(90.33,26.59) 87.9,26.59 86.81,25.49 v1(86.81,25.2) 86.73,25.11 v1(84.45,25.11) 81.73,25.11 v1(80.06,26.78) ; 59.23,67.32 56.43,64.53 v1(56.43,63.63) 56.43,63.05 56.06,62.68 55.48,62.68 55.25,62.91 55.25,64.71 58.26,67.72 58.26,70.5 56.09,72.68 56.09,73.6 55.43,74.26 v1(55.33,74.26) 53.82,75.77 53.82,78.8 52.98,79.64 52.2,79.64 51.31,80.53 51.31,81.88 52.36,82.92 53.67,82.92 54.04,83.29 54.04,86.18 57.36,89.5 59.23,89.5 61.73,92.01 62.73,92.01 62.96,91.78 62.96,91.13 60.23,88.4 57.62,88.4 55,85.78 55,82.89 54.07,81.96 ; 59.23,67.32 59.23,70.95 57.07,73.1 57.07,74.05 54.78,76.34 54.78,79.2 53.38,80.61 52.6,80.61 52.28,80.93 52.28,81.48 52.76,81.96 54.07,81.96 ; 59.23,67.32 59.28,67.27 59.28,63.17 60.42,62.03 60.74,62.03 61.06,62.35 61.06,62.75 60.24,63.57 60.24,71.3 58.03,73.51 58.03,74.45 55.75,76.74 55.75,79.61 54.06,81.29 54.06,81.95 54.07,81.96
  IN3 w0.254: 89.29,24.16 89.22,24.1 85.32,24.1 84.45,24.97 v1(84.45,25.11) 83.62,25.94 80.26,25.94 78.55,24.23 73.54,24.23 72.44,25.32 71.73,25.32 68.58,28.47 56.18,28.47 55.19,27.47 v1(55.19,26.77) 55.84,26.77 56.57,27.49 68.19,27.49 71.33,24.35 72.04,24.35 72.59,23.81 v1(72.59,23.62) 72.94,23.26 78.95,23.26 80.66,24.97 83.08,24.97 84.92,23.13 108.35,23.13 110,24.78 111.27,24.78 111.59,25.1 v1(111.59,25.27) 111.59,25.42 111.26,25.75 109.6,25.75 107.95,24.1 89.31,24.1 89.29,24.12 89.29,24.16 ; 89.29,24.16 v1(89.29,24.61)
  VCC w0.203: JUSB1.10 302.11,76.03 ; JUSB1.10 299.5,76.83 ; JUSB1.10 300.81,77.63 ; JUSB1.10 299.5,76.03 ; JUSB1.10 302.11,76.83 ; JUSB1.10 302.11,77.63 ; JUSB1.10 300.81,76.03 ; JUSB1.10 299.5,77.63 ; JUSBC1.1 1.8,90.97 ; JUSBC1.1 3.25,90.17 ; JUSBC1.1 1.8,89.37 ; JUSBC1.1 0.35,90.17 ; JUSBC1.1 3.25,90.97 ; JUSBC1.1 0.35,89.37 ; JUSBC1.1 0.35,90.97 ; JUSBC1.1 3.25,89.37 ; JHDMI1.22 11.8,58.35 ; JHDMI1.22 11.8,56.65 ; JHDMI1.22 13.06,57.5 ; JHDMI1.22 13.06,58.35 ; JHDMI1.22 10.54,58.35 ; JHDMI1.22 10.54,56.65 ; JHDMI1.22 13.06,56.65 ; 97.17,69.25 H3.1 ; H3.1 99.43,71.51 ; H3.1 99.43,66.99 ; H3.1 101.08,70.9 ; H3.1 101.69,69.25 ; H3.1 101.08,67.6 ; H3.1 97.78,70.9 ; H3.1 97.78,67.6 ; 301.99,82.61 JUSB1.7 ; JUSB1.7 303.22,82.61 ; JUSB1.7 303.22,83.85 ; JUSB1.7 301.99,83.85 ; JUSB1.7 301.8,83.23 ; JUSB1.7 302.61,84.03 ; JUSB1.7 302.61,82.43 ; JUSBC1.5 6.25,90.92 ; JUSBC1.5 5.55,89.84 ; JUSBC1.5 6.95,88.97 ; JUSBC1.5 5.55,90.92 ; JUSBC1.5 6.25,88.97 ; JUSBC1.5 6.95,90.92 ; JUSBC1.5 5.55,88.97 ; H31.1 7.84,76.2 ; H31.1 7.84,79.5 ; H31.1 7.84,77.85 ; H31.1 7.08,79.5 ; H31.1 6.32,76.2 ; H31.1 7.08,76.2 ; H31.1 6.32,79.5 ; H31.1 6.32,77.85 ; 6.25,33.25 JUSB2.13 ; JUSB2.13 8.56,34.05 ; JUSB2.13 7.41,33.25 ; JUSB2.13 8.56,33.25 ; JUSB2.13 6.25,34.05 ; 6.85,80.78 JUSBC1.4 ; JUSBC1.4 5.54,80.78 ; JUSBC1.4 8.16,81.53 ; JUSBC1.4 8.16,82.28 ; JUSBC1.4 6.85,82.28 ; JUSBC1.4 5.54,81.53 ; JUSBC1.4 8.16,80.78 ; JUSB2.11 8.56,50.25 ; JUSB2.11 7.41,50.25 ; JUSB2.11 6.25,50.25 ; JUSB2.11 6.25,49.45 ; JUSB2.11 8.56,49.45 ; 312.25,72.1 H17.1 ; H17.1 315.2,70.85 ; H17.1 313.5,69.15 ; H17.1 312.25,69.6 ; H17.1 311.8,70.85 ; H17.1 313.5,72.55 ; H17.1 314.75,72.1 ; H17.1 314.75,69.6 ; 11.8,71.15 JHDMI1.20 ; JHDMI1.20 11.8,72.85 ; JHDMI1.20 13.06,71.15 ; JHDMI1.20 10.54,72.85 ; JHDMI1.20 10.54,71.15 ; JHDMI1.20 13.06,72 ; JHDMI1.20 13.06,72.85 ; H12.1 5.68,79.1 ; H12.1 2.73,77.85 ; H12.1 6.13,77.85 ; H12.1 3.18,76.6 ; H12.1 4.43,79.55 ; H12.1 3.18,79.1 ; H12.1 5.68,76.6 ; H12.1 4.43,76.15 ; 303.4,50.94 JSD1.10 ; JSD1.10 302.29,50.94 ; JSD1.10 304.51,51.63 ; JSD1.10 304.51,52.33 ; JSD1.10 304.51,50.94 ; JSD1.10 302.29,51.63 ; JSD1.10 303.4,52.33 ; JSD1.10 302.29,52.33 ; 2.57,30.65 H27.1 ; H27.1 4.78,30.65 ; H27.1 2.57,27.25 ; H27.1 6.99,27.25 ; H27.1 2.57,28.95 ; H27.1 4.78,27.25 ; H27.1 6.99,30.65 ; H27.1 6.99,28.95 ; 311.89,52.33 JSD1.13 ; JSD1.13 314.11,51.63 ; JSD1.13 311.89,50.94 ; JSD1.13 314.11,52.33 ; JSD1.13 313,52.33 ; JSD1.13 311.89,51.63 ; JSD1.13 314.11,50.94 ; JSD1.13 313,50.94 ; 14.24,42.37 JUSB2.7 ; JUSB2.7 15.66,41.75 ; JUSB2.7 14.24,41.13 ; JUSB2.7 15.47,42.37 ; JUSB2.7 14.85,42.55 ; JUSB2.7 15.47,41.13 ; JUSB2.7 14.85,40.95 ; JUSB2.12 17.96,36.15 ; JUSB2.12 16.66,36.15 ; JUSB2.12 17.96,35.35 ; JUSB2.12 15.35,36.15 ; JUSB2.12 15.35,35.35 ; JUSB2.12 15.35,34.55 ; JUSB2.12 17.96,34.55 ; JUSB2.12 16.66,34.55 ; 4.03,94.3 H11.1 ; H11.1 7.43,94.3 ; H11.1 5.73,96 ; H11.1 5.73,92.6 ; H11.1 6.98,95.55 ; H11.1 6.98,93.05 ; H11.1 4.48,95.55 ; H11.1 4.48,93.05 ; 5.54,90.17 JUSBC1.2 ; JUSBC1.2 6.85,89.42 ; JUSBC1.2 8.16,90.92 ; JUSBC1.2 6.85,90.92 ; JUSBC1.2 8.16,89.42 ; JUSBC1.2 5.54,90.92 ; JUSBC1.2 8.16,90.17 ; 12.7,61.2 JHDMI1.2 ; JHDMI1.2 13.6,61.2 ; JHDMI1.2 13.6,60.3 ; JHDMI1.2 12.7,60.3 ; JHDMI1.2 12.59,60.75 ; JHDMI1.2 13.71,60.75 ; 11.15,65.7 JHDMI1.11 ; JHDMI1.11 11.04,65.25 ; JHDMI1.11 11.15,64.8 ; JHDMI1.11 12.05,65.7 ; JHDMI1.11 12.16,65.25 ; JHDMI1.11 12.05,64.8 ; 300.81,88.83 JUSB1.12 ; JUSB1.12 302.11,90.43 ; JUSB1.12 299.5,89.63 ; JUSB1.12 300.81,90.43 ; JUSB1.12 302.11,88.83 ; JUSB1.12 299.5,90.43 ; JUSB1.12 299.5,88.83 ; JUSB1.12 302.11,89.63 ; JUSB1.13 311.21,91.73 ; JUSB1.13 308.9,90.93 ; JUSB1.13 310.06,91.73 ; JUSB1.13 311.21,90.93 ; JUSB1.13 308.9,91.73 ; 11.15,67.8 JHDMI1.17 ; JHDMI1.17 11.15,68.7 ; JHDMI1.17 11.04,68.25 ; JHDMI1.17 12.16,68.25 ; JHDMI1.17 12.05,68.7 ; JHDMI1.17 12.05,67.8 ; JSD1.12 316.2,65.93 ; JSD1.12 315.09,65.23 ; JSD1.12 315.09,65.93 ; JSD1.12 316.2,64.54 ; 5.55,82.73 JUSBC1.6 ; JUSBC1.6 5.55,80.78 ; JUSBC1.6 6.25,80.78 ; JUSBC1.6 6.95,80.78 ; JUSBC1.6 6.95,82.73 ; JUSBC1.6 5.55,81.85 ; JUSBC1.6 6.25,82.73 ; JHDMI1.21 3.45,74.5 ; JHDMI1.21 1.8,74.5 ; JHDMI1.21 5.1,73.5 ; JHDMI1.21 1.8,73.5 ; JHDMI1.21 5.1,74.5 ; JUSBC1.3 3.25,81.53 ; JUSBC1.3 0.35,80.73 ; JUSBC1.3 0.35,81.53 ; JUSBC1.3 3.25,82.33 ; JUSBC1.3 1.8,80.73 ; JUSBC1.3 0.35,82.33 ; JUSBC1.3 3.25,80.73 ; JUSBC1.3 1.8,82.33 ; 2.82,23.65 H13.1 ; H13.1 4.78,21.69 ; H13.1 3.35,25.08 ; H13.1 6.74,23.65 ; H13.1 4.78,25.61 ; H13.1 6.21,22.22 ; H13.1 3.35,22.22 ; H13.1 6.21,25.08 ; 12.7,64.2 JHDMI1.8 ; JHDMI1.8 13.6,64.2 ; JHDMI1.8 12.59,63.75 ; JHDMI1.8 13.71,63.75 ; JHDMI1.8 12.7,63.3 ; JHDMI1.8 13.6,63.3 ; 15.74,38.87 JUSB2.4 ; JUSB2.4 17.16,38.25 ; JUSB2.4 16.97,38.87 ; JUSB2.4 15.74,37.63 ; JUSB2.4 16.36,39.05 ; JUSB2.4 16.97,37.63 ; JUSB2.4 15.55,38.25 ; JUSB2.4 16.36,37.45 ; 11.15,61.8 JHDMI1.5 ; JHDMI1.5 12.05,62.7 ; JHDMI1.5 11.04,62.25 ; JHDMI1.5 12.16,62.25 ; JHDMI1.5 11.15,62.7 ; JHDMI1.5 12.05,61.8 ; 1.8,56 JHDMI1.23 ; JHDMI1.23 1.8,55 ; JHDMI1.23 5.1,56 ; JHDMI1.23 5.1,55 ; JHDMI1.23 3.45,55 ; 300.49,86.11 JUSB1.4 ; JUSB1.4 300.3,86.73 ; JUSB1.4 301.11,85.93 ; JUSB1.4 300.49,87.35 ; JUSB1.4 301.72,87.35 ; JUSB1.4 301.11,87.53 ; JUSB1.4 301.91,86.73 ; JUSB1.4 301.72,86.11 ; JUSB2.10 17.96,47.35 ; JUSB2.10 15.35,48.15 ; JUSB2.10 17.96,48.15 ; JUSB2.10 16.66,48.95 ; JUSB2.10 15.35,47.35 ; JUSB2.10 15.35,48.95 ; JUSB2.10 16.66,47.35 ; 7.63,92.65 H30.1 ; H30.1 8.39,92.65 ; H30.1 7.63,94.3 ; H30.1 8.39,95.95 ; H30.1 7.63,95.95 ; 302.29,64.54 JSD1.11 ; JSD1.11 303.4,64.54 ; JSD1.11 303.4,65.93 ; JSD1.11 304.51,64.54 ; JSD1.11 304.51,65.23 ; JSD1.11 304.51,65.93 ; JSD1.11 302.29,65.23 ; JSD1.11 302.29,65.93 ; JUSB1.11 311.21,75.53 ; JUSB1.11 311.21,74.73 ; JUSB1.11 308.9,74.73 ; JUSB1.11 310.06,74.73 ; JUSB1.11 308.9,75.53
  IN4 w0.127: v1(261.85,44.47) 262.2,44.82 262.97,44.82 264.71,43.09 264.71,37.95 265.73,36.92 266.36,36.92 268.23,35.05 268.96,35.05 269.32,34.69 269.32,34.3 269.12,34.09 268.48,34.09 v1(268.26,34.31) 268.26,34.43 266.18,36.51 265.56,36.51 264.29,37.78 264.29,42.92 263.87,43.34 263.17,43.34 262.63,43.88 v1(262.36,43.88)
  GND3 w0.203: 6.25,49.45 JUSB2.11 ; JUSB2.11 6.25,50.25 ; JUSB2.11 8.56,49.45 ; JUSB2.11 8.56,50.25 ; JUSB2.11 7.41,50.25 ; 264.73,109.85 H15.1 ; H15.1 265.98,112.8 ; H15.1 263.48,110.3 ; H15.1 265.98,110.3 ; H15.1 263.03,111.55 ; H15.1 263.48,112.8 ; H15.1 266.43,111.55 ; H15.1 264.73,113.25 ; H16.1 303.29,102.45 ; H16.1 300.34,103.7 ; H16.1 299.89,102.45 ; H16.1 302.84,103.7 ; H16.1 302.84,101.2 ; H16.1 301.59,104.15 ; H16.1 300.34,101.2 ; H16.1 301.59,100.75 ; 7.63,95.95 H30.1 ; H30.1 8.39,95.95 ; H30.1 7.63,92.65 ; H30.1 9.15,95.95 ; H30.1 8.39,92.65 ; H30.1 9.15,92.65 ; H30.1 7.63,94.3 ; H30.1 9.15,94.3 ; H27.1 6.99,30.65 ; H27.1 6.99,28.95 ; H27.1 2.57,27.25 ; H27.1 2.57,28.95 ; H27.1 4.78,27.25 ; H27.1 2.57,30.65 ; H27.1 6.99,27.25 ; H27.1 4.78,30.65 ; JSD1.10 303.4,52.33 ; JSD1.10 302.29,50.94 ; JSD1.10 303.4,50.94 ; JSD1.10 304.51,51.63 ; JSD1.10 304.51,52.33 ; JSD1.10 302.29,51.63 ; JSD1.10 304.51,50.94 ; JSD1.10 302.29,52.33 ; H20.1 292.05,43.66 ; H20.1 292.58,45.13 ; H20.1 290.58,47.14 ; H20.1 292.05,46.6 ; H20.1 288.57,45.13 ; H20.1 289.11,43.66 ; H20.1 290.58,43.12 ; H20.1 289.11,46.6 ; 299.5,77.63 JUSB1.10 ; JUSB1.10 299.5,76.03 ; JUSB1.10 302.11,76.83 ; JUSB1.10 300.81,77.63 ; JUSB1.10 299.5,76.83 ; JUSB1.10 302.11,77.63 ; JUSB1.10 300.81,76.03 ; JUSB1.10 302.11,76.03 ; 7.41,33.25 JUSB2.13 ; JUSB2.13 6.25,34.05 ; JUSB2.13 8.56,34.05 ; JUSB2.13 6.25,33.25 ; JUSB2.13 8.56,33.25 ; 11.8,71.15 JHDMI1.20 ; JHDMI1.20 10.54,72.85 ; JHDMI1.20 10.54,71.15 ; JHDMI1.20 13.06,72 ; JHDMI1.20 11.8,72.85 ; JHDMI1.20 13.06,72.85 ; JHDMI1.20 13.06,71.15 ; 11.15,68.7 JHDMI1.17 ; JHDMI1.17 11.04,68.25 ; JHDMI1.17 11.15,67.8 ; JHDMI1.17 12.05,67.8 ; JHDMI1.17 12.16,68.25 ; JHDMI1.17 12.05,68.7 ; 162.18,88.8 H1.1 ; H1.1 163.83,92.71 ; H1.1 165.48,92.1 ; H1.1 165.48,88.8 ; H1.1 163.83,88.19 ; H1.1 166.09,90.45 ; H1.1 162.18,92.1 ; H1.1 161.57,90.45 ; JUSB1.4 301.11,87.53 ; JUSB1.4 301.91,86.73 ; JUSB1.4 300.3,86.73 ; JUSB1.4 301.11,85.93 ; JUSB1.4 300.49,86.11 ; JUSB1.4 301.72,86.11 ; JUSB1.4 301.72,87.35 ; JUSB1.4 300.49,87.35 ; 4.48,93.05 H11.1 ; H11.1 5.73,92.6 ; H11.1 5.73,96 ; H11.1 4.48,95.55 ; H11.1 7.43,94.3 ; H11.1 6.98,95.55 ; H11.1 4.03,94.3 ; H11.1 6.98,93.05 ; 0.35,80.73 JUSBC1.3 ; JUSBC1.3 1.8,82.33 ; JUSBC1.3 3.25,80.73 ; JUSBC1.3 3.25,81.53 ; JUSBC1.3 3.25,82.33 ; JUSBC1.3 1.8,80.73 ; JUSBC1.3 0.35,82.33 ; JUSBC1.3 0.35,81.53 ; 14.85,40.95 JUSB2.7 ; JUSB2.7 15.47,41.13 ; JUSB2.7 14.24,41.13 ; JUSB2.7 14.24,42.37 ; JUSB2.7 15.47,42.37 ; JUSB2.7 15.66,41.75 ; JUSB2.7 14.85,42.55 ; JUSB2.4 16.36,39.05 ; JUSB2.4 17.16,38.25 ; JUSB2.4 16.97,37.63 ; JUSB2.4 16.97,38.87 ; JUSB2.4 15.74,38.87 ; JUSB2.4 16.36,37.45 ; JUSB2.4 15.74,37.63 ; JUSB2.4 15.55,38.25 ; JUSBC1.1 3.25,90.17 ; JUSBC1.1 1.8,89.37 ; JUSBC1.1 0.35,89.37 ; JUSBC1.1 3.25,90.97 ; JUSBC1.1 3.25,89.37 ; JUSBC1.1 0.35,90.97 ; JUSBC1.1 0.35,90.17 ; JUSBC1.1 1.8,90.97 ; H2.1 165.48,67.6 ; H2.1 163.83,66.99 ; H2.1 166.09,69.25 ; H2.1 165.48,70.9 ; H2.1 162.18,67.6 ; H2.1 163.83,71.51 ; H2.1 162.18,70.9 ; H2.1 161.57,69.25 ; H4.1 99.43,92.71 ; H4.1 101.08,92.1 ; H4.1 101.69,90.45 ; H4.1 97.17,90.45 ; H4.1 101.08,88.8 ; H4.1 99.43,88.19 ; H4.1 97.78,92.1 ; H4.1 97.78,88.8 ; JHDMI1.2 13.6,60.3 ; JHDMI1.2 12.7,61.2 ; JHDMI1.2 12.7,60.3 ; JHDMI1.2 13.6,61.2 ; JHDMI1.2 12.59,60.75 ; JHDMI1.2 13.71,60.75 ; 7.08,76.2 H31.1 ; H31.1 6.32,79.5 ; H31.1 7.84,79.5 ; H31.1 7.08,79.5 ; H31.1 6.32,76.2 ; H31.1 7.84,77.85 ; H31.1 6.32,77.85 ; H31.1 7.84,76.2 ; 3.35,22.22 H13.1 ; H13.1 6.21,22.22 ; H13.1 2.82,23.65 ; H13.1 6.74,23.65 ; H13.1 6.21,25.08 ; H13.1 4.78,21.69 ; H13.1 4.78,25.61 ; H13.1 3.35,25.08 ; JSD1.11 304.51,65.23 ; JSD1.11 303.4,65.93 ; JSD1.11 303.4,64.54 ; JSD1.11 302.29,65.93 ; JSD1.11 304.51,64.54 ; JSD1.11 302.29,65.23 ; JSD1.11 304.51,65.93 ; JSD1.11 302.29,64.54 ; 2.73,77.85 H12.1 ; H12.1 4.43,79.55 ; H12.1 6.13,77.85 ; H12.1 5.68,79.1 ; H12.1 5.68,76.6 ; H12.1 4.43,76.15 ; H12.1 3.18,76.6 ; H12.1 3.18,79.1 ; 301.99,82.61 JUSB1.7 ; JUSB1.7 301.99,83.85 ; JUSB1.7 303.22,83.85 ; JUSB1.7 301.8,83.23 ; JUSB1.7 303.22,82.61 ; JUSB1.7 302.61,84.03 ; JUSB1.7 302.61,82.43 ; JUSB2.10 17.96,48.95 ; JUSB2.10 15.35,47.35 ; JUSB2.10 16.66,47.35 ; JUSB2.10 17.96,48.15 ; JUSB2.10 17.96,47.35 ; JUSB2.10 15.35,48.95 ; JUSB2.10 16.66,48.95 ; JUSB2.10 15.35,48.15 ; 311.8,70.85 H17.1 ; H17.1 312.25,72.1 ; H17.1 313.5,69.15 ; H17.1 315.2,70.85 ; H17.1 314.75,69.6 ; H17.1 313.5,72.55 ; H17.1 314.75,72.1 ; H17.1 312.25,69.6 ; H3.1 99.43,71.51 ; H3.1 101.08,70.9 ; H3.1 101.69,69.25 ; H3.1 97.78,70.9 ; H3.1 101.08,67.6 ; H3.1 97.78,67.6 ; H3.1 99.43,66.99 ; H3.1 97.17,69.25 ; 311.25,22.22 H18.1 ; H18.1 311.25,25.08 ; H18.1 312.68,21.69 ; H18.1 310.72,23.65 ; H18.1 314.11,22.22 ; H18.1 312.68,25.61 ; H18.1 314.64,23.65 ; H18.1 314.11,25.08 ; JHDMI1.8 13.71,63.75 ; JHDMI1.8 13.6,63.3 ; JHDMI1.8 12.59,63.75 ; JHDMI1.8 12.7,64.2 ; JHDMI1.8 12.7,63.3 ; JHDMI1.8 13.6,64.2 ; JUSBC1.5 6.95,90.92 ; JUSBC1.5 6.25,90.92 ; JUSBC1.5 5.55,88.97 ; JUSBC1.5 5.55,89.84 ; JUSBC1.5 5.55,90.92 ; H5.1 158.73,103.97 ; H5.1 158.73,99.17 ; H5.1 160.48,99.82 ; H5.1 156.98,103.32 ; H5.1 160.48,103.32 ; H5.1 156.33,101.57 ; H5.1 161.13,101.57 ; H5.1 156.98,99.82 ; JHDMI1.22 13.06,58.35 ; JHDMI1.22 13.06,56.65 ; JHDMI1.22 13.06,57.5 ; JHDMI1.22 11.8,56.65 ; JHDMI1.22 10.54,58.35 ; JHDMI1.22 10.54,56.65 ; JHDMI1.22 11.8,58.35 ; 47.67,111.95 H14.1 ; H14.1 50.39,110.79 ; H14.1 50.79,111.95 ; H14.1 48.07,110.79 ; H14.1 49.23,113.51 ; H14.1 49.23,110.39 ; H14.1 50.39,113.11 ; H14.1 48.07,113.11 ; 1.8,74.5 JHDMI1.21 ; JHDMI1.21 5.1,73.5 ; JHDMI1.21 1.8,73.5 ; JHDMI1.21 3.45,74.5 ; JHDMI1.21 5.1,74.5 ; 158.73,22.75 H8.1 ; H8.1 161.13,25.15 ; H8.1 156.98,23.4 ; H8.1 160.48,23.4 ; H8.1 158.73,27.55 ; H8.1 156.98,26.9 ; H8.1 156.33,25.15 ; H8.1 160.48,26.9 ; 1.8,55 JHDMI1.23 ; JHDMI1.23 5.1,56 ; JHDMI1.23 5.1,55 ; JHDMI1.23 1.8,56 ; JHDMI1.23 3.45,55 ; 274.43,102.35 H21.1 ; H21.1 278.44,102.35 ; H21.1 277.91,103.82 ; H21.1 274.96,103.82 ; H21.1 277.91,100.88 ; H21.1 276.44,104.36 ; H21.1 274.96,100.88 ; H21.1 276.44,100.34 ; 5.54,90.92 JUSBC1.2 ; JUSBC1.2 8.16,90.92 ; JUSBC1.2 5.54,90.17 ; JUSBC1.2 8.16,90.17 ; JUSBC1.2 6.85,90.92 ; JHDMI1.5 12.16,62.25 ; JHDMI1.5 12.05,62.7 ; JHDMI1.5 12.05,61.8 ; JHDMI1.5 11.04,62.25 ; JHDMI1.5 11.15,61.8 ; JHDMI1.5 11.15,62.7 ; 308.9,75.53 JUSB1.11 ; JUSB1.11 308.9,74.73 ; JUSB1.11 311.21,74.73 ; JUSB1.11 310.06,74.73 ; JUSB1.11 311.21,75.53 ; H28.1 312.68,30.65 ; H28.1 311.43,30.2 ; H28.1 313.93,30.2 ; H28.1 310.98,28.95 ; H28.1 314.38,28.95 ; H28.1 313.93,27.7 ; H28.1 312.68,27.25 ; H28.1 311.43,27.7 ; 304.23,102.45 H29.1 ; H29.1 304.23,104.25 ; H29.1 304.23,100.65 ; H29.1 305.65,104.25 ; H29.1 305.65,102.45 ; H29.1 304.94,104.25 ; H29.1 304.94,100.65 ; H29.1 305.65,100.65 ; JUSB1.13 311.21,90.93 ; JUSB1.13 311.21,91.73 ; JUSB1.13 308.9,91.73 ; JUSB1.13 308.9,90.93 ; JUSB1.13 310.06,91.73 ; JUSB1.12 302.11,89.63 ; JUSB1.12 302.11,90.43 ; JUSB1.12 299.5,89.63 ; JUSB1.12 299.5,88.83 ; JUSB1.12 302.11,88.83 ; JUSB1.12 299.5,90.43 ; JUSB1.12 300.81,90.43 ; JUSB1.12 300.81,88.83 ; JHDMI1.11 12.05,64.8 ; JHDMI1.11 11.04,65.25 ; JHDMI1.11 12.16,65.25 ; JHDMI1.11 11.15,65.7 ; JHDMI1.11 11.15,64.8 ; JHDMI1.11 12.05,65.7 ; JUSBC1.4 8.16,80.78 ; JUSBC1.4 5.54,81.53 ; JUSBC1.4 8.16,81.53 ; JUSBC1.4 6.85,80.78 ; JUSBC1.4 5.54,80.78 ; 5.55,81.85 JUSBC1.6 ; JUSBC1.6 6.95,80.78 ; JUSBC1.6 5.55,82.73 ; JUSBC1.6 5.55,80.78 ; JUSBC1.6 6.25,80.78 ; JUSB2.12 16.66,36.15 ; JUSB2.12 15.35,35.35 ; JUSB2.12 15.35,34.55 ; JUSB2.12 17.96,34.55 ; JUSB2.12 16.66,34.55 ; JUSB2.12 17.96,36.15 ; JUSB2.12 15.35,36.15 ; JUSB2.12 17.96,35.35 ; JSD1.13 314.11,50.94 ; JSD1.13 313,50.94 ; JSD1.13 314.11,51.63 ; JSD1.13 311.89,50.94 ; JSD1.13 314.11,52.33 ; JSD1.13 311.89,51.63 ; JSD1.13 311.89,52.33 ; JSD1.13 313,52.33 ; JSD1.12 316.2,65.93 ; JSD1.12 315.09,65.23 ; JSD1.12 316.2,64.54 ; JSD1.12 315.09,65.93
  BOTTOM w0.076: 114.61,74.78 UC1.K27 114.02,74.78 ; UC1.K25 114.81,75.76 ; UC1.K25 114.22,75.76 ; UC1.K25 114.52,76.05 ; UC1.K25 114.52,75.46 ; 114.31,73.12 UC1.K30 114.02,72.83 ; 114.02,74.13 UC1.K28 114.31,74.42 ; UC1.J33 114.3,70.81 ; UC1.J33 113.72,70.81 ; UC1.J33 114.01,71.1 ; 34.88,87.65 v1(34.83,87.65)
  BOTTOM w0.09: v1(150.52,67.96) 150.52,68.94 UC1.CJ36 ; UC1.CP21 v1(154.52,78.59) ; v1(108.74,78.57) UC1.B21 ; v1(117.79,67.96) UC1.T36 ; UC1.AT36 v1(130.37,67.96) ; UC1.BY36 v1(145.47,67.96) ; UC1.BD36 v1(135.41,67.96) ; UC1.BM36 v1(140.44,67.96) ; UC1.CP13 v1(154.52,83.63) ; UC1.CP9 v1(154.52,86.15) ; v1(108.74,76.06) UC1.B25 ; UC1.CE36 v1(147.99,67.96) ; UC1.L36 v1(115.27,67.96) ; v1(108.74,73.54) UC1.B29 ; v1(142.96,67.96) UC1.BT36
  BOTTOM w0.1: 114.29,76.89 UC1.K24 ; UC1.K24 114.74,76.89 ; UC1.K24 114.74,76.44 ; UC1.K24 114.29,76.44 ; 114.29,75.98 UC1.K25 ; UC1.K25 114.74,75.98 ; UC1.K25 114.74,75.53 ; 114.29,78.02 UC1.K22 ; UC1.K22 114.74,78.02 ; UC1.K22 114.74,77.57 ; 114.29,78.48 UC1.K21 114.74,78.48 ; UC1.BP15 141.64,82.2 ; UC1.BP15 141.19,82.2 ; UC1.BP15 141.19,82.65 ; 126.01,75.86 UC1.AJ25 125.94,75.48
  BOTTOM w0.102: UC1.AG26 125.01,75.46 125.01,75.47 UC1.AH25 ; UC1.AG26 124.55,75.48 124.55,75.49 UC1.AF25 ; UC1.AG26 124.58,75.03 124.58,75.02 UC1.AF27 124.12,75 124.12,75 UC1.AE26 ; UC1.AE26 123.67,75.46 123.67,75.47 UC1.AE25 123.64,75.92 123.64,75.93 UC1.AE24 ; UC1.AE26 124.12,75.48 124.12,75.49 UC1.AF25 ; UC1.AE26 123.67,75.03 123.67,75.02 UC1.AE27 ; UC1.AH25 125.01,75.95 125.01,75.96 UC1.AG24 ; UC1.AH25 125.49,75.95 125.49,75.96 UC1.AH24 ; UC1.AH24 125.92,75.96 125.92,75.95 126.01,75.86 ; UC1.AH24 125.44,76.43 125.44,76.43 ; UC1.AH24 125.71,76.19 125.95,76.43 ; UC1.AG24 124.79,76.19 124.55,76.43 ; UC1.AG24 124.55,75.93 124.55,75.92 UC1.AF25 ; UC1.AG24 125.06,76.43 ; UC1.AF25 124.1,75.95 124.1,75.96 UC1.AE24 ; UC1.AE24 124.15,76.43 124.17,76.43
  BOTTOM w0.12: UC1.D21 UC1.C21
  BOTTOM w0.127: v1(11.98,80.73) v3(11.98,79.83) ; v3(82.66,111.07) 82.66,111.67 v1(82.81,111.82) ; UT1.A22 UT1.B22 ; 30.99,80.41 31.18,80.23 UT1.AB6 ; v1(168.08,89.53) v3(168.08,90.47) ; v1(48.33,47.77) v3(48.33,48.56) ; v1(28.4,81.67) 28.62,81.89 UT1.T2 UT1.T1 ; v1(144.53,107.98) v3(143.55,107.98) ; v1(177.04,93.28) v3(176.22,93.28) ; UT1.AC18 UT1.AB18 ; v1(243.02,47.05) v3(243.02,48.08) ; v1(149.61,107.18) v3(149.61,108.27) ; v1(102.5,94.55) v3(102.5,93.31)
  BOTTOM w0.152: UT1.AC6 UT1.AB6 ; UT1.L22 UT1.L23 26.32,71.65 v1(26.34,71.62) ; UT1.R23 UT1.R22 ; v1(32.41,73.76) 32.38,73.79 UT1.AC20 ; 23.56,72.98 UT1.E22 UT1.E23 23.56,71.95 23.63,71.88 23.63,71.11 23.56,71.04 ; UT1.N22 UT1.N23 ; 31.06,78.39 31.01,78.34 31.01,77.15 31.33,77.47 UT1.AB12 UT1.AC12 ; 31.06,78.39 UT1.Y9 ; 31.06,78.39 UT1.AB10 UT1.AC10 32.17,78.39 32.3,78.52 32.52,78.52 v1(32.52,78.51) ; UT1.AC8 UT1.AB8 31.06,79.31 30.92,79.17 ; 21.22,70.92 22.64,72.35 UT1.C23 UT1.C22 UT1.B22 ; v1(32.59,76.54) 32.58,76.55 UT1.AC14 UT1.AB14 ; v1(25.84,83.01) 25.86,83 UT1.K1 UT1.K2 ; UT1.A12 UT1.B12 ; UT1.AB22 UT1.AC22 ; UT1.AC18 32.36,74.71 v1(32.39,74.74) ; UT1.A20 UT1.B20 ; UT1.A6 UT1.B6 ; v1(31.31,71.82) 30.92,72.21 UT1.AA23 UT1.AA22 ; v1(24.86,83.04) 24.94,82.96 UT1.H1 UT1.H2 ; UT1.B16 UT1.A16 ; UT1.G23 UT1.G22 ; UT1.U22 UT1.U23 ; v1(26.72,83.03) 26.78,82.98 UT1.M1 UT1.M2 ; UT1.B18 UT1.A18 ; v1(25.37,71.62) 25.37,71.65 25.41,71.69 25.41,72.41 UT1.J23 UT1.J22 ; UT1.AC16 31.84,75.63 31.38,75.63 UT1.AB16 ; UT1.B14 UT1.A14 ; UT1.AC2 UT1.AB2 UT1.AB1 UT1.AC1 ; v1(28.01,84.26) 27.69,83.94 27.69,82.78 27.7,82.77 UT1.P1 UT1.P2 ; UT1.A8 UT1.B8 ; UT1.W23 UT1.W22
  BOTTOM w0.16: UC1.B31 109.63,72.29 108.01,72.29 v1(108.01,72.28)
  BOTTOM w0.175: v1(32.45,77.53) 32.4,77.47 UT1.AC12
  BOTTOM w0.178: UT1.AB20 UT1.AC20 ; UT1.B10 UT1.A10
  BOTTOM w0.18: UC1.AC10 v1(122.39,84.73) ; UC1.AV25 v1(131.63,76.39) ; v1(130.71,84.77) UC1.AU10 ; UC1.BK3 UC1.BK2 v1(138.95,91.69) ; UC1.CP15 154.99,82.37 v1(155.14,82.23) ; v1(134.86,86.77) UC1.BC8 ; v1(136.25,84.91) UC1.BE10 ; UC1.BF36 v1(136.66,67.23) ; UC1.BL25 v1(139.83,76.39) ; UC1.CP19 v1(155.27,79.85) ; UC1.V36 119.04,68.86 v1(119.04,67.23) ; UC1.B7 v1(109.12,87.42) ; UC1.CP27 153.81,74.62 154.55,74.62 154.77,74.4 v1(155.37,74.4) ; UC1.P36 v1(116.53,67.23) ; UC1.AF36 124.08,68.86 124.08,67.23 v1(124.07,67.21) ; UC1.AV8 v1(132.09,86.77) ; UC1.W10 v1(119.62,84.73) ; UC1.P10 v1(116.85,84.73) ; UC1.BK10 v1(139.02,84.76) ; v1(117.9,77.02) 118.41,76.51 UC1.U24 ; UC1.CP11 153.63,84.91 155.28,84.91 v1(155.3,84.93) ; UC1.BM9 v1(140.41,85.4) ; UC1.BC25 v1(134.36,76.39) ; UC1.J36 v1(114.01,67.21) ; v1(132.09,88.04) 131.99,87.99 UC1.AV6 ; UC1.B23 v1(108.01,77.32) ; UC1.AB36 v1(121.56,67.23) ; v1(129.32,86.75) UC1.AN8 ; UC1.AN25 v1(128.9,76.39) ; v1(134.15,67.23) UC1.BB36 ; UC1.BA10 v1(133.48,84.93) ; UC1.CF3 UC1.CF2 v1(148.72,91.69) ; v1(133.94,88.04) UC1.BA6 ; UC1.CB3 UC1.CB2 146.27,91.6 v1(146.12,91.75) ; v1(136.71,86.77) UC1.BE8 ; UC1.AM10 v1(127.93,84.73) ; v1(126.6,67.23) UC1.AK36 ; UC1.AV36 v1(131.63,67.23) ; v1(129.32,87.4) UC1.AN7 ; v1(129.11,67.23) 129.11,68.86 UC1.AP36 ; UC1.B27 108.03,74.8 v1(108.01,74.78) ; UC1.AG10 v1(125.16,84.73) ; UC1.N25 v1(116.14,76.39)
  BOTTOM w0.2: UC1.E9 v1(111.41,85.71) UC1.D9 UC1.D8 ; UC1.V4 119.43,89.17 v1(119.43,89.68) UC1.V3 ; UC1.AB27 v1(121.15,74.49) ; v1(109.64,82.82) 109.96,82.35 UC1.B15 ; UC1.C9 v1(110.29,85.64) ; UC1.AL32 127.06,71.49 v1(126.62,71.28) UC1.AK33 ; UC1.CB4 146.27,89.17 v1(146.27,89.68) UC1.CB3 ; UC1.AC30 122.52,72.77 v1(122.06,72.52) ; UC1.AH33 v1(125.34,70.21) UC1.AH35 ; UC1.B12 109.96,84.23 v1(109.64,84.7) ; UC1.V30 v1(118.41,72.58) ; UC1.W30 v1(119.33,72.58) ; UC1.CF3 v1(148.72,89.68) UC1.CF4 ; UC1.Y35 v1(120.3,70.21) UC1.Y33 ; v1(145.95,88.67) UC1.BY5 ; UC1.C29 UC1.B29 ; UC1.AD33 v1(122.82,70.21) UC1.AD35 ; UC1.BV3 v1(143.83,89.68) UC1.BV4 ; UC1.AF30 123.93,72.61 v1(123.92,72.59) ; UC1.AT36 UC1.AT35 ; UC1.C21 UC1.B21 ; UC1.Y27 v1(120.24,74.49) ; UC1.T30 v1(117.5,72.58) ; v1(113.24,85.73) UC1.H9 ; UC1.T36 UC1.T35 ; UC1.P3 v1(116.99,89.68) UC1.P4 ; UC1.D1 v1(110.81,91.68) ; v1(108.82,71.53) 108.92,71.63 109.31,71.63 UC1.A32 ; v1(114.19,85.64) UC1.K9 ; UC1.BP3 v1(141.39,89.68) ; UC1.K27 v1(114.77,74.49) ; UC1.AB30 v1(121.15,72.58) ; UC1.BK3 v1(138.95,89.68) ; v1(111.59,81.88) UC1.F15 ; UC1.U26 UC1.V27 v1(118.41,74.49) ; v1(109.64,79.99) 109.96,80.46 UC1.B18 ; UC1.T27 v1(117.5,74.49) ; v1(112.24,85.64) UC1.G9 ; UC1.V26 UC1.W27 v1(119.33,74.49) ; UC1.Y30 v1(120.24,72.58) ; UC1.B9 v1(109.64,85.64) ; UC1.J12 v1(113.54,84.7) ; UC1.J15 v1(113.54,82.82) ; UC1.F12 v1(111.59,84.7) ; UC1.AE30 123,72.6 v1(123,72.58) ; UC1.AC27 v1(122.06,74.49) ; UC1.CC16 v1(147.59,81.16) ; v1(111.59,79.99) UC1.F18 ; v1(113.54,79.99) UC1.J18 ; UC1.AM35 v1(127.85,70.21)
  BOTTOM w0.203: v1(30.64,59.95) 30.77,59.81 UT5.G8 ; v1(155.47,68.49) 155.47,69.32 154.49,70.29 UC1.CR34 153.86,70.29 153.38,69.81 UC1.CP35 ; UT5.E5 UT5.F5 ; UT5.E5 UT5.E6 ; UT5.E5 32.11,57.65 32.11,57.48 32.44,57.15 v1(32.44,57) ; UT5.F5 UT5.F6 ; UT5.F5 UT5.G5 ; UT5.F8 UT5.F7 ; UT5.F8 v1(31.27,59.95) ; UT5.F8 UT5.G8 ; UT5.F8 UT5.E8 ; UT5.F7 UT5.G7 ; UT5.F7 UT5.F6 ; UT5.F7 UT5.E7 ; v1(29.8,57.56) 29.84,57.56 UT5.H5 ; v1(28.31,55.51) 28.77,55.97 UT5.L1 ; JEDP1.6 59.43,112.11 ; UT5.E8 UT5.E7 ; UT5.E8 UT5.D8 32.45,59.31 v1(32.74,59.31) 33.1,59.31 UT5.B8 ; UT5.E8 31.77,59.86 v1(31.86,59.95) ; UT5.E7 UT5.E6 ; UT5.E6 UT5.F6 ; UT5.G7 UT5.G8 ; UT5.G7 UT5.G6 ; 58.62,112.27 58.63,112.26 JEDP1.4 ; UC1.AM33 v1(127.85,70.21) ; UT5.F6 UT5.G6 ; UT5.A6 34.13,58.49 v1(34.26,58.36) ; 102.56,29.84 102.21,30.19 JDIMM1.172 ; UT5.B7 UT5.A7 34.04,58.99 v1(34.26,59.2) 33.97,59.49 UT5.A8 ; JDIMM1.72 75.21,30.23 74.8,29.83 v1(74.8,29.73) ; UT5.G8 UT5.H8 30.1,59.31 v1(29.8,59.31) ; CC300.2 130.24,94.18 130.39,94.04 v1(130.39,93.28) 130.39,92.53 ; UT5.G6 UT5.G5 ; UT5.G5 UT5.H4 30.27,57.17 v1(30.1,57) ; JEDP1.8 60.23,112.11 ; v1(34.23,55.87) 34.12,55.99 UT5.A1 ; JEDP1.39 72.63,112.11 ; JEDP1.15 63.03,112.11 ; 30.92,76.54 30.93,76.55 UT1.AB14
  BOTTOM w0.254: 116.47,32.25 116.71,32.01 JDIMM1.230 ; JDIMM1.103 82.96,40.07 v1(83.34,40.46) ; UC1.AD33 122.76,70.87 121.62,70.87 UC1.AB33 ; JXDP1.8 71.78,99.9 72.02,100.13 73.03,100.13 73.58,99.58 JXDP1.2 ; DT13.2 14.25,81.38 v1(14.55,81.08) ; DT13.2 v1(13.91,80.8) ; DT13.2 13.57,81.38 v1(13.28,81.08) ; v1(143.79,78.64) UC1.BU20 v1(143.69,79.48) ; PC10.2 65.86,95.14 v1(65.22,95.78) 64.88,96.12 JXDP1.31 ; JDIMM1.106 83.7,30.09 v1(83.41,29.79) ; v1(169.79,97.5) 169.46,97.17 QC4.1 ; 49.4,58.06 49.4,57.98 PR3005.1 ; 49.4,58.06 49.4,58.06 PC3009.2 ; 49.4,58.06 PC3008.2 ; 110.81,32.25 110.71,32.14 JDIMM1.206 ; RT491.2 10.84,90.26 v1(10.68,90.42) ; RT491.2 11.59,90.26 11.75,90.42 v1(11.77,90.42) ; RT491.2 v1(11.22,90.8) ; UC1.V33 119.5,70.81 119.56,70.87 120.02,70.87 120.08,70.81 UC1.Y33 ; JNGFF1.18 262.48,50.13 262.18,50.43 v1(262.18,50.88) ; JDIMM1.252 122.2,29.93 v1(121.99,29.71) ; JNGFF3.39 v1(24.38,23.93) ; 154.88,97.28 154.18,97.28 153.93,97.02 153.93,95.31 150.88,92.26 ; UC1.BT14 v1(143.04,82.84) UC1.BT15 ; v1(151.27,67.72) 151.13,67.86 151.13,68.35 151,68.48 UC1.CK37 ; v1(10.59,88.26) 10.8,88.47 RT490.2 ; CT88.2 CT90.2 22.95,88.35 v1(22.59,87.98) 22.55,87.95 RT36.2 ; QC4.4 168.46,99.37 v1(168.4,99.43) ; v1(143.69,81.16) UC1.BU16 143.32,81.63 142.76,81.63 UC1.BT16 ; v1(124.54,70.97) 124.39,70.81 UC1.AF33 ; 79.06,32.32 78.7,31.96 JDIMM1.86 ; JAPS1.14 291.95,30.26 291.6,29.9 v1(291.6,28.82) ; RT220.2 11.56,83.06 v1(11.44,83.18) ; RT220.2 v1(11.98,83.6) ; RT220.2 12.39,83.06 v1(12.58,83.24) ; v1(25.6,87.4) 25.28,87.4 25.22,87.47 24.99,87.47 RT33.2 ; DT14.2 14.25,82.95 v1(14.55,83.24) ; DT14.2 13.57,82.95 v1(13.28,83.24) ; DT14.2 v1(13.91,83.52) ; RT490.2 11.56,88.47 v1(11.77,88.26) ; RT490.2 v1(11.22,87.92) ; JNGFF3.57 19.88,23.74 v1(19.75,23.87) ; CC80.2 CC69.2 144.34,94.22 144.18,94.38 v1(143.85,94.38) ; v1(83.34,41.16) 83.96,40.55 JDIMM1.107 ; v1(12.52,90.44) 12.82,90.14 13.14,90.14 DT17.2 ; DT17.2 13.49,90.15 v1(13.79,90.44) ; DT17.2 v1(13.15,90.67) ; v1(74.81,97.76) 74.53,97.48 JXDP1.62 ; v1(294.58,32.06) 294.58,31.95 294.95,31.58 JAPS1.8 294.96,31.01 294.96,30.41 294.78,30.23 294.13,30.23 293.95,30.41 JAPS1.10 ; DT18.2 v1(13.15,88) ; DT18.2 13.49,88.58 v1(13.79,88.28) ; DT18.2 12.81,88.58 v1(12.52,88.28) ; v1(30.36,23.93) 30.38,23.91 JNGFF3.15 ; RV102.2 100.08,98.67 99.38,98.67 v1(98.94,99.12) ; RT219.2 12.35,81.27 v1(12.53,81.08) ; RT219.2 11.69,81.27 v1(11.44,81.02) ; RT219.2 v1(11.98,80.73) ; JUSH1.20 270.93,31.7 v1(271.11,31.52) 271.43,31.84 JUSH1.21 ; v1(21.47,23.93) 21.38,23.84 JNGFF3.51 ; JAPS1.12 292.95,29.22 v1(292.91,29.18) ; UC1.BT5 v1(143.17,88.67) ; UC1.BT28 v1(143.02,73.78) ; v1(181.58,82.45) 181.71,82.33 UE4.3 ; JUSH1.17 269.43,31.59 v1(269.59,31.43) ; 103.13,38.09 102.96,38.27 JDIMM1.175 ; JFPBTN1.2 v1(314.51,100.8) ; JNGFF3.27 v1(27.38,23.93) ; JNGFF3.45 v1(22.88,23.92) ; JDIMM1.99 81.96,40.47 81.65,40.78 v1(81.19,40.78) ; 68.4,32.25 68.21,32.06 JDIMM1.44 ; JNGFF2.57 281.18,57.83 v1(281.01,58) ; JNGFF3.21 28.88,23.7 v1(29.09,23.91) ; v1(49.52,61.72) PU3000.4 ; UC1.CR36 155.37,67.57 156.25,67.57 v1(156.33,67.64) ; v1(32.34,24) 31.88,23.54 JNGFF3.9 ; JNGFF3.33 v1(25.88,23.9) ; UC1.CH31 v1(150.24,71.88) ; 43.69,101.85 44.19,101.36 44.81,101.36 45.21,101.75 45.21,102.94 44.75,103.4 44.75,104.71 43.1,106.36 43.1,107.84 v1(42.83,108.11) 41.75,108.11 v1(41.24,107.6) 41.81,107.03 41.81,105.85 43.5,104.16 43.5,102.33 43.69,102.14 43.69,101.85
  BOTTOM w0.305: v1(59.36,100.36) 59.39,100.32 59.39,99.89 59.18,99.68 JXDP1.50 ; v1(259.39,54.27) 259.28,54.38 JNGFF1.1 ; v1(248.93,31.49) 249.08,31.64 JKBTP1.9 ; 111.71,29.9 JDIMM1.210 111.71,32.16 ; 68.96,40.36 JDIMM1.47 68.96,38.1 ; 112.45,40.36 JDIMM1.213 112.45,38.1 ; JNGFF1.19 v1(258.16,49.88) ; 104.45,38.1 JDIMM1.181 104.45,40.36 ; 184.65,38.1 JDIMM2.193 184.65,40.36 184.91,40.62 v1(185.13,40.62) 185.65,40.09 JDIMM2.197 185.65,38.1 ; 107.21,29.9 JDIMM1.192 ; 81.7,32.16 JDIMM1.98 81.7,29.9 ; 138.16,38.1 JDIMM2.15 138.16,40.35 137.94,40.57 137.63,40.57 137.62,40.56 v1(137.41,40.56) 137.14,40.56 136.66,40.07 JDIMM2.9 136.66,38.1 ; JDIMM2.5 135.66,40.17 135.26,40.57 v1(135.14,40.57) 135.03,40.57 134.66,40.19 JDIMM2.1 ; 101.96,40.36 JDIMM1.171 101.96,38.1 ; v1(188.25,29.83) 188.6,29.83 188.91,30.14 JDIMM2.210 188.91,32.16 ; v1(188.25,29.83) 187.91,30.17 JDIMM2.206 ; v1(188.25,29.83) 188.21,29.83 ; 105.45,40.36 JDIMM1.185 105.45,38.1 ; 189.91,32.16 JDIMM2.214 189.91,30.07 190.21,29.76 v1(190.63,29.76) 190.91,30.03 JDIMM2.218 ; 180.16,38.1 JDIMM2.175 180.16,40.14 179.85,40.44 v1(178.82,40.44) 178.82,40.33 178.86,40.33 179.16,40.03 JDIMM2.171 ; v1(293.7,82.28) 294.06,82.63 JESPI.9 ; 79.7,29.9 JDIMM1.90 79.7,32.16 ; 59.7,32.16 JDIMM1.10 v1(59.7,29.69) ; JDIMM1.201 109.45,40.36 ; 180.41,32.16 JDIMM2.176 180.41,30.02 v1(180.19,29.81) 179.82,29.81 179.41,30.22 JDIMM2.172 ; 186.65,38.1 JDIMM2.201 186.65,40.37 186.86,40.57 187.2,40.57 v1(187.23,40.54) 187.5,40.54 187.65,40.38 JDIMM2.205 187.65,38.1 ; JDIMM2.6 135.9,30.06 v1(136.24,29.72) ; 71.21,29.9 JDIMM1.56 71.21,32.16 ; 60.96,40.36 JDIMM1.15 60.96,38.1 ; JXDP1.37 v1(63.08,95.78) ; 153.66,38.1 JDIMM2.77 153.68,39.26 153.68,40.32 153.46,40.54 v1(152.89,40.54) 152.66,40.3 JDIMM2.73 152.66,38.1 ; JXDP1.13 v1(70.28,97.23) ; 62.7,29.9 JDIMM1.22 62.7,32.16 ; 159.9,32.16 JDIMM2.102 159.9,29.9 ; JDIMM2.23 140.16,40.17 139.79,40.54 v1(139.33,40.54) 139.16,40.36 JDIMM2.19 ; 196.16,38.1 JDIMM2.239 196.16,40.04 196.06,40.14 196.06,40.69 v1(196.2,40.83) ; 76.7,29.9 JDIMM1.78 76.7,32.16 ; v1(275.51,55.74) 275.18,56.08 JNGFF2.33 ; 77.7,29.9 JDIMM1.82 ; 60.7,32.16 JDIMM1.14 60.7,29.9 ; JDIMM2.48 146.41,29.99 146.6,29.79 v1(146.85,29.79) 147.11,29.79 147.41,30.09 JDIMM2.52 147.41,32.16 ; v1(136.9,29.73) JDIMM2.10 136.9,32.16 ; v1(181.51,40.45) 181.65,40.3 JDIMM2.181 181.65,38.1 ; 192.91,32.16 JDIMM2.226 192.91,29.86 v1(192.87,29.82) 192.12,29.82 191.91,30.03 JDIMM2.222 191.91,32.16 ; 145.16,38.1 JDIMM2.43 145.16,40.39 v1(144.97,40.57) 144.49,40.57 144.42,40.49 144.36,40.49 144.16,40.29 JDIMM2.39 ; JDIMM2.64 150.41,29.9 150.29,29.79 v1(149.9,29.79) 149.6,29.79 149.41,29.99 JDIMM2.60 149.41,32.16 ; 110.71,29.9 JDIMM1.206 ; 65.96,40.36 JDIMM1.35 65.96,38.1 ; 106.45,38.1 JDIMM1.189 106.45,40.36 ; 57.46,40.36 JDIMM1.1 57.05,39.23 ; JDIMM1.175 102.96,40.36 ; 141.9,32.16 JDIMM2.30 141.9,30.1 142.18,29.83 v1(142.62,29.83) 143.15,29.83 143.41,30.09 JDIMM2.36 143.41,32.16 ; 78.7,29.9 JDIMM1.86 ; v1(158.73,29.86) 158.9,30.03 JDIMM2.98 ; JNGFF1.45 256.12,43.38 255.95,43.55 v1(255.95,43.55) 255.91,43.52 255.91,42.1 256.13,41.88 JNGFF1.51 ; v1(142.73,37.16) 143.16,37.59 JDIMM2.35 ; 120.2,29.9 JDIMM1.244 120.2,32.16 ; JDIMM2.213 189.65,40.32 189.93,40.6 v1(189.93,40.62) 189.99,40.57 190.44,40.57 190.65,40.36 JDIMM2.217 190.65,38.1 ; v1(62.17,98.14) 62.78,98.75 JXDP1.38 ; 154.9,32.16 JDIMM2.82 154.9,30.09 154.6,29.79 v1(154.37,29.79) 154.21,29.79 153.9,30.09 JDIMM2.78 153.9,32.16 ; 134.66,38.1 JDIMM2.1 ; JDIMM2.1 134.25,39.23 ; 139.9,32.16 JDIMM2.22 139.9,30.03 140.21,29.73 v1(140.38,29.73) 140.71,29.73 140.9,29.93 JDIMM2.26 ; JNGFF2.51 279.68,55.99 v1(279.43,55.73) ; 199.16,38.1 JDIMM2.251 199.16,40.1 v1(198.73,40.52) 198.71,40.49 198.34,40.49 198.16,40.31 JDIMM2.247 ; 72.21,29.9 JDIMM1.60 72.21,32.16 ; 107.45,40.36 JDIMM1.193 107.45,38.1 ; 74.21,29.9 JDIMM1.68 74.21,32.16 ; 114.96,40.36 JDIMM1.223 114.96,38.1 ; JDIMM1.69 74.46,40.36 ; v1(191.86,40.62) 192.16,40.33 JDIMM2.223 192.16,38.1 ; 159.16,38.1 JDIMM2.99 159.16,40.25 v1(159.43,40.52) 159.87,40.52 160.16,40.23 JDIMM2.103 ; 67.21,29.9 JDIMM1.40 ; 63.7,29.9 JDIMM1.26 ; JDIMM2.230 193.91,29.94 193.81,29.84 v1(193.81,29.83) 194.53,29.83 194.91,30.21 JDIMM2.234 194.91,32.16 ; v1(309.31,7.87) 309.08,7.63 JLED1.1 ; 61.7,32.16 JDIMM1.18 61.7,29.9 ; 104.21,29.9 JDIMM1.180 104.21,32.16 ; 149.66,38.1 JDIMM2.61 149.66,40.15 149.27,40.54 v1(148.71,40.54) 148.66,40.48 JDIMM2.57 148.66,38.1 ; 116.96,40.36 JDIMM1.231 116.96,38.1 ; v1(59.44,97.23) 59.44,97.09 59.48,97.05 JXDP1.49 ; JDIMM2.40 144.41,29.91 144.52,29.79 v1(144.89,29.79) 145.29,29.79 145.41,29.9 JDIMM2.44 ; JDIMM2.248 198.4,30.07 v1(198.16,29.83) 197.7,29.83 197.4,30.12 JDIMM2.244 197.4,32.16 ; 103.21,32.16 JDIMM1.176 103.21,29.9 ; 117.71,29.9 JDIMM1.234 117.71,32.16 ; JXDP1.32 64.58,99.94 64.73,100.08 v1(64.73,100.2) ; JXDP1.14 69.98,98.89 69.76,98.67 68.47,98.67 68.18,98.96 JXDP1.20 68.18,99.53 67.56,100.16 v1(67.56,100.2) ; 70.21,32.16 JDIMM1.52 70.21,29.9 ; JDIMM1.5 58.46,40.36 ; 71.46,38.1 JDIMM1.57 71.46,40.36 ; 114.71,29.9 JDIMM1.222 114.71,32.16 ; JDIMM1.218 113.71,32.16 ; v1(188.45,40.52) 188.65,40.31 JDIMM2.209 188.65,38.1 ; 121.2,32.16 JDIMM1.248 121.2,29.9 ; v1(199.23,29.83) 199.4,30.01 JDIMM2.252 199.4,32.16 ; 108.21,29.9 JDIMM1.196 108.21,32.16 ; JDIMM2.185 182.65,40.13 183.1,40.57 v1(183.54,40.57) 183.65,40.46 JDIMM2.189 183.65,38.1 ; 63.96,38.1 JDIMM1.27 63.96,40.36 ; JDIMM1.247 120.96,40.36 ; 64.96,38.1 JDIMM1.31 64.96,40.36 ; 101.21,29.9 JDIMM1.168 101.21,32.16 ; 117.96,38.1 JDIMM1.235 117.96,40.36 ; v1(193.2,40.59) 193.16,40.54 JDIMM2.227 ; 138.9,32.16 JDIMM2.18 138.9,29.91 138.73,29.73 v1(138.41,29.73) 138.09,29.73 137.9,29.91 JDIMM2.14 137.9,32.16 ; 141.16,38.1 JDIMM2.27 141.16,40.46 v1(141.23,40.54) 141.71,40.54 141.75,40.49 141.95,40.49 142.16,40.29 JDIMM2.31 142.16,38.1 ; v1(255.82,38.68) 256.02,38.88 JNGFF1.63 ; JDIMM1.77 76.46,40.36 ; JXDP1.25 v1(66.68,97.23) 66.38,97.53 JXDP1.26 ; 115.96,38.1 JDIMM1.227 115.96,40.36 ; JDIMM1.85 78.46,40.36 ; 66.96,40.36 JDIMM1.39 66.96,38.1 ; v1(157.69,29.88) 157.9,30.1 JDIMM2.94 ; 69.96,38.1 JDIMM1.51 69.96,40.36 ; 69.21,29.9 JDIMM1.48 ; JDIMM1.72 75.21,32.16 ; 160.9,32.16 JDIMM2.106 160.9,29.96 161.03,29.83 ; 80.46,40.36 JDIMM1.93 80.46,38.1 ; JDIMM1.73 75.46,40.36 ; 121.96,38.1 JDIMM1.251 121.96,40.36 ; 59.46,38.1 JDIMM1.9 59.46,40.36 ; 178.41,29.9 JDIMM2.168 178.41,32.15 v1(178.63,32.38) ; 185.41,32.16 JDIMM2.196 185.41,29.91 v1(185.49,29.83) 186.78,29.83 186.91,29.95 JDIMM2.202 186.91,32.16 ; 73.21,29.9 JDIMM1.64 ; 181.41,32.16 JDIMM2.180 181.41,29.87 ; 155.66,38.1 JDIMM2.85 155.66,40.28 v1(155.91,40.54) 154.94,40.54 154.66,40.25 JDIMM2.81 154.66,38.1 ; v1(255.95,40.44) 256.01,40.38 JNGFF1.57 ; 147.16,38.1 JDIMM2.51 147.16,40.23 146.85,40.54 v1(146.75,40.54) 146.46,40.54 146.16,40.23 JDIMM2.47 146.16,38.1 ; 150.66,38.1 JDIMM2.65 150.66,40.5 v1(150.62,40.54) 151.43,40.54 151.66,40.31 JDIMM2.69 151.66,38.1 ; 155.9,32.16 JDIMM2.86 155.9,30.02 156.1,29.83 v1(156.38,29.83) 156.62,29.83 156.9,30.11 JDIMM2.90 156.9,32.16 ; v1(148.19,29.79) 148.41,30.01 JDIMM2.56 148.41,32.16 ; 197.16,40.36 JDIMM2.243 197.16,38.19 196.85,37.88 v1(196.66,37.88) ; v1(193.84,40.59) 194.16,40.27 JDIMM2.231 ; 105.21,29.9 JDIMM1.184 105.21,32.16 ; 67.96,38.1 JDIMM1.43 67.96,40.36 ; JNGFF1.7 256.35,52.88 255.78,52.31 v1(255.78,51.17) ; JDIMM1.65 73.46,40.36 ; 106.21,29.9 JDIMM1.188 106.21,32.16 ; 61.96,38.1 JDIMM1.19 61.96,40.36 ; JNGFF1.13 257.99,51.38 258.1,51.27 v1(258.26,51.27) ; 134.5,31.03 JDIMM2.2 134.9,29.9 ; 100.96,38.1 JDIMM1.167 100.96,40.36 ; JFPBTN1.8 v1(312.52,102.3) ; 156.66,38.1 JDIMM2.89 156.66,40.43 v1(156.76,40.54) 157.24,40.54 157.41,40.37 157.44,40.37 157.66,40.15 JDIMM2.93 157.66,38.1 ; v1(195.91,33.14) JDIMM2.238 195.91,29.9 ; 111.45,40.36 JDIMM1.209 111.45,38.1 ; 57.7,29.9 JDIMM1.2 57.3,31.03 ; JXDP1.8 71.78,99.14 71.39,98.75 v1(71.39,98.52) ; JDIMM2.68 151.41,30.09 151.71,29.79 v1(151.99,29.79) 152.1,29.79 152.41,30.09 JDIMM2.72 152.41,32.16 ; 58.7,29.9 JDIMM1.6 ; v1(294.93,92.11) 294.96,92.09 JDEG1.10 ; JDIMM1.23 62.96,40.36 ; JXDP1.19 v1(68.48,97.23) ; 66.21,32.16 JDIMM1.36 66.21,29.9 ; JDIMM2.184 182.41,29.99 v1(182.06,29.65) ; 184.41,32.16 JDIMM2.192 184.41,30.07 184.04,29.7 183.6,29.7 183.41,29.9 JDIMM2.188 183.41,32.16 ; JNGFF2.27 v1(273.68,57.93) ; v1(161.33,40.46) 161.16,40.28 JDIMM2.107 ; JXDP1.7 v1(72.08,97.23) ; 116.71,29.9 JDIMM1.230 ; 119.96,38.1 JDIMM1.243 119.96,40.36 ; 110.45,38.1 JDIMM1.205 110.45,40.36 ; 81.96,38.1 JDIMM1.99 ; 118.96,38.1 JDIMM1.239 ; 109.71,32.16 JDIMM1.202 109.71,29.9 ; 113.45,40.36 JDIMM1.217 113.45,38.1 ; 118.71,32.16 JDIMM1.238 118.71,29.9 ; 112.71,29.9 JDIMM1.214 ; 108.45,38.1 JDIMM1.197 ; 195.16,38.1 JDIMM2.235 195.16,40.58 v1(195.16,40.59) ; v1(262.43,31.49) JUSH1.3 ; 82.7,29.9 JDIMM1.102 ; JDIMM1.94 80.7,32.16 ; 68.21,29.9 JDIMM1.44 ; JDIMM1.252 122.2,32.16 ; 115.71,29.9 JDIMM1.226 ; 178.16,38.1 JDIMM2.167 178.16,40.28 v1(178,40.44) ; 79.46,40.36 JDIMM1.89 79.46,38.1 ; JDIMM1.61 72.46,40.36 ; 64.7,32.16 JDIMM1.30 64.7,29.9 ; JDIMM1.81 77.46,40.36
  BOTTOM w0.356: v1(55.07,61.75) 54.96,61.64 PC3001.1 54.1,61.64 PR3003.1 53.82,62.86 PC3002.2 ; v1(16.72,31.71) 16.99,31.44 CT193.2 ; v1(50.97,56.23) 50.59,56.23 50.11,56.71 PC3003.1 49.9,57.05 49.98,57.13 PR3005.1
  BOTTOM w0.381: CT99.2 CT102.1 12.39,84.34 v1(12.52,84.2) v1(12.98,83.74) ; CE53.2 179.29,80.67 v1(179.33,80.64) ; CC10.2 v1(198.8,66.22) ; v1(111.21,100.38) 111.8,99.79 RC409.1 RC413.1 ; v1(294.93,92.11) 294.12,92.92 293.99,92.92 293.83,93.09 JDEG1.12 ; v1(164.53,81.63) 164.13,82.04 CC319.2 ; JDEG1.11 292.64,86.59 v1(292.43,86.38) ; RC410.1 107.71,99.82 107.33,100.2 v1(107.33,100.38) ; DA7.1 v1(298.01,19.3) ; CT83.2 29.58,52.61 RT96.2 v1(29.21,51.63) ; v1(107.36,97.84) 107.13,97.61 RC136.2 ; v1(12.68,87.64) v1(12.1,87.64) 11.82,87.36 CT100.1 CT101.2 ; v1(35.19,73.19) 36.63,73.19 36.65,73.21 ; RC402.2 153.3,97.21 153.84,97.76 v1(154.1,97.76) ; PC906.2 41.54,42.98 v1(41.28,42.73) ; RT447.1 CT237.2 40.27,69.65 39.99,69.93 v1(39.36,69.93) ; PC3004.1 44.27,64.76 44.02,65.01 44.02,66.53 v1(43.47,67.09) ; RC446.1 161.48,76.26 161.22,75.99 v1(161.02,75.99) ; v1(98.94,99.12) 99.21,99.4 QV2.3 ; v1(34.84,83.08) 34.73,83.08 34.41,82.76 RT24.2 RT37.2 ; v1(310.27,68.38) 310.2,68.38 310.17,68.42 CR19.1 ; UC9.3 177.69,84.27 177.83,84.41 177.83,85.22 177.54,85.52 v1(177.32,85.52) ; DT40.3 v1(11.58,85.89) ; v1(109.04,98.29) 109.04,98.44 108.55,98.92 RC418.1 ; CE36.2 v3(180.17,98.16) 180.47,98.16 v1(180.85,98.55) ; v1(178.14,78.69) 178.16,78.66 178.17,78.66 178.55,78.28 UE3.3 ; RT86.2 33.45,63.66 CT76.2 ; CT71.2 32.72,52.77 RT63.2 ; v1(35.21,74.89) 36.49,74.89 36.52,74.92 ; v1(168.67,93.44) 168.58,93.53 RC844.2 ; UE5.3 175.89,77.83 175.74,77.68 v1(175.06,77.68) ; CV39.2 26.27,47.53 v1(26.3,47.56) ; RC417.1 113.42,96.58 113.72,96.27 v1(113.75,96.27) ; v1(163.77,85.59) RC521.2 ; v1(35.27,78.62) 36.47,78.62 36.52,78.67 ; v1(107.96,100.38) 108.02,100.45 RC723.1 RC411.1 ; v1(113.54,99.67) 113.43,99.79 RC415.1 ; v1(300.42,27.68) 299.92,27.68 299.45,28.15 JAPS1.19 ; v1(181.58,79.31) 181.58,79.53 182.07,80.02 CZ56.2 ; RT440.1 v1(38.42,68.57) CT1.2 ; v1(27.82,64.26) 27.82,63.53 27.96,63.39 RT103.1 27.38,63.05 27.13,62.81 CT85.2 ; UD1.3 95.97,66.59 v1(96.72,65.84) ; JAPS1.20 289.29,28.19 289.49,28.19 v1(289.5,28.18) ; v1(30.42,61.65) 30.26,61.82 RT99.1 ; 163.46,74.23 163.46,73.59 162.67,72.8 161.62,72.8 v1(160.47,71.66) ; CZ55.2 v1(184.73,77.34) ; RC416.1 111.13,95.38 v1(110.67,95.84) 110.14,95.31 RC565.2 ; v1(39.02,61.52) 39.25,61.75 39.25,62.42 40.04,63.21 UT32.2 ; v1(175.91,81.38) 176.11,81.38 176.35,81.15 CE52.2 ; CD32.2 91.24,67.45 v1(90.85,67.84) ; v1(50.97,56.23) 50.97,57.19 PQ3000.4 ; v1(112.99,94.63) 113.1,94.74 RC419.1 ; v1(46.53,47.74) 46.63,47.84 PC751.2 ; PC1137.2 v1(103.13,85.59) ; CZ53.2 183.39,79.05 183.65,79.31 v1(184.73,79.31) ; v1(161.49,96.13) 161.49,95.33 CC70.2 CC83.2 ; DA6.1 v1(302.33,19.3) ; CI7.2 v1(31.67,41.6) ; v1(137.37,94.62) 137.41,94.66 CC29.2 ; PH603.1 77.26,65.94 77.41,65.79 v1(77.41,65.53) ; CC84.2 160.65,73.58 v1(160.6,73.53)
  BOTTOM w0.457: PC2.2 241.71,37.99 242.63,37.08 v1(242.63,36.57) 242.63,36.38 242.13,35.88 240.21,35.88 PC1.2 ; CLIP13.1 32.33,86.1 v1(32.39,86.16)
  BOTTOM w0.5: 157.27,93.37 156.97,93.07 ; v1(160.41,93.37) 160.81,93.78 160.81,95.52 v1(160.85,95.56) v1(160.85,96.39) 160.66,96.58 v1(157.8,96.58) 157.8,96.64 157.49,96.95 156.73,96.95 156.15,97.53 155.45,97.53 v1(155.2,97.28)
  BOTTOM w0.508: PC1018.2 v1(122.56,100.96) ; PR103.2 186.44,92.89 v1(185.87,92.89) ; PC684.2 v1(75.3,83.13) ; JSIM1.8 v1(308.1,49.55) ; RZ25.2 307.84,8.59 v1(307.31,8.06) ; v1(162.06,96.45) 162.16,96.45 162.71,95.9 CC100.2 CC103.2 ; DA3.1 v1(304.93,49.14) ; CE32.2 188.14,80.75 v1(187.96,80.58) 187.75,80.37 DE1.2 ; CLIP15.1 14.89,68.23 14.38,68.74 v1(14.38,69.96) ; v1(308.41,3.07) 307.77,3.07 JLED1.5 ; v1(36.9,61.65) 36.73,61.82 CLIP14.1 36.73,72.02 36.84,72.13 ; JSIM1.3 v1(313.47,66.4) ; v1(28.38,66.61) 28.72,66.27 CT82.2 ; YT1.2 19.59,64.13 v1(20.14,64.13) 20.14,63.49 SHDCAN.1 ; 157.27,93.37 157.27,93.37 v1(158.97,93.37) 160.4,93.37 v1(160.41,93.37) ; v1(160.85,95.56) 160.68,95.73 YC1.4 ; UT2.4 42.71,77.25 v1(42.67,77.21) ; JESPI.12 293.88,84.13 v1(294.19,83.82) ; v1(39.26,83.74) PC806.2 PC807.2 ; UC6.4 188.68,70.66 v1(188.33,70.31) ; v1(93.51,102.07) 93.33,101.88 CV15.2 94.16,101.21 94.74,101.8 CV14.2 ; v1(168.19,82.73) 168.2,82.75 CC318.2 ; v1(24.07,59.76) 24.07,60.04 24.73,60.7 CT86.2 ; JESPI.11 293.27,78.44 v1(293.58,78.74) ; v1(100.71,101.91) 101.33,101.29 CV17.2 ; v1(162.82,85.59) 162.82,85.34 163.28,84.88 CC302.2 RC730.2 ; RC520.2 v1(169.61,87.5) ; v1(89.67,68.83) 89.67,68.45 PC1102.2 ; JKBTP1.22 243.13,29.67 242.3,30.5 v1(242.3,31.11) ; v1(171.56,66.3) 171.56,66.62 171.67,66.72 RC518.2 ; v1(108.34,98.23) 108.34,98.16 108.08,97.91 RC161.2 ; v1(193.33,84.16) 193.33,84.16 194.21,85.05 JFAN1.6 ; CZ84.2 244.47,35 243.54,34.06 v1(243.54,33.7) ; v1(172.41,71.22) 171.98,70.79 RC515.2 RC96.2 ; CC320.2 170.25,79.6 v1(170.21,79.55) ; JUSH1.28 v1(260.76,29.3) ; v1(45.23,59.6) 45.17,59.54 PC725.2 PC726.2 ; PR506.2 181.76,101.67 v1(181.04,100.96) ; v1(101.51,75.91) 100.78,75.18 PC1122.2 ; CC1476.2 168.87,76.19 v1(168.61,75.93) 168.46,75.78 RC444.1 ; v1(27.12,53.35) CT73.2 ; CZ200.2 310.28,93.34 309.8,92.86 v1(309.8,92.46) ; v1(18.1,67.68) 18.15,67.68 18.17,67.7 CT20.2 ; JASA1.1 v1(106.93,112.87) ; RC401.2 163.77,78.8 v1(164.09,78.48) ; v1(166.91,80.32) 166.91,81.2 166.55,81.55 RC745.2 ; JDIMM1.261 124.63,44.99 v1(124.07,44.43) ; RC151.2 124.85,98.59 v1(124.31,98.04) ; CC1452.2 194.07,71.76 v1(194.33,71.5) ; v1(261.25,54.68) 260.45,55.48 JNGFF1.76 ; v1(302.01,49.9) 301.62,49.9 JSIM1.7 ; CC21.2 156.14,96.65 155.9,96.89 v1(155.84,96.89) ; UT7.2 v1(22.91,91.86) ; v1(90.88,69.31) 91.46,68.73 PC1104.2 ; SW1.5 v1(303.88,25.05) ; PC1106.2 87.99,73.89 v1(87.97,73.87) ; JDIMM1.262 58.55,47.13 v1(59.33,46.36) ; v1(35.06,52.84) 35.06,53.45 CT74.2 ; PC657.2 v1(72.65,86.8) ; CLIP16.1 32.68,49.05 33.72,50.1 v1(33.85,50.1) 33.98,50.1 34.74,49.33 ; v1(89.49,110.06) 89.26,110.29 87.22,110.29 JIRTS1.19 ; CE61.2 180.99,85.06 v1(181.61,85.67) ; JSPI1.22 173,69.99 v1(172.59,70.41) ; JSPI1.21 186.7,70.02 v1(186.3,70.43) ; PC350.2 195.88,106.71 196.3,107.14 v1(196.3,107.59) ; 23.56,71.04 23.03,70.52 23.03,67.57 23.02,67.56 v1(22.04,67.56) 21.9,67.7 CT21.2 21.26,67.62 YT1.4 ; JSIM1.C5 v1(315.84,63.01) ; v1(173.36,106.75) 173.43,106.82 PC506.2 ; 28.14,85.21 28.17,85.25 CLIP13.1 ; CT84.2 30.72,52.19 v1(30.36,52.19) ; v1(106,97.91) 105.68,98.23 UV24.2 ; 17.43,66.2 17.43,70.56 17.79,70.92 21.22,70.92 ; JIRTS1.7 v1(93.12,111.01) ; JSIM1.6 299.09,53.48 v1(300.13,54.52) ; JDIMM2.261 197.87,47.13 195.41,44.67 195.41,44.05 196.03,43.43 v1(196.67,43.43) ; RV3.2 102.44,94.6 v1(102.5,94.55) ; v1(196.93,105.2) 196.33,105.8 PC360.2 ; PC1154.2 v1(92.1,86.58) ; RC2.1 v1(168.08,89.53) ; v1(257.18,30.84) 257.18,30.79 256.53,30.14 JKBTP1.21 ; RC754.2 175.72,86.28 v1(175.65,86.35) ; 154.88,97.28 v1(155.2,97.28) ; v1(37.25,43.35) 37.26,43.35 37.71,42.9 UT6.4 ; v1(308.49,67.05) 307.78,67.76 CR20.2 ; CC22.2 v1(156.14,93.77) ; v1(297.02,64.24) 297.53,63.73 JSIM1.5 ; DI2.1 v1(24.39,37.4) ; CI45.2 v1(26.61,38.09) ; CZ86.2 CZ85.2 247.29,35.26 v1(247.72,35.68) ; CV16.2 102.62,100.42 v1(102.08,99.88) ; JIRTS1.6 v1(92.32,111.01) ; v1(168.77,69.42) 169.32,69.97 RC519.2 ; JSIM1.4 v1(306.8,67.44) ; JASA1.6 v1(110.63,111.59) ; v1(191.08,76.77) 192.32,78.01 192.32,78.89 191.81,79.4 JFAN1.1 ; PC122.2 v1(41.31,23.36) ; v1(230.98,42.87) 230.21,42.87 PC743.2 ; JDIMM2.262 134.23,44.84 134.59,44.48 v1(134.59,44.45) ; CZ87.2 250.07,35.23 v1(250.07,35.74) ; PC1015.2 v1(128.78,100.96) ; YC1.2 v1(157.7,94.63) ; JRTC1.2 v1(291.47,14.01) ; PC1086.2 v1(128.82,107.4) ; JLED1.6 311.9,3.07 v1(311.25,3.07) ; v1(36.12,100.77) 36.48,101.12 PJPDC1.7 ; SW1.4 v1(303.88,29.22) ; PJPDC1.6 34.88,87.65 ; PC1014.2 v1(125.67,100.96) ; JNGFF2.76 v1(286.78,59.3) ; PC1155.2 v1(92.1,85.25) ; PC124.2 v1(38.96,23.35) ; DA2.1 v1(301.28,47.71) ; v1(33.05,51.8) CT71.2 ; PC1084.2 v1(128.78,109.71)
  vias: v1(0.43,91.31) v1(0.43,80.77) v1(0.58,79.89) v1(1.08,92.4) v1(1.21,78.79) v1(1.21,77.52) v1(1.21,76.25) v1(1.21,74.98) v1(1.21,73.71) v1(1.21,55.78) v1(1.21,54.51) v1(1.21,53.24) v1(1.21,51.97) v1(1.21,31.22) v1(1.21,29.95) v1(1.21,28.68) v1(1.21,27.41) v1(1.21,26.14) v1(1.21,24.87) v1(1.21,23.6) v1(1.21,21.87) v1(1.21,20.6) v1(1.27,19.33) v1(1.66,56.62) v1(1.79,72.88) v1(2.04,31.72) v1(2.12,28.96) v1(2.17,18.43) v1(2.28,92.82) v1(2.53,77.85) v1(2.46,51.76) v1(2.62,23.65) v1(3.14,93.14) v1(3.24,32.14) v1(3.48,79.5) v1(3.48,76.2) v1(3.5,51.02) v1(3.49,26.94) v1(3.44,18.38) v1(3.63,31.01) v1(3.66,49.76) v1(3.66,33.34) v1(3.7,25.52) v1(3.7,21.78) v1(3.83,94.3) v1(4.13,34.52) v1(4.66,48.98) v1(4.71,18.38) v1(4.78,95.95) v1(4.78,92.65) v1(5.22,72.88) v1(5.22,56.62) v1(5.38,79.5) v1(5.38,76.2) v1(5.4,34.52) v1(5.91,31) v1(5.86,25.52) v1(5.86,21.78) v1(5.98,72.88) v1(5.98,56.62) v1(5.93,48.98) v1(5.98,18.38) v1(6.07,26.91) v1(6.68,95.95) v1(6.68,92.65) v1(6.94,23.65) v1(7.25,72.88) v1(7.25,56.62) v1(7.25,18.38) v1(7.41,28.96) v1(8.52,72.88) v1(8.52,56.62) v1(8.52,18.36) v1(8.73,48.98) v1(9.1,96.22) v1(9.21,34.52) v1(9.68,17.86) v1(9.79,72.88) v1(9.79,56.62) v1(9.74,48.98) v1(10.06,96.22) v1(10.48,71.1) v1(10.48,69.83) v1(10.48,68.56) v1(10.48,67.29) v1(10.48,66.02) v1(10.48,64.75) v1(10.48,63.48) v1(10.48,62.21) v1(10.48,60.94) v1(10.48,59.67) v1(10.48,58.4) v1(10.48,34.52) v1(10.44,16.84) v1(10.61,15.58) v1(10.88,31.32) v1(10.88,30.05) v1(10.88,28.78) v1(10.88,27.51) v1(10.88,26.24) v1(11.01,48.98) v1(11.07,96.22) v1(11.24,14.48) v1(11.75,34.52) v1(12.09,96.22) v1(12.15,31.32) v1(12.15,30.05) v1(12.13,16.31) v1(12.28,48.98) v1(12.26,14.48) v1(12.77,26.54) v1(12.78,25.2) v1(12.9,32.01) v1(12.83,28.31) v1(12.95,34.09) v1(13.11,96.22) v1(13.42,31.32) v1(13.42,30.05) v1(13.46,49.47) v1(13.54,51.49) v1(13.59,19.03) v1(13.55,17.88) v1(13.93,26.12) v1(14.12,96.22) v1(14.04,53.02) v1(14.17,94.99) v1(14.17,94.42) v1(14.15,34.52) v1(14.31,51.49) v1(14.25,48.48) v1(14.25,47.21) v1(14.25,35.78) v1(14.42,32.01) v1(14.43,19.68) v1(14.69,31.32) v1(14.69,30.05) v1(14.74,94.99) v1(14.74,94.42) v1(14.76,25.83) v1(14.76,25.23) v1(15.07,51.49) v1(15.14,96.22) v1(15.31,94.99) v1(15.31,94.42) v1(15.33,25.83) v1(15.33,25.23) v1(15.88,94.99) v1(15.88,94.42) v1(15.92,29.2) v1(15.91,25.23) v1(15.94,32.01) v1(15.96,31.32) v1(15.97,27.46) v1(16.15,96.22) v1(16.45,94.99) v1(16.77,30.05) v1(16.9,86.61) v1(16.96,25.24) v1(17.17,96.22) v1(17.53,86.61) v1(18.03,58.4) v1(17.98,43.42) v1(17.98,42.4) v1(17.98,41.38) v1(17.98,37.99) v1(17.98,37.23) v1(17.98,36.47) v1(18.19,96.22) v1(18.17,77.1) v1(18.17,75.34) v1(18.16,54.58) v1(18.19,52.69) v1(18.23,73.29) v1(18.23,71.53) v1(18.42,81.02) v1(18.37,56.41) v1(19.2,96.22) v1(20.22,96.22) v1(20.32,87.54) v1(20.33,86.96) v1(20.71,83.75) v1(20.64,45.02) v1(20.64,44.38) v1(20.68,43.55) v1(20.68,42.98) v1(20.63,21.58) v1(20.83,56.25) v1(20.86,26.87) v1(21.12,38.26) v1(21.12,36.52) v1(21.22,59.94) v1(21.15,58.16) v1(21.23,96.22) v1(21.26,83.6) v1(21.27,54.35) v1(21.27,52.51) v1(21.25,43.55) v1(21.25,42.98) v1(21.34,39.82) v1(21.66,83.18) v1(21.92,96.22) v1(22.13,21.58) v1(22.42,55.62) v1(22.36,52.7) v1(22.52,30.98) v1(22.76,96.22) v1(22.88,26.24) v1(23.2,79.74) v1(23.2,78.44) v1(23.2,77.14) v1(23.22,76.5) v1(23.21,75.18) v1(23.62,58.26) v1(23.63,21.58) v1(23.85,78.44) v1(24.03,96.22) v1(24.07,56.76) v1(24.64,54.73) v1(24.83,28.25) v1(25.14,21.58) v1(25.3,96.22) v1(25.25,38.97) v1(25.8,77.14) v1(25.8,76.49) v1(25.75,33.16) v1(26.08,26.71) v1(26.17,92.64) v1(26.27,29.55) v1(26.45,80.39) v1(26.49,56.88) v1(26.49,27.87) v1(26.57,96.22) v1(26.61,67.05) v1(26.63,21.58) v1(26.74,92.64) v1(26.93,49.08) v1(26.87,36.57) v1(26.84,29.55) v1(27.31,90.1) v1(27.41,29.55) v1(27.64,26.28) v1(27.84,96.22) v1(27.88,35.49) v1(28.09,42.01) v1(28.12,21.58) v1(28.2,89.4) v1(28.4,75.19) v1(28.64,29.08) v1(29.11,96.24) v1(29.17,87.7) v1(29.64,21.58) v1(29.85,28.06) v1(30.12,97.02) v1(30.26,108.44) v1(30.26,107.17) v1(30.26,105.9) v1(30.26,104.63) v1(30.26,103.36) v1(30.26,102.09) v1(30.26,100.82) v1(30.26,99.55) v1(30.26,98.28) v1(30.91,39.81) v1(30.91,39.24) v1(30.91,38.67) v1(30.91,38.09) v1(30.91,37.52) v1(30.87,28.76) v1(31.26,109.22) v1(31.48,39.81) v1(31.48,39.24) v1(31.48,38.67) v1(31.48,38.09) v1(31.48,37.52) v1(31.44,27.62) v1(32.53,109.22) v1(32.71,28.76) v1(32.96,68.64) v1(33.8,109.34) v1(34.23,29.27) v1(34.36,65.23) v1(34.38,64.22) v1(34.38,63.63) v1(34.66,23.93) v1(34.66,23.36) v1(34.68,22.77) v1(34.68,22.18) v1(34.68,21.6) v1(34.75,110.18) v1(34.8,69.97) v1(34.82,19.68) v1(35.71,18.78) v1(35.71,17.89) v1(36.02,110.22) v1(36.89,14.48) v1(37.04,110.22) v1(37.13,16.08) v1(38.05,110.22) v1(38.17,15.87) v1(38.16,14.48) v1(38.42,79.56) v1(39.07,110.22) v1(39.12,15.87) v1(39.13,14.48) v1(40.01,28.87) v1(40.08,110.22) v1(40.4,14.48) v1(40.57,93.18) v1(40.62,28.12) v1(40.71,45.21) v1(40.96,93.59) v1(40.96,92.78) v1(41.1,110.22) v1(41.22,28.12) v1(41.54,93.59) v1(41.54,93.02) v1(41.55,92.45) v1(41.67,14.48) v1(41.81,28.12) v1(42.12,110.22) v1(42.11,93.59) v1(42.11,93.02) v1(42.11,92.45) v1(42.3,22.12) v1(42.68,93.02) v1(42.94,14.48) v1(43.64,110.22) v1(44.21,14.48) v1(44.44,28.21) v1(44.91,110.22) v1(45.48,14.48) v1(45.69,22.6) v1(45.69,21.94) v1(45.81,54.97) v1(45.81,53.85) v1(45.81,52.74) v1(46.18,110.29) v1(46.31,21.15) v1(46.75,14.48) v1(46.93,54.97) v1(46.93,53.85) v1(46.93,52.74) v1(46.89,21.15) v1(47.08,111.18) v1(47.16,112.58) v1(47.33,113.71) v1(47.46,111.95) v1(47.46,27.19) v1(47.46,26.6) v1(47.48,21.15) v1(47.71,19.38) v1(47.7,18.11) v1(47.7,16.84) v1(47.7,15.57) v1(48.04,54.97) v1(48.04,53.85) v1(48.04,52.74) v1(48.35,113.48) v1(48.35,110.42) v1(48.35,20.48) v1(48.56,74.25) v1(48.57,71.89) v1(49.25,21.38) v1(49.48,113.87) v1(50.11,113.48) v1(50.11,110.42) v1(50.65,23.8) v1(50.65,22.53) v1(50.81,25.09) v1(50.88,113.87) v1(51,111.95) v1(51.54,70.52) v1(51.54,69.21) v1(51.54,67.89) v1(51.54,66.58) v1(51.72,26.13) v1(52.4,113.87) v1(52.48,66.58) v1(52.52,60.33) v1(52.53,73.46) v1(52.53,72.88) v1(52.53,72.3) v1(52.55,70.52) v1(52.55,69.21) v1(52.55,67.89) v1(52.62,64.87) v1(52.62,64.28) v1(53.12,74.05) v1(53.12,73.46) v1(53.12,72.88) v1(53.12,72.3) v1(53.27,26.39) v1(53.56,70.52) v1(53.56,69.21) v1(53.56,67.89) v1(53.67,113.87) v1(54,112.88) v1(54.52,25.63) v1(54.87,112.88) v1(54.94,113.87) v1(54.93,97.99) v1(55.01,24.1) v1(55.01,22.93) v1(55.31,73.7) v1(55.31,73.12) v1(56.21,113.87) v1(56.23,22.58) v1(57.26,112.88) v1(57.48,113.87) v1(57.5,22.58) v1(57.6,78.61) v1(57.6,78.04) v1(57.55,24.12) v1(58.05,40.52) v1(58.17,78.61) v1(58.17,78.04) v1(58.24,87.5) v1(58.24,36.83) v1(58.24,35.31) v1(58.24,33.78) v1(58.4,26.18) v1(58.55,84.83) v1(58.75,113.87) v1(58.76,112.9) v1(58.81,87.5) v1(59.05,29.79) v1(59.25,107.56) v1(59.76,112.88) v1(60.02,113.87) v1(60.04,36.91) v1(60.04,34.62) v1(60.44,40.46) v1(60.66,26.43) v1(61.11,112.88) v1(61.06,29.73) v1(61.29,113.87) v1(61.38,80) v1(61.38,79.07) v1(61.72,25.35) v1(61.82,36.65) v1(61.82,35.13) v1(61.82,33.6) v1(61.86,40.47) v1(61.92,24.2) v1(61.91,22.92) v1(62.34,112.88) v1(62.56,113.87) v1(62.7,80) v1(62.7,79) v1(62.7,77.99) v1(63.18,29.73) v1(63.14,22.58) v1(63.74,40.52) v1(63.76,36.64) v1(63.76,35.12) v1(63.76,33.59) v1(63.83,113.87) v1(64.01,80) v1(64.01,79) v1(64.01,77.99) v1(64.41,22.58) v1(64.63,112.88) v1(64.79,60.53) v1(64.79,59.01) v1(64.79,57.49) v1(64.75,23.76) v1(64.88,25.18) v1(65.1,113.87) v1(65.32,80) v1(65.32,79) v1(65.32,77.99) v1(65.4,36.91) v1(65.4,29.79) v1(65.45,36.07) v1(65.45,33.78) v1(66.32,60.53) v1(66.32,59.01) v1(66.32,57.49) v1(66.37,113.87) v1(66.43,26.41) v1(66.83,112.88) v1(67.13,77.59) v1(67.57,80.64) v1(67.57,80.04) v1(67.64,113.87) v1(67.7,77.59) v1(67.7,77.02) v1(67.7,76.45) v1(67.69,29.79) v1(67.75,36.52) v1(67.75,35) v1(67.75,33.47) v1(67.84,60.53) v1(67.84,59.01) v1(67.84,57.49) v1(68.04,25.94) v1(68.71,24.65) v1(68.71,23.57) v1(68.91,113.87) v1(68.89,106.97) v1(68.92,40.49) v1(69.22,22.58) v1(69.28,36.54) v1(69.28,35.02) v1(69.28,33.5) v1(69.65,29.79) v1(69.95,40.51) v1(70.18,113.87) v1(70.55,112.88) v1(70.7,106.97) v1(70.78,74.11) v1(70.81,37.11) v1(70.81,34.82) v1(70.81,24.19) v1(70.74,22.58) v1(70.87,23.62) v1(70.99,29.79) v1(71.32,91.81) v1(71.25,91.18) v1(71.32,90.54) v1(71.32,89.91) v1(71.45,113.87) v1(71.47,110.05) v1(71.51,92.96) v1(71.51,92.39) v1(71.43,79.09) v1(71.43,78.52) v1(71.44,23.62) v1(71.7,112.88) v1(71.82,91.5) v1(71.82,90.93) v1(71.82,90.23) v1(72.02,23.62) v1(72.01,22.58) v1(72.08,93.02) v1(72.07,79.09) v1(72.07,78.52) v1(72.14,91.98) v1(72.33,92.51) v1(72.33,90.61) v1(72.52,29.84) v1(72.61,106.98) v1(72.72,113.87) v1(72.65,93.02) v1(72.71,91.98) v1(72.78,36.14) v1(72.78,34.62) v1(72.78,33.09) v1(72.9,92.51) v1(72.9,90.61) v1(72.86,40.49) v1(73.11,112.88) v1(73.13,69.42) v1(73.28,22.58) v1(73.41,92.96) v1(73.41,91.81) v1(73.48,90.74) v1(73.54,92.39) v1(73.67,91.27) v1(73.99,113.87) v1(73.98,92.96) v1(73.98,91.81) v1(74.06,110.05) v1(74.11,92.39) v1(74.05,90.74) v1(74.24,91.27) v1(74.36,89.91) v1(74.58,40.46) v1(74.55,22.58) v1(74.68,92.96) v1(74.68,92.39) v1(74.82,90.92) v1(74.94,35.06) v1(74.94,33.54) v1(75.08,68.81) v1(75.26,113.87) v1(75.47,91.63) v1(75.47,90.07) v1(75.82,22.58) v1(76.23,71.78) v1(76.23,70.49) v1(76.23,69.19) v1(76.15,40.51) v1(76.45,35.89) v1(76.45,33.6) v1(76.53,113.87) v1(76.59,78.8) v1(76.71,65.46) v1(76.76,91.63) v1(77.02,90.07) v1(76.94,74.14) v1(77.08,72.43) v1(77.09,22.58) v1(77.29,74.61) v1(77.27,29.73) v1(77.44,68.34) v1(77.67,74.16) v1(77.8,113.87) v1(77.73,73.61) v1(77.73,73.04) v1(77.79,71.78) v1(77.79,70.49) v1(77.79,69.19) v1(78.06,91.63) v1(78.06,90.07) v1(78.05,85.21) v1(78.05,84.64) v1(78.24,74.82) v1(78.24,74.25) v1(78.3,73.68) v1(78.3,73.11) v1(78.36,40.49) v1(78.38,37.06) v1(78.38,35.54) v1(78.38,34.01) v1(78.36,22.58) v1(78.44,88.92) v1(78.5,72.51) v1(78.62,85.21) v1(78.62,84.64) v1(78.55,78.07) v1(78.91,113.25) v1(78.91,91.28) v1(78.87,74.25) v1(78.87,73.68) v1(78.87,73.11) v1(79,72.19) v1(79.19,85.21) v1(79.19,84.64) v1(79.18,29.73) v1(79.48,112.12) v1(79.51,82.25) v1(79.44,74.25) v1(79.44,73.68) v1(79.44,73.11) v1(79.44,72.54) v1(79.63,22.58) v1(79.7,81.04) v1(79.7,79.75) v1(79.7,78.45) v1(79.76,85.05) v1(79.76,84.47) v1(79.76,83.9) v1(79.76,83.33) v1(79.76,82.76) v1(80.02,74.29) v1(80.02,73.72) v1(80.02,73.11) v1(80.02,72.54) v1(80.08,82.25) v1(80.27,74.8) v1(80.33,85.05) v1(80.33,84.47) v1(80.33,83.9) v1(80.33,83.33) v1(80.33,82.76) v1(80.55,91.36) v1(80.55,81.69) v1(80.73,111.87) v1(80.65,82.25) v1(80.71,74.29) v1(80.65,73.72) v1(80.65,73.11) v1(80.65,72.54) v1(80.91,85.05) v1(80.91,84.47) v1(80.91,83.9) v1(80.91,83.33) v1(80.91,82.76) v1(80.91,77.6) v1(80.9,22.58) v1(80.96,91.75) v1(80.97,74.8) v1(81.22,73.11) v1(81.22,72.54) v1(81.21,35.57) v1(81.26,81.04) v1(81.26,79.75) v1(81.26,78.45) v1(81.29,73.72) v1(81.35,75.56) v1(81.35,74.35) v1(81.48,91.4) v1(81.48,85.24) v1(81.48,84.66) v1(81.48,84.09) v1(81.48,83.5) v1(81.48,82.92) v1(81.48,82.35) v1(81.54,74.92) v1(81.66,112.73) v1(81.79,73.11) v1(81.79,72.54) v1(81.86,73.72) v1(81.98,74.35) v1(82.05,91.56) v1(82.05,90.99) v1(82.05,90.42) v1(82.05,89.85) v1(82.05,89.27) v1(82.05,84.64) v1(82.05,84.07) v1(82.05,83.5) v1(82.05,82.92) v1(82.05,82.35) v1(82.05,81.72) v1(82.11,74.92) v1(82.11,29.39) v1(82.17,22.58) v1(82.43,73.72) v1(82.62,91.56) v1(82.62,90.99) v1(82.62,90.42) v1(82.62,89.85) v1(82.62,89.27) v1(82.62,84.64) v1(82.62,84.07) v1(82.62,83.5) v1(82.62,82.92) v1(82.62,82.35) v1(82.7,113.47) v1(82.68,29.39) v1(83.19,91.81) v1(83.19,91.24) v1(83.19,90.67) v1(83.19,90.1) v1(83.19,89.53) v1(83.26,36.69) v1(83.26,35.17) v1(83.26,33.65) v1(83.44,22.58) v1(83.9,113.06) v1(84.29,27.43) v1(84.48,111.93) v1(84.71,22.58) v1(84.86,28) v1(85.43,27.43) v1(85.75,111.92) v1(85.9,34.88) v1(85.98,22.58) v1(86.45,112.99) v1(87.25,22.58) v1(87.36,113.87) v1(87.95,28.95) v1(88.28,35.12) v1(88.52,22.58) v1(88.63,113.87) v1(89.16,28.95) v1(89.79,22.58) v1(89.9,113.87) v1(90.04,36.78) v1(90.04,35.25) v1(90.24,99.05) v1(91.06,22.58) v1(91.17,113.87) v1(92.33,22.58) v1(92.37,35.24) v1(92.44,113.87) v1(93.6,22.58) v1(93.71,113.87) v1(93.83,29.78) v1(94.45,35.44) v1(94.87,22.58) v1(94.98,113.87) v1(95.09,85.71) v1(95.73,85.71) v1(95.77,34.68) v1(95.77,33.15) v1(96.14,22.58) v1(96.25,113.87) v1(96.36,85.71) v1(97,85.71) v1(97.35,93.97) v1(97.41,22.58) v1(97.52,113.87) v1(97.63,85.71) v1(97.92,93.97) v1(98.09,36.47) v1(98.09,34.94) v1(98.09,33.42) v1(98.21,29.71) v1(98.48,94.08) v1(98.68,22.58) v1(98.79,113.87) v1(99.07,94.42) v1(99.1,32.58) v1(100.02,85.78) v1(99.95,22.58) v1(100.06,113.87) v1(100.17,36.8) v1(100.17,35.53) v1(100.17,34.26) v1(100.65,85.78) v1(100.92,40.59) v1(101.22,22.58) v1(101.29,85.78) v1(101.33,113.87) v1(101.86,85.78) v1(102.07,74.15) v1(102.04,40.54) v1(102.29,36.25) v1(102.29,34.73) v1(102.49,22.58) v1(102.6,113.87) v1(103.39,71.16) v1(103.56,77.32) v1(103.7,29.74) v1(103.8,75.9) v1(103.8,74.64) v1(103.76,22.58) v1(103.87,113.87) v1(104.1,40.54) v1(104.06,36.58) v1(104.06,34.3) v1(104.14,109.16) v1(104.18,72.98) v1(104.69,109.16) v1(104.66,78.57) v1(104.75,71.74) v1(104.9,29.73) v1(105.03,22.58) v1(105.14,113.87) v1(105.71,75.9) v1(105.65,36.23) v1(105.65,34.71) v1(105.65,33.18) v1(106.1,77.32) v1(106.09,72.98) v1(106.3,22.58) v1(106.41,113.87) v1(106.34,74.64) v1(106.57,78.57) v1(106.98,71.7) v1(107.22,29.78) v1(107.38,40.6) v1(107.44,36.27) v1(107.44,34.74) v1(107.44,33.22) v1(107.57,22.58) v1(107.68,113.87) v1(108.02,40.6) v1(108.72,65.9) v1(108.72,64) v1(108.83,68.92) v1(108.79,36.08) v1(108.79,33.79) v1(108.84,22.58) v1(108.95,113.87) v1(108.94,90.62) v1(109.2,40.6) v1(109.3,68.3) v1(109.7,29.78) v1(109.86,91.54) v1(110.02,65.03) v1(110.02,63.12) v1(110.11,22.58) v1(110.22,113.87) v1(110.37,40.54) v1(110.34,36.27) v1(110.34,34.74) v1(110.34,33.22) v1(110.76,88.63) v1(110.99,73.54) v1(110.99,71.02) v1(111.2,69.91) v1(111.21,29.7) v1(111.33,63.9) v1(111.38,22.58) v1(111.49,113.87) v1(111.51,76.22) v1(111.72,90.51) v1(111.84,70.28) v1(112.04,74.49) v1(112.19,76.21) v1(112.49,40.57) v1(112.62,36.23) v1(112.62,34.71) v1(112.62,33.18) v1(112.64,65.08) v1(112.64,63.18) v1(112.65,22.58) v1(112.76,113.87) v1(112.83,78.25) v1(112.75,67.96) v1(112.95,74.49) v1(113.46,78.25) v1(113.63,32.37) v1(113.86,74.49) v1(113.86,73.85) v1(113.86,73.22) v1(113.86,72.58) v1(113.86,71.95) v1(113.92,22.58) v1(113.94,64.36) v1(113.94,62.45) v1(114.03,113.87) v1(114.1,78.25) v1(114.1,76.21) v1(114.19,81.88) v1(114.4,36.65) v1(114.4,34.36) v1(114.46,29.7) v1(114.54,89.68) v1(114.54,88.67) v1(114.54,88.04) v1(114.73,78.25) v1(114.73,77.34) v1(114.73,75.3) v1(115.23,59.51) v1(115.19,22.58) v1(115.3,113.87) v1(115.27,70.21) v1(115.25,63.37) v1(115.37,29.73) v1(115.46,88.04) v1(115.68,74.49) v1(115.74,40.55) v1(115.92,36.14) v1(115.92,34.62) v1(115.92,33.09) v1(116.32,95.78) v1(116.39,88.04) v1(116.46,22.58) v1(116.57,113.87) v1(116.59,74.49) v1(116.59,73.85) v1(116.59,73.22) v1(116.59,72.58) v1(116.62,40.78) v1(117.3,104.13) v1(117.31,87.4) v1(117.73,22.58) v1(117.79,70.21) v1(117.74,61.12) v1(117.84,113.87) v1(117.98,36.58) v1(117.98,35.06) v1(117.98,33.54) v1(118.23,87.4) v1(118.71,29.57) v1(119,22.58) v1(119.11,113.87) v1(119.16,87.4) v1(119.19,41.13) v1(119.33,77.06) v1(119.43,94.23) v1(119.43,92.33) v1(119.37,62.58) v1(119.37,59.41) v1(119.45,104.13) v1(119.51,36.2) v1(119.51,33.92) v1(119.64,103.56) v1(119.78,76.39) v1(120.08,87.4) v1(120.28,106.29) v1(120.28,99.88) v1(120.23,29.7) v1(120.27,22.58) v1(120.38,113.87) v1(120.71,98.28) v1(120.69,76.39) v1(120.85,106.29) v1(121.01,87.4) v1(120.96,36.78) v1(120.96,35.25) v1(120.96,33.73) v1(121.08,61.49) v1(121.03,59.37) v1(121.19,29.71) v1(121.42,106.23) v1(121.53,40.52) v1(121.54,22.58) v1(121.65,113.87) v1(121.87,96.14) v1(121.87,94.23) v1(121.87,92.25) v1(121.87,89.68) v1(121.86,26.48) v1(121.86,24.67) v1(121.93,87.4) v1(122.81,22.58) v1(122.92,113.87) v1(122.85,88.67) v1(122.9,26.48) v1(122.9,24.67) v1(122.97,74.49) v1(123.32,44.44) v1(123.43,76.39) v1(123.54,42.53) v1(123.88,77.06) v1(123.88,74.49) v1(124.08,22.58) v1(124.19,113.87) v1(124.31,96.14) v1(124.31,94.23) v1(124.31,93.6) v1(124.31,92.96) v1(124.31,92.33) v1(124.31,89.68) v1(124.34,76.39) v1(124.7,87.4) v1(124.65,63.11) v1(124.79,77.06) v1(124.79,74.49) v1(124.79,73.85) v1(124.79,73.22) v1(124.79,72.58) v1(125.25,76.39) v1(125.35,22.58) v1(125.46,113.87) v1(125.62,88.67) v1(125.63,77.06) v1(125.71,73.85) v1(126.16,76.39) v1(126.31,64.75) v1(126.31,61.58) v1(126.31,60.94) v1(126.33,41.84) v1(126.55,87.4) v1(126.62,73.85) v1(126.62,22.58) v1(126.73,113.87) v1(126.75,89.68) v1(127.47,87.4) v1(127.53,73.85) v1(127.64,96.14) v1(127.64,94.23) v1(127.64,92.33) v1(127.8,65.78) v1(127.9,97.97) v1(127.89,22.58) v1(128,113.87) v1(128.39,88.67) v1(128.44,73.85) v1(128.44,73.22) v1(128.44,72.58) v1(129.1,64.69) v1(129.1,60.88) v1(129.19,92.33) v1(129.19,89.68) v1(129.16,22.58) v1(129.27,113.87) v1(129.35,77.06) v1(129.35,73.85) v1(130.26,73.85) v1(130.26,73.22) v1(130.27,71.31) v1(130.37,70.21) v1(130.43,22.58) v1(130.54,113.87) v1(130.76,65.04) v1(130.79,62.51) v1(131.17,73.85) v1(131.63,92.33) v1(131.63,89.68) v1(131.7,22.58) v1(131.81,113.87) v1(131.9,99.07) v1(132.09,77.06) v1(132.09,73.85) v1(132.09,73.22) v1(132.09,72.58) v1(132.07,65.09) v1(132.07,61.27) v1(132.89,70.21) v1(132.98,94.66) v1(133,92.82) v1(133,73.85) v1(132.97,22.58) v1(133.08,113.87) v1(133.73,63.71) v1(133.73,61.17) v1(133.91,73.85) v1(133.91,73.22) v1(133.91,71.31) v1(134.07,92.33) v1(134.07,89.68) v1(134.24,22.58) v1(134.35,113.87) v1(134.82,73.85) v1(135.2,44.36) v1(135.18,36.07) v1(135.18,33.78) v1(135.41,70.21) v1(135.39,64.65) v1(135.39,62.75) v1(135.51,22.58) v1(135.62,113.87) v1(135.79,88.68) v1(135.79,88.04) v1(135.79,87.4) v1(135.73,73.85) v1(135.73,73.22) v1(135.73,72.58) v1(135.77,44.36) v1(136.02,96.2) v1(136.02,94.29) v1(136.37,104.68) v1(136.4,92.26) v1(136.43,108.93) v1(136.51,89.68) v1(136.53,97.75) v1(136.66,102.58) v1(136.64,77.05) v1(136.64,74.49) v1(136.64,73.85) v1(136.78,22.58) v1(136.89,113.87) v1(137.02,108.93) v1(136.97,104.68) v1(137.01,102.14) v1(137.04,76.51) v1(137.06,62.8) v1(137.24,36.65) v1(137.24,34.37) v1(137.55,73.85) v1(137.55,73.22) v1(137.53,71.27) v1(137.92,70.21) v1(138.05,22.58) v1(138.16,113.87) v1(138.16,101.85) v1(138.36,59.88) v1(138.47,73.85) v1(138.43,61.86) v1(138.56,87.4) v1(138.95,93.6) v1(139.02,36.65) v1(139.02,35.13) v1(139.02,33.6) v1(139.32,22.58) v1(139.38,73.85) v1(139.38,73.22) v1(139.38,72.58) v1(139.4,71.95) v1(139.43,113.87) v1(139.48,87.4) v1(139.73,112.01) v1(140.22,108.93) v1(140.41,87.4) v1(140.44,70.21) v1(140.59,22.58) v1(140.7,113.87) v1(140.98,101.09) v1(140.96,36.64) v1(140.96,35.12) v1(140.96,33.59) v1(141.04,99.34) v1(141.05,95.61) v1(141.33,87.4) v1(141.74,80.32) v1(141.86,22.58) v1(141.97,113.87) v1(141.96,65.28) v1(142.25,87.4) v1(142.39,77.8) v1(142.73,36.4) v1(142.73,35.64) v1(142.96,70.21) v1(143.13,22.58) v1(143.24,113.87) v1(143.51,98.55) v1(143.71,101.95) v1(143.71,100.29) v1(143.69,76.96) v1(143.96,103.44) v1(144.41,55.9) v1(144.41,54.78) v1(144.4,22.58) v1(144.51,113.87) v1(144.85,71.95) v1(145.03,87.4) v1(144.99,84.55) v1(144.99,82) v1(144.95,36.52) v1(144.95,35) v1(144.95,33.47) v1(145.47,70.28) v1(145.64,77.8) v1(145.67,22.58) v1(145.78,113.87) v1(145.76,73.85) v1(145.84,64.66) v1(145.97,102.43) v1(145.97,98.62) v1(146.48,36.54) v1(146.48,35.02) v1(146.48,33.5) v1(146.93,113.32) v1(146.87,87.4) v1(146.94,84.52) v1(146.94,22.58) v1(147.43,92.16) v1(147.59,78.64) v1(147.59,76.12) v1(147.58,73.85) v1(147.58,71.95) v1(147.8,87.4) v1(147.99,70.28) v1(148.19,113.17) v1(148.21,22.58) v1(148.24,84.52) v1(148.44,102.43) v1(148.52,36.35) v1(148.52,34.06) v1(148.72,93.6) v1(148.72,87.4) v1(148.94,84.74) v1(148.94,82.7) v1(148.94,79.58) v1(148.94,76.47) v1(149.4,73.85) v1(149.37,23.59) v1(149.46,113.17) v1(149.48,22.58) v1(149.61,24.95) v1(149.64,87.4) v1(150.13,100.69) v1(150.13,98.79) v1(150.24,36.65) v1(150.24,35.12) v1(150.24,33.6) v1(150.51,70.31) v1(150.73,113.17) v1(150.86,84.74) v1(150.86,82.7) v1(150.86,79.58) v1(150.86,76.47) v1(151.23,73.85) v1(151.26,94.42) v1(151.26,91.69) v1(151.49,87.4) v1(151.6,26.44) v1(151.89,72.19) v1(151.88,36.58) v1(151.88,35.06) v1(151.88,33.54) v1(152,113.18) v1(152.5,88.7) v1(152.43,86.4) v1(152.43,83.88) v1(152.43,81.35) v1(152.43,78.83) v1(152.43,76.31) v1(152.43,73.79) v1(153.16,113.69) v1(153.14,36.01) v1(153.14,33.73) v1(153.27,67.97) v1(153.27,25.41) v1(153.51,23.56) v1(154.01,22.58) v1(154.42,113.87) v1(154.47,92.06) v1(155.11,92.06) v1(155.58,36.55) v1(155.58,35.03) v1(155.58,33.51) v1(155.6,22.58) v1(155.69,113.87) v1(155.74,92.06) v1(155.84,73.49) v1(156.13,101.57) v1(156.13,25.15) v1(156.38,90.64) v1(156.67,77.46) v1(156.66,71.66) v1(156.85,83.84) v1(156.87,22.58) v1(156.96,113.87) v1(157.02,92.05) v1(156.94,54.71) v1(157.12,87.47) v1(157.08,85.25) v1(157.05,73.49) v1(157.43,103.82) v1(157.43,99.32) v1(157.43,27.4) v1(157.43,22.9) v1(157.95,69.07) v1(158.06,82.58) v1(158.07,70.67) v1(158.23,113.87) v1(158.57,71.66) v1(158.76,83.84) v1(158.88,73.53) v1(159.38,76.13) v1(159.5,113.87) v1(159.56,85.31) v1(159.9,36.62) v1(159.9,35.09) v1(159.98,69.04) v1(160.03,103.82) v1(160.03,99.32) v1(160.03,27.4) v1(160.03,22.9) v1(160.68,22.58) v1(160.77,113.87) v1(161.09,35.56) v1(161.09,34.03) v1(161.33,101.57) v1(161.33,25.15) v1(161.95,22.58) v1(162.04,113.87) v1(162.86,35.56) v1(162.86,34.8) v1(162.86,33.27) v1(163.22,22.58) v1(163.31,113.87) v1(164.49,22.58) v1(164.58,113.87) v1(164.7,34.48) v1(164.7,32.95) v1(165.76,22.58) v1(165.85,113.87) v1(166,40.63) v1(166.52,23.6) v1(167.12,113.87) v1(167.24,36.78) v1(167.24,35.25) v1(167.26,24.63) v1(168.32,25.32) v1(168.39,113.87) v1(169.06,37.27) v1(169.06,34.98) v1(169.57,25.58) v1(169.66,113.87) v1(170.14,29.7) v1(170.69,35.41) v1(170.69,33.89) v1(170.82,25.37) v1(170.93,113.87) v1(171.58,40.63) v1(171.58,40.06) v1(171.91,24.72) v1(172.2,113.87) v1(172.2,36.2) v1(172.2,34.67) v1(172.2,33.15) v1(172.69,23.71) v1(173.32,22.61) v1(173.47,113.87) v1(173.49,71.75) v1(173.87,112.77) v1(173.87,112.2) v1(174.06,71.75) v1(174.19,105.33) v1(174.44,112.77) v1(174.44,112.2) v1(174.59,22.58) v1(174.74,113.87) v1(175.01,112.77) v1(175.01,112.2) v1(175.29,36.21) v1(175.29,34.69) v1(175.29,33.16) v1(175.56,112.43) v1(175.86,22.58) v1(176.01,113.87) v1(175.96,112.83) v1(177.04,94.48) v1(177.04,93.85) v1(177.13,22.58) v1(177.28,113.87) v1(177.33,36.45) v1(177.33,34.68) v1(177.33,33.15) v1(178.4,22.58) v1(178.55,113.87) v1(179.36,36.84) v1(179.36,35.31) v1(179.36,33.79) v1(179.38,26.38) v1(179.67,22.58) v1(179.82,113.87) v1(179.77,106.8) v1(179.77,106.23) v1(180.28,106.55) v1(180.57,26.4) v1(181,36.38) v1(181,34.1) v1(180.94,22.58) v1(181.09,113.87) v1(181.25,94.34) v1(182.21,22.58) v1(182.36,113.87) v1(182.52,36.84) v1(182.52,35.31) v1(183.09,27.53) v1(183.16,80.88) v1(183.48,22.58) v1(183.63,113.87) v1(183.66,28.1) v1(183.66,26.96) v1(184.23,27.53) v1(184.38,36.52) v1(184.38,35) v1(184.4,24.73) v1(184.75,22.58) v1(184.9,113.87) v1(184.97,24.72) v1(185.29,99.24) v1(185.29,98.67) v1(185.29,98.04) v1(185.3,97.4) v1(185.48,88.17) v1(185.53,24.72) v1(185.93,98.67) v1(185.93,98.04) v1(185.93,97.4) v1(185.99,36.33) v1(185.99,34.04) v1(186.02,22.58) v1(186.17,113.87) v1(186.35,105.02) v1(186.48,60.31) v1(186.56,98.67) v1(186.56,98.04) v1(186.56,97.4) v1(186.92,105.02) v1(187.2,98.04) v1(187.2,97.4) v1(187.26,99.43) v1(187.29,22.58) v1(187.44,113.87) v1(187.71,36.65) v1(187.71,35.12) v1(187.71,33.6) v1(187.77,98.04) v1(187.77,97.4) v1(187.83,99.43) v1(188.56,22.58) v1(188.71,113.87) v1(189.49,24.53) v1(189.62,36.46) v1(189.62,34.93) v1(189.62,33.41) v1(189.83,22.58) v1(189.98,113.87) v1(189.93,104.96) v1(189.94,104.36) v1(190.13,24.53) v1(190.58,105) v1(190.58,104.36) v1(190.68,97.42) v1(190.7,24.53) v1(191.1,22.58) v1(191.21,105) v1(191.21,104.34) v1(191.25,113.87) v1(191.33,24.53) v1(191.7,36.65) v1(191.7,34.36) v1(191.78,75.88) v1(191.85,105) v1(191.85,104.36) v1(191.9,87.37) v1(191.97,111.03) v1(192.23,110.46) v1(192.33,108.04) v1(192.35,86.86) v1(192.37,22.58) v1(192.52,113.87) v1(192.48,105) v1(192.48,104.36) v1(192.47,88.7) v1(192.47,88.07) v1(192.47,87.43) v1(193.11,104.39) v1(193.04,97.47) v1(193.04,88.51) v1(193.04,87.88) v1(193.04,87.24) v1(193.37,36.78) v1(193.37,35.25) v1(193.37,33.73) v1(193.61,88.51) v1(193.61,87.88) v1(193.61,87.24) v1(193.64,22.58) v1(193.79,113.87) v1(193.78,74.83) v1(194.06,97.34) v1(194.14,104.06) v1(194.18,88.51) v1(194.18,87.88) v1(194.18,87.24) v1(194.24,74.52) v1(194.54,73.91) v1(194.55,23.47) v1(194.67,36.71) v1(194.67,35.19) v1(194.67,33.66) v1(194.67,25.18) v1(195.06,113.87) v1(196.33,113.87) v1(196.26,35.95) v1(196.26,33.66) v1(196.72,26.64) v1(197.15,112.9) v1(197.36,111.65) v1(197.57,110.39) v1(197.78,109.14) v1(197.86,88.07) v1(197.99,107.89) v1(197.96,90.63) v1(198.2,106.64) v1(198.16,35.25) v1(198.48,104.93) v1(198.54,25.67) v1(198.74,103.42) v1(198.91,24.49) v1(198.91,23.3) v1(198.96,102.06) v1(199.19,100.72) v1(199.42,99.37) v1(199.59,91.64) v1(199.64,98.01) v1(199.87,96.67) v1(199.96,22.58) v1(200.09,95.36) v1(200.17,86.95) v1(200.3,94.11) v1(200.51,92.86) v1(200.48,91.59) v1(201.23,22.58) v1(201.66,86.01) v1(201.87,84.76) v1(202.09,83.51) v1(202.3,82.25) v1(202.51,81) v1(202.5,22.58) v1(202.72,79.75) v1(202.93,78.5) v1(203.14,77.24) v1(203.35,75.99) v1(203.56,74.74) v1(203.77,73.49) v1(203.77,22.58) v1(203.98,72.23) v1(204.03,32.82) v1(204.24,70.99) v1(204.55,69.76) v1(204.92,68.54) v1(205.04,22.58) v1(205.34,67.34) v1(205.81,66.17) v1(206.31,22.58) v1(206.33,65.01) v1(206.91,63.88) v1(207.53,62.77) v1(207.58,22.58) v1(208.2,61.69) v1(208.29,33.59) v1(208.92,60.64) v1(208.86,33.59) v1(208.85,22.58) v1(209.43,33.59) v1(209.68,59.63) v1(210,33.59) v1(210.12,22.58) v1(210.49,58.64) v1(210.57,33.59) v1(211.14,33.59) v1(211.33,57.7) v1(211.39,22.58) v1(211.72,33.59) v1(212.22,56.79) v1(212.66,22.58) v1(213.15,55.93) v1(213.93,22.58) v1(214.12,55.1) v1(215.12,54.32) v1(215.2,22.58) v1(215.5,24.85) v1(216.15,53.58) v1(216.47,22.58) v1(217.22,52.89) v1(217.74,22.58) v1(218.31,52.25) v1(218.53,24.53) v1(219.01,22.58) v1(219.11,24.53) v1(219.43,51.65) v1(219.68,24.53) v1(219.79,25.09) v1(220.07,49.84) v1(220.29,24.53) v1(220.28,22.58) v1(220.58,51.11) v1(220.9,24.53) v1(221.43,36.9) v1(221.58,25.14) v1(221.53,24.54) v1(221.55,22.58) v1(221.75,50.61) v1(222,36.9) v1(222.4,28.55) v1(222.4,26.92) v1(222.57,36.9) v1(222.82,22.58) v1(222.94,50.17) v1(223.15,36.9) v1(223.21,25.34) v1(223.72,36.9) v1(223.72,26.22) v1(223.72,25.65) v1(223.72,25.08) v1(224.09,22.58) v1(224.29,26.22) v1(224.29,25.65) v1(224.36,49.7) v1(225.36,22.58) v1(225.74,49.35) v1(226.63,22.58) v1(226.64,33.78) v1(226.99,49.07) v1(227.21,33.78) v1(227.78,33.78) v1(227.9,22.58) v1(228.24,48.86) v1(228.42,33.78) v1(229.17,22.58) v1(229.46,48.71) v1(230.38,48.64) v1(230.44,22.58) v1(231.65,48.58) v1(231.71,22.58) v1(232.92,48.57) v1(232.98,22.58) v1(233.09,28.12) v1(233.09,27.53) v1(233.09,26.96) v1(233.34,26.32) v1(233.69,27.45) v1(233.69,26.88) v1(233.91,26.32) v1(234.19,48.62) v1(234.26,28.15) v1(234.26,27.55) v1(234.26,26.98) v1(234.25,22.58) v1(234.82,44.74) v1(234.83,28.12) v1(234.83,27.55) v1(235.46,48.73) v1(235.52,22.58) v1(235.95,25.05) v1(235.95,23.78) v1(236.16,26.3) v1(236.52,44.65) v1(236.72,48.89) v1(237.24,26.97) v1(237.97,49.1) v1(238.32,44.64) v1(238.51,26.98) v1(239.21,49.37) v1(239.78,26.98) v1(240.44,49.7) v1(241.05,26.98) v1(241.65,50.08) v1(242.32,26.98) v1(242.84,50.51) v1(243.59,26.98) v1(243.8,43.92) v1(244.02,50.99) v1(244.86,26.98) v1(245.17,51.52) v1(245.85,31.36) v1(246.13,26.98) v1(246.3,52.11) v1(247.4,52.74) v1(247.4,26.98) v1(248.47,53.42) v1(248.67,26.98) v1(249.51,54.15) v1(249.94,26.98) v1(250.52,54.92) v1(251.21,26.98) v1(251.5,55.74) v1(252.2,31.56) v1(252.43,56.6) v1(252.48,26.98) v1(252.86,31.55) v1(253.33,57.49) v1(253.75,26.98) v1(254.04,35.71) v1(254.19,58.43) v1(254.99,33.53) v1(255.02,26.98) v1(255.14,59.56) v1(255.78,35.74) v1(255.9,37.17) v1(255.99,60.21) v1(256.29,26.98) v1(256.43,47.16) v1(257.35,59.48) v1(257.56,26.98) v1(258.11,64.09) v1(258.13,46.22) v1(258.13,45.23) v1(258.27,36.54) v1(258.57,65.09) v1(258.64,40.18) v1(258.83,26.98) v1(259.02,63.46) v1(259.09,66.25) v1(259.29,38.78) v1(259.51,60.15) v1(259.55,67.43) v1(259.59,34.66) v1(259.97,68.63) v1(259.97,62.21) v1(260.09,39.58) v1(260.1,26.98) v1(260.33,69.85) v1(260.64,71.08) v1(260.9,72.33) v1(261.1,73.58) v1(261.33,76.11) v1(261.24,74.84) v1(261.36,110.4) v1(261.36,109.13) v1(261.36,107.86) v1(261.36,106.59) v1(261.36,105.32) v1(261.36,104.05) v1(261.36,102.78) v1(261.36,101.51) v1(261.36,100.24) v1(261.36,98.97) v1(261.36,97.7) v1(261.36,96.43) v1(261.36,95.16) v1(261.36,93.89) v1(261.36,92.62) v1(261.36,91.35) v1(261.36,90.08) v1(261.36,88.81) v1(261.36,87.54) v1(261.36,86.27) v1(261.36,85) v1(261.36,83.73) v1(261.36,82.46) v1(261.36,81.19) v1(261.36,79.92) v1(261.36,78.65) v1(261.36,77.38) v1(261.37,26.98) v1(262.64,26.98) v1(262.82,111.55) v1(262.96,112.77) v1(263.45,52.24) v1(263.48,33.68) v1(263.78,113.2) v1(263.78,109.9) v1(263.91,26.98) v1(264.53,57.12) v1(264.92,57.54) v1(265.15,58.05) v1(265.18,26.98) v1(265.68,113.2) v1(265.68,109.9) v1(265.71,38.07) v1(266.26,38.98) v1(266.45,26.98) v1(266.54,43.29) v1(266.63,111.55) v1(266.79,38.43) v1(267.06,65.42) v1(267.35,65.91) v1(267.4,28.71) v1(267.72,55.71) v1(267.72,26.98) v1(267.86,113.42) v1(267.99,28.71) v1(268.14,65.45) v1(268.5,39.38) v1(268.55,28.71) v1(268.99,26.98) v1(269.13,113.42) v1(269.51,57.93) v1(270.3,112.91) v1(270.3,111.64) v1(270.26,26.98) v1(270.65,110.21) v1(271.53,26.98) v1(271.66,107.33) v1(271.66,102.25) v1(271.95,60.2) v1(271.95,59.62) v1(272.16,109.72) v1(272.8,26.98) v1(273.48,109.72) v1(273.69,65.91) v1(274.13,65.53) v1(274.07,26.98) v1(274.2,107.33) v1(274.52,28.63) v1(274.8,109.72) v1(275.34,26.98) v1(276.12,109.72) v1(276.61,26.98) v1(276.68,55.71) v1(276.74,107.33) v1(277.44,109.78) v1(277.88,26.97) v1(278.38,110.67) v1(278.39,48.88) v1(278.46,112.01) v1(278.96,48.88) v1(278.95,26.3) v1(279.08,113.42) v1(279.16,25.05) v1(279.16,23.78) v1(279.28,107.33) v1(279.35,42.41) v1(279.35,40.44) v1(279.35,38.47) v1(279.6,30.85) v1(279.59,22.58) v1(280.04,30.41) v1(280.4,113.42) v1(281.32,42.41) v1(281.32,40.44) v1(281.32,38.47) v1(281.25,23.87) v1(281.25,22.6) v1(281.61,25.46) v1(281.72,113.42) v1(281.82,107.33) v1(281.82,104.79) v1(281.82,102.25) v1(283.04,113.42) v1(283.17,59.77) v1(283.29,42.41) v1(283.29,40.44) v1(283.28,26.43) v1(284.06,59.77) v1(284.36,107.33) v1(284.36,104.79) v1(284.36,102.25) v1(284.5,112.89) v1(284.5,111.57) v1(284.78,110.3) v1(284.94,25.83) v1(285.25,90.35) v1(285.61,24.15) v1(285.64,109.75) v1(285.71,22.5) v1(285.82,90.35) v1(286.61,21.79) v1(286.9,107.33) v1(286.9,104.79) v1(286.9,102.25) v1(286.95,109.72) v1(287.5,20.89) v1(288.27,109.72) v1(288.49,65.66) v1(288.47,19.76) v1(288.56,18.7) v1(288.56,17.43) v1(288.56,16.16) v1(288.56,14.89) v1(288.56,13.62) v1(288.56,12.35) v1(288.56,11.08) v1(288.56,9.81) v1(288.56,8.54) v1(288.56,7.27) v1(288.56,6) v1(288.56,4.73) v1(288.56,3.46) v1(288.56,2.19) v1(288.57,0.92) v1(289.44,107.33) v1(289.44,104.79) v1(289.44,102.25) v1(289.59,109.72) v1(289.74,0.43) v1(290.65,81.4) v1(290.86,109.72) v1(291.03,61.59) v1(291.01,0.43) v1(291.08,62.17) v1(291.15,4.39) v1(291.15,3.12) v1(291.15,1.85) v1(291.27,67.66) v1(291.27,65.42) v1(291.28,32.51) v1(291.92,32.51) v1(291.98,107.33) v1(291.98,104.79) v1(291.98,102.25) v1(292.13,109.72) v1(292.28,0.43) v1(292.38,66.54) v1(292.42,4.39) v1(292.42,3.12) v1(292.42,1.85) v1(292.59,16.16) v1(292.59,14.89) v1(292.59,13.62) v1(292.64,6.52) v1(292.64,5.76) v1(293.22,76.31) v1(293.24,16.28) v1(293.24,12.84) v1(293.4,109.72) v1(293.37,60.24) v1(293.5,67.66) v1(293.5,65.42) v1(293.5,59.65) v1(293.55,0.43) v1(293.69,4.39) v1(293.69,3.12) v1(293.69,1.85) v1(293.84,76.93) v1(293.84,75.69) v1(293.86,16.16) v1(293.86,14.89) v1(293.86,13.62) v1(294.13,21.56) v1(294.52,107.33) v1(294.52,104.79) v1(294.52,102.25) v1(294.46,76.31) v1(294.63,51.19) v1(294.67,109.72) v1(294.82,0.43) v1(294.96,4.39) v1(294.96,3.12) v1(294.96,1.85) v1(295.28,72.64) v1(295.28,72.07) v1(295.94,109.72) v1(296.09,0.43) v1(296.23,4.39) v1(296.23,3.12) v1(296.23,1.85) v1(296.61,75.24) v1(296.92,102.55) v1(296.92,99.55) v1(297.06,107.33) v1(297.06,104.79) v1(297.12,88.32) v1(297.19,86.61) v1(297.17,83.8) v1(297.36,0.43) v1(297.52,109.72) v1(297.5,4.39) v1(297.5,3.12) v1(297.5,1.85) v1(297.99,97.94) v1(297.95,71.18) v1(298.01,32.58) v1(298.1,105.75) v1(298.1,101.23) v1(298.23,103.98) v1(298.63,0.43) v1(298.77,4.39) v1(298.77,3.12) v1(298.77,1.85) v1(298.84,109.72) v1(298.91,98.81) v1(298.96,69.97) v1(299.15,68.26) v1(299.28,32.38) v1(299.57,96.37) v1(299.69,102.45) v1(299.85,87.87) v1(299.85,87.08) v1(299.85,86.32) v1(299.85,83.5) v1(299.85,82.73) v1(299.85,82) v1(299.9,0.43) v1(300.07,107.37) v1(300.04,4.39) v1(300.04,3.12) v1(300.04,1.85) v1(300.16,109.72) v1(300.3,31.76) v1(300.53,106.12) v1(300.59,97.15) v1(300.64,104.1) v1(300.64,100.8) v1(300.69,30.35) v1(300.81,56.19) v1(301.17,0.43) v1(301.31,3.12) v1(301.31,1.85) v1(301.48,109.72) v1(301.59,69.58) v1(301.63,31.22) v1(301.8,29.31) v1(302.22,69.58) v1(302.44,0.43) v1(302.54,104.1) v1(302.54,100.8) v1(302.58,3.12) v1(302.58,1.85) v1(302.66,107.39) v1(302.65,92.56) v1(302.8,109.72) v1(302.86,69.58) v1(302.89,31.2) v1(302.86,30.05) v1(302.98,73.44) v1(303.16,106.13) v1(303.22,90.19) v1(303.21,88.92) v1(303.21,77.49) v1(303.14,29.09) v1(303.23,76.22) v1(303.42,92.56) v1(303.5,102.45) v1(303.71,0.43) v1(303.74,73.44) v1(304.16,109.72) v1(304.18,92.56) v1(304.16,90.96) v1(304.15,10.36) v1(304.29,75.51) v1(304.25,69.58) v1(304.5,73.44) v1(304.89,69.58) v1(304.98,0.43) v1(305.07,28.99) v1(305.07,27.72) v1(305.07,26.45) v1(305.07,25.18) v1(305.07,23.91) v1(305.15,95.27) v1(305.23,31.12) v1(305.4,90.46) v1(305.46,109.71) v1(305.46,76) v1(305.62,8.16) v1(306.25,0.43) v1(306.37,30.31) v1(306.36,28.99) v1(306.36,27.72) v1(306.36,26.45) v1(306.36,25.18) v1(306.36,23.91) v1(306.71,105.59) v1(306.7,96.03) v1(306.67,90.46) v1(306.73,76) v1(307.05,98.53) v1(307.21,108.67) v1(307.52,0.43) v1(307.94,90.46) v1(308,76) v1(308.15,108.67) v1(308.41,4.08) v1(308.79,0.43) v1(309.1,98.25) v1(309.42,108.67) v1(309.43,4.08) v1(309.43,3.07) v1(309.5,14.55) v1(309.84,15.77) v1(309.96,13.36) v1(310.06,0.43) v1(310.52,23.65) v1(310.44,4.08) v1(310.44,3.07) v1(310.78,28.95) v1(310.83,16.56) v1(311.03,12.68) v1(311.19,108.67) v1(311.25,4.08) v1(311.33,0.43) v1(311.49,97.66) v1(311.63,101.44) v1(311.59,95.07) v1(311.6,70.85) v1(311.6,25.52) v1(311.6,21.78) v1(311.73,30.6) v1(311.73,27.3) v1(311.75,90.46) v1(311.81,76) v1(312.1,16.6) v1(312.3,12.77) v1(312.49,98.97) v1(312.55,72.5) v1(312.55,69.2) v1(312.6,0.43) v1(312.72,108.67) v1(313.01,92.37) v1(313.02,90.46) v1(313.08,76) v1(313.24,16.03) v1(313.53,13.08) v1(313.63,30.6) v1(313.63,27.3) v1(313.8,74.95) v1(313.76,25.52) v1(313.76,21.78) v1(313.91,91.4) v1(313.86,0.54) v1(313.96,73.96) v1(313.98,48.74) v1(314.08,52.64) v1(314.08,20.52) v1(314.1,19.5) v1(314.1,18.23) v1(314.1,16.96) v1(314.1,11.95) v1(314.1,10.68) v1(314.1,9.41) v1(314.1,8.14) v1(314.1,6.87) v1(314.1,5.6) v1(314.1,4.33) v1(314.1,3.06) v1(314.1,1.79) v1(314.5,108.67) v1(314.45,72.5) v1(314.45,69.2) v1(314.59,28.95) v1(314.76,21.86) v1(314.9,94.91) v1(314.84,23.65) v1(315.03,92.26) v1(315.41,70.85) v1(315.53,73.2) v1(315.73,108.37) v1(315.8,107.1) v1(315.8,105.7) v1(315.8,104.56) v1(315.8,103.29) v1(315.8,102.02) v1(315.8,100.75) v1(315.8,99.48) v1(315.8,98.21) v1(315.8,72.04) v1(315.8,69.88) v1(315.8,68.23) v1(315.86,97.06) v1(315.99,22.18) v1(316.04,66.98) v1(316.11,52) v1(316.19,92.59) v1(316.25,96.1) v1(316.25,94.46) v1(316.25,31.04) v1(316.25,29.77) v1(316.25,28.5) v1(316.25,27.23) v1(316.25,25.96) v1(316.25,24.69) v1(316.25,23.42) v1(317.07,66.23) v1(317.07,63.69) v1(317.07,62.42) v1(317.07,61.15) v1(317.07,59.88) v1(317.07,58.61) v1(317.07,57.34) v1(317.07,56.07) v1(317.07,54.8) v1(317.07,53.53) v1(317.07,52.26) v3(45.59,72.27) v3(52.11,74.29) v3(54.29,64.51) v3(62.43,76.89) v3(80.69,75.6) v3(80.94,90.01) v3(81.67,77.62) v3(97.59,94.74) v3(108.65,98.72) v3(119.86,105.14) v3(120.14,102.69) v3(120.52,107.66) v3(122.6,109.57) v3(122.59,107.36) v3(137.78,105.44) v3(137.8,103.45) v3(182.29,23.96) v3(190.7,41.6) v3(191.89,85.41) v3(192.02,109.62) v3(191.99,106.57) v3(192.82,103.92) v3(221.8,37.78) v3(222.27,24.58) v3(225.24,37.97) v3(266.92,107.41) v3(299.12,95.28)
