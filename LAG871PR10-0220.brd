# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_P4: length 233.4
  TOP w0.104: UR1.5 287.65,66.34 287.41,66.1 287.41,65.71 v1(287.29,65.59)
  IN4 w0.094: v1(132.98,95.3) 133.3,95.61 133.3,95.65 133.39,95.75 134.26,95.75 134.46,95.95 134.46,97.85 134.86,98.25 134.86,101.87 134.58,102.15 134.58,105.56 135.88,106.86 135.88,110.92 137.13,112.17 138.18,112.17 139.1,111.25 142.31,111.25 142.56,111.5 142.56,111.82 142.95,112.2 145.64,112.2 147.16,110.68 148.86,110.68 149.55,111.37 152.87,111.37 153.46,111.97 157.25,111.97 157.65,112.36 166.14,112.36 170.55,107.95 174.81,107.95 184.05,98.72 184.05,96.78 184.74,96.09 184.74,95.17 187.85,92.06 187.85,88.54 190.02,86.36 190.44,86.36 192.74,84.06 192.74,83.87 194.06,82.55 194.06,82.32 201.58,74.8 201.58,66.2 206.2,61.58 206.2,60.68 216.53,50.35 218.48,50.35 221.35,47.48 224.43,47.48 224.85,47.06 241.39,47.06 242.48,48.15 248.51,48.15 251.12,50.76 252.59,50.76 257.59,55.76 259.26,55.76 262.59,59.08 262.59,64.44 264.75,66.6 278.09,66.6 278.21,66.73 279.52,66.73 279.72,66.93 279.72,68.31 280.77,69.36 285.36,69.36 286.4,68.32 286.4,67.74 287.56,66.58 287.56,65.86 v1(287.29,65.59)
  BOTTOM w0.076: UC1.BA2 133.1,91.18 133.1,92.42 133.74,93.06 133.74,94.54 v1(132.98,95.3)
CLK_PCIE_P5: length 181.1
  IN4 w0.094: v1(136.32,93.6) 136.13,93.4 135.28,93.4 134.95,93.07 134.95,91.76 134.51,91.33 132.67,91.33 132.46,91.54 132.46,97.03 133.17,97.74 133.17,100.64 132.77,101.04 132.77,109.1 128.79,113.08 110.07,113.08 109.48,112.49 106.77,112.49 106.18,113.08 88.15,113.08 86.15,111.08 79.35,111.08 78.29,112.15 53.74,112.15 47,105.41 47,104.94 45.91,103.85 45.38,103.85 43.88,102.36 38.93,102.36 36.02,99.44 36.02,93.75 33.89,91.63 29.15,91.63 28.89,91.36 24.76,91.36 22.98,89.58 21.96,89.58 21.1,88.72 21.1,84.93 19.51,83.35 19.51,80.56 20.19,79.88 20.96,79.88 21.66,79.17 21.66,78.41 22.64,77.43 22.64,73.66 23.41,72.89 28.63,72.89 28.83,73.09 28.83,73.65 v1(29.07,73.89)
  BOTTOM w0.076: v1(136.32,93.6) 136.07,93.34 135.86,93.34 135.69,93.17 135.69,91.42 135.59,91.33 135.59,90.86 135.85,90.6 UC1.BE2
  BOTTOM w0.094: UT1.V19 29.38,74.2 v1(29.07,73.89)
CLK_TP_SIO_I2C_DAT: length 119
  TOP w0.127: v1(254.31,31.55) 254.81,31.05 v2(254.81,30.45) 254.81,30.32 254.63,30.14 RZ23.2 253.9,29.79 253.96,29.73 CZ81.1 254.39,28.95 254.43,28.91 RZ346.2 ; v1(275.48,85.39) 275.48,85.29 UE1.E10
  IN1 w0.084: v1(275.48,85.39) 275.9,85.81 276.37,85.81 276.59,86.03 276.59,86.23 276.98,86.63 279.58,86.63 279.92,86.98 282.99,86.98 283.53,86.43 285.19,86.43 285.57,86.81 286.34,86.81 286.81,87.28 288.26,87.28 288.45,87.09 289.96,87.09 290.75,87.88 292.34,87.88 293.03,88.57 294.27,88.57 295.46,87.38 295.46,85.08 294.96,84.57 294.96,83.25 295.49,82.72 295.49,76.86 295.6,76.74 295.6,73.66 294.91,72.96 294.91,71.65 295.79,70.77 295.79,69.86 294.93,69 294.93,67.72 295.51,67.14 295.51,62.65 294.83,61.98 294.83,57.86 295.7,56.99 295.7,53.54 294.47,52.32 281.78,52.32 279.72,50.26 279.72,48.44 278.96,47.68 278.28,47.68 277.17,46.58 277.17,46.1 276.07,44.99 275.57,44.99 274.4,43.82 274.4,39.81 273.39,38.79 273.39,37.6 271.2,35.41 269.23,35.41 268.58,34.76 267.42,34.76 267.03,34.37 265.14,34.37 263.86,33.09 261.16,33.09 260.33,32.25 259.71,32.25 259.22,32.74 257.09,32.74 255.9,31.55 v1(254.31,31.55)
CLK_TP_SIO_R: length 5.8
  TOP w0.127: RZ19.2 253.26,31.37 RZ23.1 253.56,30.73 253.54,30.74 CZ89.1 v2(252.1,30.74) 251.97,30.74 251.64,31.08 v1(251.64,31.55)
  BOTTOM w0.127: JKBTP1.14 251.58,31.68 251.64,31.62 v1(251.64,31.55)
CLKREQ_CNV#: length 156
  TOP w0.127: RZ1385.1 265.49,51.23 265.78,50.93 v1(265.78,50.43) 265.71,50.36 v2(264.98,50.36) ; v1(176.47,66.12) RC752.2
  IN4 w0.076: v1(150.31,73.22) 150.76,72.78 150.76,71.18 151.01,70.92
  IN4 w0.084: v1(265.78,50.43) 264,50.43 262.72,49.16 261.39,49.16 258.95,46.72 258.95,43.04 261.18,40.81 261.18,39.44 259,37.26 258.34,37.26 255.9,34.82 252.99,34.82 252.46,34.28 250.2,34.28 249.98,34.5 246.49,34.5 246.06,34.08 239.25,34.08 238.5,34.82 230.61,34.82 230.13,34.33 224.92,34.33 224.44,34.82 221.05,34.82 219.72,36.14 216.45,36.14 213.69,38.91 211.79,38.91 208.91,41.78 208.55,41.78 198.83,51.5 195.28,51.5 194.86,51.07 192.34,51.07 184.85,58.56 184.85,61.86 181.63,65.08 181.63,66.32 181.35,66.59 177.13,66.59 176.66,66.12 v1(176.47,66.12)
  IN4 w0.102: 151.01,70.92 155.2,70.92 156.28,69.85 156.28,69.85 156.42,69.7 156.74,69.7 157.28,69.16 157.28,68.84 158.47,67.66 158.54,67.66 161.51,64.7 162.26,64.7 162.86,65.29 169.05,65.29 169.18,65.16 172.04,65.16 172.38,65.5 173.79,65.5 174.4,66.11 176.46,66.11 v1(176.47,66.12)
  BOTTOM w0.089: UC1.CH29 v1(150.31,73.22)
CLKREQ_CNV#_R: length 3.8
  TOP w0.127: RZ1385.2 v2(263.48,51.23) 263.1,51.23 v1(262.74,50.86)
  BOTTOM w0.127: JNGFF1.14 263.01,51.13 v1(262.74,50.86)
CLKREQ_PCIE#0: length 142
  TOP w0.104: RC297.1 178.68,67.97 v1(178.68,68.53)
  IN1 w0.094: v1(178.68,68.53) 178.68,68.19 179.57,67.3 181.91,67.3 185.26,63.94 185.26,63.48 187.61,61.13 187.61,57.89 188.99,56.51 190.3,56.51 191.49,55.32 192.4,55.32 193.8,53.92 198.48,53.92 214.52,37.88 217.1,37.88 219.77,35.22 229.59,35.22 230.37,36 239.65,36 240.14,35.51 246.24,35.51 246.87,36.14 251.74,36.14 252.77,35.11 255.91,35.11 256.13,35.33 256.73,35.33 257.42,36.02 258.45,36.02 259.59,37.16 264.58,37.16 265.02,37.6 268.33,37.6 270.85,40.12 270.85,41.4 271.52,42.07 271.52,44.21 273.93,46.62 274.64,46.62 275.51,47.49 275.72,47.49 276.13,47.9 276.13,49.11 278.24,51.22 278.24,53.25 279.46,54.47 279.46,55.23 279.8,55.58 279.8,57.85 v1(279.01,58.64)
  BOTTOM w0.104: JNGFF2.52 279.93,62.39 278.76,61.22 278.76,59.69 279.03,59.43 279.03,58.78 279.01,58.77 v1(279.01,58.64)
CLKREQ_PCIE#0_R: length 37.3
  TOP w0.104: RC297.2 v1(178.97,66.12) RC189.1
  IN4 w0.094: v1(178.97,66.12) 177.69,64.83 176.63,64.83 176.11,64.3 174.4,64.3 173.74,63.64 172.51,63.64 172.27,63.88 168.66,63.88 168.52,64.01 163.39,64.01 162.75,63.38 159.82,63.38 153.64,69.56 150.18,69.56 149.66,70.09 149.66,70.81 149.4,71.06 v1(149.4,71.31)
  BOTTOM w0.089: UC1.CF32 149.37,71.33 v1(149.4,71.31)
CLKREQ_PCIE#1: length 94.2
  TOP w0.104: v1(181.6,69.21) 181.32,68.93 RC526.1
  IN1 w0.094: v1(254.85,40.29) 254.85,40.08 253.69,38.92 247.59,38.92 246.4,37.73 243.95,37.73 243.58,38.09 229.78,38.09 229.15,37.47 220.31,37.47 217.93,39.85 215.39,39.85 199.61,55.63 194.35,55.63 193.03,56.94 192.14,56.94 190.54,58.54 190.54,61.31 182.57,69.28 181.67,69.28 v1(181.6,69.21)
  BOTTOM w0.104: v1(254.85,40.29) 254.85,40.65 255.58,41.38 JNGFF1.53
CLKREQ_PCIE#1_R: length 42.5
  TOP w0.104: RC526.2 181.18,66.95 v1(181.18,66.12) 181.18,65.8 181.45,65.54 RC522.1
  IN4 w0.094: v1(148.49,71.31) 148.49,71.06 148.97,70.58 148.97,69.8 150.08,68.69 153.1,68.69 156.15,65.64 156.15,65.13 159.26,62.03 163.31,62.03 163.94,62.67 166.4,62.67 167.34,61.72 170.77,61.72 171.08,62.03 175.52,62.03 176.19,62.7 177.27,62.7 177.62,63.05 178.09,63.05 181.16,66.12 v1(181.18,66.12)
  BOTTOM w0.089: UC1.CE32 v1(148.49,71.31)
CLKREQ_PCIE#2: length 261.1
  TOP w0.104: v1(177.32,68.53) 177.32,68.15 177.32,68.15 RC727.1
  IN1 w0.094: v1(40.65,34.09) 41.26,34.09 43.27,32.08 43.27,30.6 44.59,29.28 48.21,29.28 48.71,28.78 56.94,28.78 58.33,30.17 68.41,30.17 69.07,29.5 69.07,28.84 70.04,27.87 70.04,26.19 71.05,25.19 73.19,25.19 74.62,23.76 116.18,23.76 118.09,25.68 146.16,25.68 148.96,28.48 160.2,28.48 161.31,27.38 161.72,27.38 162.4,26.69 165.36,26.69 166.05,27.38 172.31,27.38 172.69,27.76 176.37,27.76 180.36,23.76 186.16,23.76 190.7,28.3 191.77,28.3 192.63,29.16 202.14,29.16 202.23,29.26 202.23,31.23 202.55,31.56 203.3,31.56 204.89,33.15 204.89,34.01 204.21,34.69 204.21,36.95 204.33,37.07 204.33,40.86 198.23,46.96 196.8,46.96 194.35,49.41 192.47,49.41 190.75,51.13 189.44,51.13 182.28,58.29 181.23,58.29 180.93,58.59 180.93,60.21 180.71,60.43 179.91,60.43 178.83,61.51 178.83,64.83 177.74,65.91 177.74,66.92 177.32,67.35 v1(177.32,68.53)
  IN4 w0.094: JNGFF3.52 21.13,21.71 22.03,22.61 22.03,24.4 24.22,26.59 24.22,28.17 27.22,31.17 35.88,31.17 38.8,34.09 v1(40.65,34.09)
CLKREQ_PCIE#2_R: length 35.5
  TOP w0.104: RC525.1 v1(177.32,66.12) RC727.2
  IN4 w0.076: v1(149.4,72.58) 149.76,72.23 149.76,71.69 149.92,71.53 149.92,71.15 150.4,70.67
  IN4 w0.094: v1(177.32,66.12) 176.83,65.63 174.6,65.63 173.41,64.44 172.84,64.44 172.6,64.68 168.99,64.68 168.85,64.81 163.06,64.81 162.46,64.22 161.31,64.22 158.34,67.18 157.89,67.18 154.4,70.67 150.4,70.67
  BOTTOM w0.089: UC1.CF30 v1(149.4,72.58)
CLKREQ_PCIE#3_R: length 40.4
  TOP w0.104: RC523.1 v1(180.62,66.12)
  IN4 w0.076: v1(148.49,71.95) 148.86,71.58 148.86,71.04 148.91,70.99 148.91,70.94
  IN4 w0.094: v1(180.62,66.12) 180.47,66.12 177.87,63.52 177.42,63.52 177.07,63.18 176.38,63.18 176.13,63.43 174.76,63.43 174.1,62.77 172.15,62.77 171.91,63.01 168.29,63.01 168.16,63.14 163.75,63.14 163.11,62.5 159.46,62.5 156.38,65.58 156.38,65.73 153.12,69 150.1,69 149.2,69.9 149.2,70.66 148.91,70.94
  BOTTOM w0.089: UC1.CE31 v1(148.49,71.95)
CLKREQ_PCIE#4: length 169.1
  TOP w0.104: UR1.2 v1(288.87,67.54) ; v1(179.23,68.53) 179.23,68.23 RC528.1
  IN1 w0.094: v1(294.41,64.71) 294.65,64.47 294.65,63.01 293.97,62.34 293.97,57.5 294.84,56.64 294.84,55.56 294.52,55.24 286.87,55.24 286.28,55.83 282.51,55.83 282.23,56.11 281.86,56.11 279.15,53.4 279.15,51.49 279.14,51.48 279.14,51.43 278.92,51.21 278.87,51.21 276.53,48.87 276.53,47.73 275.94,47.15 275.94,46.61 275.56,46.22 274.33,46.22 273.71,45.61 273.71,45.16 273.49,44.94 272.82,44.94 272.76,44.89 271.92,44.05 271.92,41.91 271.24,41.23 271.24,39.46 267.97,36.18 267.14,36.18 266.56,36.77 259.76,36.77 258.62,35.62 257.58,35.62 256.9,34.93 256.3,34.93 256.08,34.71 252.6,34.71 251.85,35.47 250.32,35.47 249.97,35.11 239.97,35.11 239.49,35.6 230.54,35.6 229.76,34.82 219.61,34.82 216.94,37.49 214.35,37.49 198.31,53.52 193.64,53.52 192.24,54.92 191.33,54.92 190.18,56.07 188.87,56.07 187.19,57.74 187.19,60.98 184.86,63.31 184.86,63.78 181.74,66.9 179.41,66.9 178.28,68.02 178.28,68.78 178.41,68.91 178.86,68.91 v1(179.23,68.53)
  BOTTOM w0.104: v1(288.87,67.54) 289.9,67.54 290.84,66.61 291.6,66.61 293.16,65.04 294.08,65.04 v1(294.41,64.71)
CLKREQ_PCIE#4_R: length 40.3
  TOP w0.104: RC528.2 v1(179.8,66.12) RC51.1
  IN4 w0.076: 149.04,71.12 149.04,72.03 v1(148.49,72.58)
  IN4 w0.094: 149.04,71.12 149.43,70.73 149.43,69.99 150.15,69.27 153.36,69.27 159.65,62.98 162.92,62.98 163.55,63.62 168.36,63.62 168.49,63.48 172.1,63.48 172.34,63.24 173.91,63.24 174.57,63.91 176.27,63.91 176.8,64.43 178.11,64.43 v1(179.8,66.12)
  BOTTOM w0.089: UC1.CE30 v1(148.49,72.58)
CLKREQ_PCIE#5: length 293.4
  TOP w0.104: RC529.1 177.88,67.94 v1(177.88,68.53)
  IN1 w0.094: v1(41.31,47.68) 41.31,47.17 39.37,45.23 39.37,42.87 39.5,42.73 39.5,34.54 42.87,31.17 42.87,30.44 44.53,28.77 48.06,28.77 48.46,28.38 57.1,28.38 57.93,29.2 68.51,29.2 68.6,29.11 68.6,28.72 69.64,27.68 69.64,26.03 70.91,24.76 73.03,24.76 74.43,23.37 116.34,23.37 118.26,25.28 146.32,25.28 149.12,28.08 160.04,28.08 161.14,26.98 161.55,26.98 162.24,26.3 165.53,26.3 166.21,26.98 172.48,26.98 172.86,27.36 176.2,27.36 180.2,23.37 186.32,23.37 190.86,27.9 191.94,27.9 192.8,28.76 202.34,28.76 202.63,29.05 202.63,31.07 202.72,31.16 203.46,31.16 205.29,32.98 205.29,34.17 204.61,34.86 204.61,35.4 205.87,36.67 205.87,37.9 205.87,37.9 204.73,39.05 204.73,41.03 198.4,47.35 196.97,47.35 194.51,49.81 192.63,49.81 190.92,51.53 189.61,51.53 182.44,58.69 181.53,58.69 181.33,58.89 181.33,60.37 180.88,60.83 180.07,60.83 179.23,61.67 179.23,64.99 178.6,65.63 178.6,66.77 177.88,67.49 v1(177.88,68.53) ; v1(32.14,72) 32.39,72 32.79,72.4 32.79,76.2 32.97,76.38 32.97,76.87 33.4,77.31 33.4,77.79 33.09,78.1 33.09,80.48 v1(32.6,80.98)
  IN4 w0.094: v1(41.31,47.68) 40.84,48.15 40.84,53.71 40.33,54.22 40.33,58.91 41.22,59.8 41.22,60.32 40.77,60.76 40.77,69.91 39.69,70.99 36.04,70.99 35.95,70.89 35.95,70.86 35.66,70.58 34.42,70.58 34.36,70.63 33.79,70.63 33.67,70.76 33.09,70.76 32.86,70.99 32.84,70.99 32.14,71.69 v1(32.14,72)
  BOTTOM w0.076: UT1.AC5 32.26,80.69 32.55,80.98 v1(32.6,80.98)
CLKREQ_PCIE#5_R: length 36.6
  TOP w0.104: RC529.2 v1(178.15,66.12) RC190.1
  IN4 w0.076: v1(149.4,71.95) 149.4,71.81 149.76,71.46 149.76,71.17 149.75,71.16 149.75,71.04 149.89,70.9
  IN4 w0.094: v1(178.15,66.12) 177.26,65.23 174.77,65.23 173.57,64.04 172.67,64.04 172.43,64.28 168.82,64.28 168.69,64.41 163.22,64.41 162.63,63.82 160.64,63.82 158.43,66.02 158.43,66.07 154.76,69.74 150.31,69.74 149.89,70.16 149.89,70.9
  BOTTOM w0.089: v1(149.4,71.95) 149.37,71.97 UC1.CF31
CMOUT: length 116.7
  TOP w0.127: v2(31.27,47.75) 31.4,47.62 v1(32.07,47.62)
  TOP w0.203: PR727.1 40,48.05 v1(39.1,48.05)
  TOP w0.254: PQ812.2 56.93,104.53 55.88,104.53 55.65,104.3 54.76,104.3 v1(54.53,104.53) 53.84,103.84 PQ811.3 53.84,102.72 53.71,102.58 53.36,102.58 53.19,102.75 PQ811.2
  IN3 w0.254: v1(35.39,83) 35.52,83 36.33,82.19 36.33,78.66 37.17,77.83 37.17,76.34 36.49,75.67 36.49,72.83 36.07,72.41 36.07,70.92 35.74,70.59 26.22,70.59 25.03,69.4 25.03,63.94 25.91,63.05 25.91,61.08 25.15,60.32 23.06,60.32 21.85,59.11 21.85,52.11 21.09,51.35 v1(21.09,50.29)
  IN4 w0.254: v1(32.07,47.62) 32.07,47.87 31.63,48.32 30.8,48.32 30.55,48.57 26.68,48.57 24.96,50.29 v1(21.09,50.29)
  BOTTOM w0.254: v1(32.07,47.62) 34.8,47.62 35,47.81 37.89,47.81 38.13,48.05 v1(39.1,48.05) ; v1(54.53,104.53) 54.53,104.25 51.96,101.68 46.95,101.68 45.35,100.08 42.12,100.08 41.7,100.5 39.78,100.5 39.08,99.8 36.73,99.8 36.04,99.1 36.04,91.71 34.17,89.85 34.17,88.95 34.36,88.76 34.36,87.05 34.8,86.61 35.88,86.61 37.09,85.4 37.09,83.43 36.66,83 v1(35.39,83)
CNV_BRI_PRX_DTX: length 143.4
  TOP w0.127: v1(174.7,78.59) 174.7,79.24 175.57,80.12 RC724.1
  IN1 w0.084: v1(174.7,78.59) 174.7,79.72 174.78,79.8 175.38,79.8 175.75,79.44 175.75,77.84 175.24,77.33 175.24,75.41 179.74,70.91 181.6,70.91 191.01,61.5 191.01,58.74 192.34,57.41 194.09,57.41 194.52,57.85 198.1,57.85 215.63,40.32 218.92,40.32 221.3,37.94 228.96,37.94 229.58,38.56 243.47,38.56 243.63,38.72 244.28,38.72 244.42,38.58 246.58,38.58 247.4,39.39 253.09,39.39 253.77,40.07 v1(253.77,40.29)
  IN1 w0.102: v1(151.49,78.51) 151.61,78.39 152.54,78.39 153.11,78.96 154.67,78.96 155.37,78.26 161.68,78.26 162.33,77.6 174.05,77.6 174.7,78.25 v1(174.7,78.59)
  BOTTOM w0.089: UC1.CK20 v1(151.49,78.51)
  BOTTOM w0.127: v1(253.77,40.29) 253.77,40.45 254.08,40.76 254.08,42.49 253.18,43.39 252.1,43.39 251.28,44.21 251.28,47.06 251.68,47.45 252.97,47.45 RZ1381.2
CNV_BRI_PRX_DTX_R: length 16.7
  IN1 w0.084: v1(265.75,49.14) 265.64,49.26 262.84,49.26 262.64,49.06 259.4,49.06 258.92,48.57 258.55,48.57 258.47,48.49 258.47,48.02 258.38,47.94 258.22,47.94 258.13,48.02 258.13,48.49 258.05,48.57 257.88,48.57 257.8,48.49 257.8,47.39 257.71,47.3 257.55,47.3 257.46,47.39 257.46,48.49 257.38,48.57 255.88,48.57 255.11,47.8 v1(255.11,47.73)
  BOTTOM w0.127: JNGFF1.22 264.61,49.14 v1(265.75,49.14) ; RZ1381.1 254.72,48.11 v1(255.11,47.73)
CNV_BRI_PTX_DRX: length 29.5
  TOP w0.127: v1(175.29,78.56) 176.05,79.32 RC711.2
  IN1 w0.102: v1(150.86,78.51) 151.3,78.07 152.83,78.07 152.93,78.17 152.93,78.51 153.03,78.61 153.24,78.61 153.34,78.51 153.34,78.17 153.44,78.07 153.64,78.07 153.75,78.17 153.75,78.67 153.85,78.77 154.05,78.77 154.15,78.67 154.15,78.17 154.25,78.07 161.58,78.07 162.25,77.4 174.13,77.4 v1(175.29,78.56)
  BOTTOM w0.089: UC1.CJ20 v1(150.86,78.51)
CNV_BRI_PTX_DRX_R: length 118.8
  TOP w0.127: v1(178.39,76.14) 178.39,76.24 v2(177.41,77.21) 177.35,77.27 RZ603.1 RC711.1
  IN1 w0.084: v1(178.39,76.14) 179.28,77.03 182.16,77.03 183.45,75.74 183.45,75.55 183.33,75.43 183.33,75.31 183.43,75.21 183.55,75.21 183.72,75.37 183.83,75.37 183.95,75.25 183.95,75.14 183.79,74.97 183.79,74.85 183.9,74.73 184.02,74.73 184.18,74.89 184.3,74.89 184.42,74.77 184.42,74.65 184.26,74.49 184.26,74.38 184.38,74.26 184.5,74.26 184.65,74.41 184.77,74.41 184.89,74.29 184.89,74.18 184.7,73.99 184.7,73.87 184.82,73.75 184.94,73.75 185.13,73.94 185.25,73.94 185.38,73.81 185.38,73.69 185.19,73.5 185.19,73.38 185.31,73.26 185.43,73.26 185.62,73.45 185.73,73.45 185.87,73.32 185.87,73.2 185.68,73.01 185.68,72.89 185.8,72.78 185.92,72.78 186.1,72.96 186.22,72.96 189.11,70.07 189.11,68.07 194.53,62.65 198.34,62.65 216.8,44.2 221.33,44.2 222.63,42.9 229.54,42.9 230.22,42.22 241.67,42.22 242.76,43.31 243.97,43.31 245.68,45.01 249.3,45.01 250.26,45.97 252.73,45.97 253.68,46.93 255.18,46.93 255.59,46.52 257.64,46.52 259.52,48.39 263.32,48.39 263.81,48.88 265.21,48.88 265.64,48.45 v1(266.63,48.45)
  BOTTOM w0.127: v1(266.63,48.45) 266.63,47.1 265.86,46.33 265.86,46.12 265.37,45.63 JNGFF1.36
CNV_COEX1: length 168.5
  TOP w0.127: RZ373.2 280.47,59.03 277.74,59.03 277.64,58.94 275.46,58.94 274.87,58.35 v2(274.87,58.2) 274.6,57.93 v1(274.45,57.93)
  IN1 w0.102: v1(150.22,80.59) 150.8,80 151.17,80 151.17,80 151.73,80 151.73,80 154.5,80 155.62,78.89 166.13,78.89 166.53,78.48 168.34,78.48 168.68,78.82 171.81,78.82 173.17,80.18 175.54,80.18 176.13,79.6 176.13,77.68 175.62,77.18 175.62,75.57 179.9,71.29 181.76,71.29 192.93,60.12 195.27,60.12 195.93,59.46 198.13,59.46 216.09,41.5 219.37,41.5 221.78,39.09 228.48,39.09 229.1,39.72 242.99,39.72 243.15,39.88 244.76,39.88 244.9,39.73 246.1,39.73 247.45,41.08 251.09,41.08 252.39,42.38 269.16,42.38 269.53,42.75 269.53,44.48 270.81,45.76 271.09,45.76 273.71,48.37 273.71,48.81 276.04,51.14 276.04,54.12 274.75,55.41 274.75,57.63 v1(274.45,57.93)
  BOTTOM w0.089: v1(150.22,80.59) UC1.CH17
CNV_COEX2: length 169.8
  TOP w0.102: v2(274.07,57.13) 274.07,58.13 v1(274.44,58.49)
  TOP w0.127: v1(274.44,58.49) 275.11,59.17 277.55,59.17 277.64,59.26 279.58,59.26 280.23,59.91 280.23,61.31 RZ372.2
  IN1 w0.102: v1(274.44,58.49) 274.07,58.13 274.07,57.06 274.43,56.7 274.43,55.44 275.79,54.08 275.79,51.18 273.5,48.89 273.5,48.46 271.36,46.32 271.09,46.32 268.87,44.1 268.64,44.1 268.2,43.67 264.69,43.67 263.61,42.58 252.31,42.58 251.01,41.28 247.37,41.28 246.02,39.94 244.99,39.94 244.84,40.08 243.07,40.08 242.91,39.92 229.02,39.92 228.39,39.3 221.86,39.3 219.46,41.7 216.17,41.7 198.22,59.66 196.01,59.66 195.35,60.32 193.02,60.32 181.85,71.49 179.99,71.49 175.82,75.65 175.82,77.09 176.33,77.6 176.33,79.68 175.63,80.39 173.09,80.39 171.87,79.17 156.47,79.17 155.42,80.22 151.68,80.22 151.65,80.19 151.25,80.19 v1(150.86,80.59)
  BOTTOM w0.089: v1(150.86,80.59) UC1.CJ17
CNV_COEX3: length 169.1
  TOP w0.127: v1(274.44,59.43) 274.73,59.43 274.92,59.63 277.36,59.63 277.46,59.73 278.3,59.73 278.43,59.86 278.43,61.3 RZ374.2
  IN1 w0.084: v1(274.44,59.43) 274.86,59.43 274.95,59.35 274.95,55.52 276.79,53.67 276.79,51.62 273.9,48.73 273.9,48.29 271.17,45.56 270.89,45.56 269.72,44.39 269.72,40.95 269.17,40.4 268.07,40.4 267.68,40.01 265.84,40.01 264.12,38.28 258.1,38.28 256.58,36.77 253.12,36.77 252.63,37.26 243.75,37.26 243.38,37.62 229.97,37.62 228.88,36.53 220.59,36.53 217.74,39.38 215.2,39.38 199.41,55.16 194.15,55.16 192.84,56.47 191.95,56.47 190.05,58.37 190.05,60.74 186.83,63.96 186.83,64.34 182.35,68.81 181.17,68.81 179.82,70.16 179.82,70.57 175.06,75.34 175.06,77.08 174.93,77.2 162.19,77.2 161.51,77.89 160.96,77.89 160.54,77.47 v1(160.54,77.46)
  BOTTOM w0.076: 156.44,79 156.34,78.9 154.98,78.9 154.82,79.06 154.75,79.13 154.29,79.13 154.1,78.93 153.83,78.93 153.35,79.2 UC1.CP20
  BOTTOM w0.102: v1(160.54,77.46) 160.54,78.03 v2(160.16,78.41) 159.58,79 156.44,79
CNV_DET#_EC: length 67.2
  TOP w0.127: v1(269.51,58.5) 269.25,58.5 269.04,58.3 269.04,57.4 269.35,57.09 v2(269.35,56.73) 269.25,56.62 268.45,56.62 RZ377.2 268.63,56.11 268.95,56.11 269.21,55.85 RZ827.2 269.21,55.15 269.02,54.96 QZ17.1 ; UE1.L11 280.96,86.1 280.96,86.79 281.09,86.91 281.45,86.91 281.88,87.34 281.88,87.5 282.41,88.02 282.41,90.52 v1(282.8,90.92)
  IN1 w0.084: v1(282.77,67.07) 283.13,67.07 283.22,66.99 283.22,66.35 283.01,66.15 281.45,66.15 281.02,66.58 272.11,66.58 270.74,65.21 268.9,65.21 267.7,64.01 267.7,59.78 268.98,58.5 v1(269.51,58.5)
  IN2 w0.122: v1(282.8,90.92) 283.69,90.03 284.3,90.03 284.51,89.82 285.89,89.82 287.15,88.56 287.15,88.37 287.15,88.37 287.15,87.12 285.93,85.89 285.93,83.96 286.16,83.73 286.16,83.07 285.82,82.73 285.82,80.61 286.48,79.96 286.48,79.45 285.34,78.32 285.34,75.89 284.09,74.63 284.09,73.48 283.59,72.99 282.86,72.99 282.45,72.57 282.45,68.78 282.97,68.25 282.97,67.27 v1(282.77,67.07)
CNV_PRX_DTX_N0: length 147.7
  IN4 w0.094: v1(259.41,39.52) 259.41,40.64 259.05,41 253.69,41 253.19,40.5 253.19,40.08 252.6,39.49 251.26,39.49 251.17,39.58 251.17,40.03 250.97,40.23 250.27,40.23 250.07,40.03 250.07,39.58 249.98,39.49 248.92,39.49 248.83,39.58 248.83,39.99 248.63,40.19 247.93,40.19 247.73,39.99 247.73,39.58 247.64,39.49 246.94,39.49 245.42,37.97 240.38,37.97 240.32,37.91 229.33,37.91 228.85,37.42 226.2,37.42 225,38.62 221.61,38.62 221,39.23 217.73,39.23 214.9,42.07 213.14,42.07 200.16,55.05 193.59,55.05 190.05,58.58 190.05,61.85 190.48,62.28 190.48,65.6 188.45,67.63 187.18,67.63 181.3,73.52 176.22,73.52 175.61,74.14 173.77,74.14 173.5,73.88 171.45,73.88 170.77,74.55 167.3,74.55 167.24,74.61 161.92,74.61 161.73,74.42 159.65,74.42 159.45,74.23 v1(159.45,73.53)
  BOTTOM w0.076: UC1.CR30 154.13,72.94 154.41,72.66 158.95,72.66 159.02,72.73 159.02,73.01 159.1,73.08 159.25,73.08 159.33,73.01 159.33,72.73 159.4,72.66 159.62,72.66 159.86,72.9 159.86,73.12 159.71,73.27
  BOTTOM w0.104: 159.71,73.27 v1(159.45,73.53) ; v1(259.41,39.52) 259.41,41.56 259.99,42.14 259.99,47.33 259.21,48.1 259.21,50.37 258.7,50.88 JNGFF1.15
CNV_PRX_DTX_N1: length 148.7
  IN4 w0.094: v1(157.63,73.59) 157.63,74.13 158.68,75.18 161.43,75.18 162.45,76.2 166.19,76.2 166.84,75.56 170.59,75.56 171.69,74.46 173.26,74.46 173.52,74.72 176.11,74.72 176.73,74.1 181.54,74.1 186.32,69.32 188.75,69.32 189.62,68.45 189.62,67.29 191.06,65.84 191.06,62.04 190.63,61.61 190.63,58.82 193.83,55.63 200.4,55.63 213.38,42.65 215.14,42.65 217.98,39.81 221.25,39.81 221.85,39.21 225.24,39.21 226.44,38.01 228.61,38.01 229.09,38.49 240.08,38.49 240.84,39.25 245.88,39.25 247.45,40.82 251.05,40.82 251.82,41.58 259.33,41.58 260.29,40.62 260.29,40.33 v1(260.42,40.2)
  BOTTOM w0.076: v1(157.63,73.59) 157.63,73.41 157.28,73.06 155.83,73.06 155.83,73.06 154.48,73.06 154.38,73.15 154.17,73.37 153.8,73.37 153.64,73.28 153.45,73.28 153.39,73.29 153.24,73.29 153.23,73.3 153.03,73.3 152.94,73.2 152.3,73.2 UC1.CM30
  BOTTOM w0.104: v1(260.42,40.2) 260.36,40.26 260.36,41.66 260.59,41.89 260.59,47.58 259.85,48.32 259.85,51.05 258.52,52.38 JNGFF1.9
CNV_PRX_DTX_P0: length 147.7
  IN4 w0.094: v1(258.83,39.52) 258.83,39.71 258.92,39.81 259.14,39.81 259.23,39.9 259.23,40.57 258.98,40.82 253.76,40.82 253.37,40.43 253.37,40.01 252.67,39.31 251.18,39.31 250.98,39.51 250.98,39.96 250.89,40.05 250.35,40.05 250.26,39.96 250.26,39.51 250.05,39.31 248.84,39.31 248.64,39.51 248.64,39.91 248.55,40 248.01,40 247.91,39.91 247.91,39.51 247.71,39.31 247.02,39.31 245.5,37.79 240.46,37.79 240.4,37.72 229.41,37.72 228.92,37.24 226.13,37.24 224.93,38.44 221.54,38.44 220.93,39.05 217.66,39.05 214.82,41.88 213.06,41.88 200.08,54.86 193.51,54.86 189.87,58.5 189.87,61.93 190.3,62.36 190.3,65.53 188.37,67.45 187.11,67.45 181.22,73.34 176.15,73.34 175.53,73.96 173.84,73.96 173.58,73.69 171.37,73.69 170.7,74.37 167.22,74.37 167.16,74.43 162,74.43 161.8,74.23 159.73,74.23 159.64,74.14 159.64,73.94 159.73,73.84 159.93,73.84 160.03,73.75 v1(160.03,73.53)
  BOTTOM w0.076: 160.03,73.27 160.03,72.83 159.69,72.49 154.34,72.49 154.23,72.61 154.23,72.61 154.16,72.67 153.87,72.67 UC1.CP30
  BOTTOM w0.104: v1(258.83,39.52) 259.22,39.91 259.22,41.64 259.79,42.22 259.79,47.25 259.02,48.02 259.02,50.29 258.62,50.69 258.26,50.69 257.95,50.38 JNGFF1.17 ; 160.03,73.27 v1(160.03,73.53)
CNV_PRX_DTX_P1: length 148.7
  IN4 w0.094: v1(158.18,73.33) 158.18,73.57 157.82,73.93 157.82,74.07 158.75,75 161.51,75 162.53,76.01 166.12,76.01 166.76,75.37 170.52,75.37 171.62,74.28 173.34,74.28 173.6,74.54 176.03,74.54 176.65,73.92 181.46,73.92 186.25,69.13 188.67,69.13 189.43,68.37 189.43,67.21 190.88,65.77 190.88,62.11 190.45,61.69 190.45,58.75 193.75,55.44 200.33,55.44 213.3,42.47 215.06,42.47 217.9,39.63 221.17,39.63 221.78,39.02 225.17,39.02 226.37,37.82 228.68,37.82 229.17,38.3 240.15,38.3 240.91,39.06 245.95,39.06 247.52,40.64 251.13,40.64 251.89,41.4 259.25,41.4 260.09,40.56 260.09,40.39 259.83,40.13 v1(259.83,40.08)
  BOTTOM w0.076: UC1.CN30 152.64,72.84 152.72,72.76 152.93,72.76 153,72.84 153,73.03 153.1,73.13 153.3,73.13 153.3,73.13 153.37,73.13 153.44,73.12 153.68,73.12 153.84,73.2 154.1,73.2 154.27,73.04 154.27,73.03 154.41,72.89 157.35,72.89 157.61,73.16 157.85,73.16
  BOTTOM w0.104: JNGFF1.11 257.89,51.88 258.19,52.19 258.44,52.19 259.66,50.97 259.66,48.24 260.4,47.5 260.4,41.97 260.17,41.74 260.17,40.49 259.83,40.16 v1(259.83,40.08) ; 157.85,73.16 158.02,73.33 v1(158.18,73.33)
CNV_PTX_DRX_N0: length 132
  IN4 w0.094: v1(254.75,37.15) 255,37.4 255,37.56 254.91,37.65 253.5,37.65 252.62,36.77 247.11,36.77 247.02,36.68 245.58,35.24 239.77,35.24 239.02,35.98 230.13,35.98 229.65,35.5 225.4,35.5 224.92,35.98 221.53,35.98 220.2,37.3 216.93,37.3 214.17,40.07 212.41,40.07 199.36,53.12 191.94,53.12 187.54,57.51 187.54,62.07 188.55,63.08 188.55,64.8 187.8,65.55 186.54,65.55 180.5,71.59 175.16,71.59 174.75,71.19 172.97,71.19 172.56,71.59 165.97,71.59 165.14,72.42 162.48,72.42 160.17,70.11 159.18,70.11 v1(158.63,70.66)
  BOTTOM w0.076: UC1.CN32 152.61,71.67 152.39,71.67 152.31,71.59 152.31,71.45 152.39,71.37 152.49,71.37 152.49,71.36 152.8,71.36 152.95,71.52 152.95,71.58 153,71.68 153.08,71.78 153.19,71.82 153.38,71.83 153.46,71.8 153.51,71.8 153.6,71.79 153.78,71.79 153.84,71.81 153.92,71.82 154.01,71.82 154.07,71.8 154.22,71.7 154.35,71.68 154.52,71.68 155.06,71.68 155.18,71.68 155.74,71.12 158.55,71.12 158.63,71.04 v1(158.63,70.66)
  BOTTOM w0.104: JNGFF1.65 256.15,38.38 256.06,38.28 255.13,38.28 254.75,37.91 v1(254.75,37.15)
CNV_PTX_DRX_N1: length 132.3
  IN4 w0.094: v1(157.51,70.67) 157.5,70.67 157.5,71 157.6,71.1 158.93,71.1 159.91,72.08 161.31,72.08 162.24,73 165.53,73 165.74,73.21 170.22,73.21 171.25,72.18 180.74,72.18 186.63,66.29 187.89,66.29 189.13,65.04 189.13,62.84 188.71,62.41 188.71,58.02 189.77,56.96 189.77,56.83 189.55,56.61 189.55,56.33 190.04,55.84 190.33,55.84 190.54,56.05 190.68,56.05 191.06,55.67 191.06,55.54 190.84,55.32 190.84,55.04 191.33,54.55 191.62,54.55 191.83,54.76 191.97,54.76 193.03,53.7 199.6,53.7 212.58,40.72 214.34,40.72 217.18,37.88 220.45,37.88 221.05,37.28 224.44,37.28 225.64,36.08 229.41,36.08 229.89,36.56 239.33,36.56 240.07,35.82 245.33,35.82 246.78,37.27 246.86,37.35 250.37,37.35 250.58,37.55 250.58,37.74 250.67,37.83 251.21,37.83 251.3,37.74 251.3,37.55 251.51,37.35 252.38,37.35 254.18,39.15 254.74,39.15 254.88,39 254.88,38.5 254.74,38.36 254.57,38.36 254.48,38.45 v1(254.48,38.62)
  BOTTOM w0.076: UC1.CP33 153.68,71.06 154.73,71.06 155.76,70.03 156.5,70.03 156.76,70.28 157.12,70.28 v1(157.51,70.67)
  BOTTOM w0.104: v1(254.48,38.62) 254.53,38.67 254.53,39.44 254.97,39.88 JNGFF1.59
CNV_PTX_DRX_P0: length 132
  IN4 w0.094: v1(159.28,70.7) 159.14,70.56 159.14,70.41 159.26,70.29 160.09,70.29 162.41,72.6 165.22,72.6 166.04,71.78 172.64,71.78 173.05,71.37 174.68,71.37 175.08,71.78 180.57,71.78 186.61,65.73 187.88,65.73 188.73,64.88 188.73,63 187.73,62 187.73,57.59 192.02,53.3 199.44,53.3 212.48,40.25 214.24,40.25 217.01,37.49 220.28,37.49 221.6,36.16 225,36.16 225.48,35.68 229.57,35.68 230.06,36.16 239.1,36.16 239.84,35.42 245.5,35.42 246.95,36.87 247.03,36.95 252.54,36.95 253.43,37.83 254.99,37.83 255.19,37.63 255.19,37.31 v1(255.34,37.15)
  BOTTOM w0.076: UC1.CM32 152.38,71.95 152.81,71.98 153.09,71.98 153.09,71.98 153.18,71.98 153.4,72 153.48,71.97 153.52,71.97 153.61,71.96 153.76,71.96 153.81,71.97 153.9,71.98 153.96,71.98 154.02,71.98 154.13,71.96 154.28,71.86 154.36,71.84 154.52,71.84 155.06,71.84 155.08,71.84 155.24,71.84 155.81,71.28 158.7,71.28 v1(159.28,70.7)
  BOTTOM w0.104: v1(255.34,37.15) 255.34,37.4 255.27,37.46 255.03,37.46 254.95,37.55 254.95,37.83 255.21,38.09 255.94,38.09 256.15,37.88 JNGFF1.67
CNV_PTX_DRX_P1: length 132.4
  IN4 w0.094: v1(156.88,70.64) 157.52,71.28 158.85,71.28 159.84,72.26 161.24,72.26 162.16,73.19 165.46,73.19 165.66,73.39 170.29,73.39 171.32,72.36 180.81,72.36 186.7,66.47 187.96,66.47 189.32,65.12 189.32,62.76 188.89,62.34 188.89,58.1 189.95,57.04 189.95,56.75 189.74,56.54 189.74,56.4 190.12,56.02 190.25,56.02 190.47,56.24 190.75,56.24 191.24,55.75 191.24,55.46 191.03,55.25 191.03,55.11 191.41,54.73 191.54,54.73 191.76,54.94 192.04,54.94 193.1,53.88 199.68,53.88 212.66,40.9 214.42,40.9 217.25,38.07 220.52,38.07 221.13,37.46 224.52,37.46 225.72,36.26 229.33,36.26 229.81,36.74 239.4,36.74 240.15,36 245.26,36 246.71,37.45 246.79,37.53 250.3,37.53 250.39,37.62 250.39,37.81 250.59,38.01 251.29,38.01 251.49,37.81 251.49,37.62 251.58,37.53 252.3,37.53 254.1,39.33 254.81,39.33 255.07,39.08 255.07,38.87 v1(255.26,38.68)
  BOTTOM w0.076: v1(156.88,70.64) 156.43,70.19 155.83,70.19 154.8,71.22 153.84,71.22 153.81,71.25 153.55,71.25 UC1.CN33
  BOTTOM w0.104: v1(255.26,38.68) 254.72,39.21 254.72,39.36 255.05,39.69 255.85,39.69 256.15,39.38 JNGFF1.61
CNV_RF_RESET#: length 164.5
  TOP w0.127: RC640.2 176.03,66.72 176,66.75 175.93,66.75 v1(175.15,67.52) ; v1(267.24,51.85) 267.16,51.93 v2(267.16,52.42) 267.66,52.92 QZ17.2
  IN4 w0.084: v1(267.24,51.85) 267.18,51.91 265.21,51.91 262.64,49.34 261.25,49.34 258.76,46.85 258.76,42.97 260.99,40.74 260.99,39.52 258.92,37.44 258.26,37.44 255.82,35 252.91,35 252.38,34.47 250.27,34.47 250.05,34.69 246.41,34.69 245.98,34.26 239.32,34.26 238.58,35 230.54,35 230.05,34.52 225,34.52 224.52,35 221.12,35 219.8,36.33 216.53,36.33 213.76,39.09 211.86,39.09 208.99,41.97 208.63,41.97 198.91,51.68 195.21,51.68 194.78,51.26 192.42,51.26 185.05,58.63 185.05,60.95 187.58,63.49 187.58,64.4 187.4,64.58 185.34,64.58 181.89,68.02 176.37,68.02 175.87,67.52
  IN4 w0.102: v1(151.29,72.13) 152.27,71.15 155.26,71.15 156.51,69.91 156.82,69.91 157.49,69.24 157.49,68.93 158.55,67.86 158.62,67.86 161.59,64.9 162.18,64.9 162.77,65.49 168.39,65.49 169.94,67.05 172.42,67.05 172.9,67.52 v1(175.15,67.52) 175.87,67.52
  BOTTOM w0.076: UC1.CJ32 150.77,71.61 151.29,72.13 v1(151.29,72.13)
  BOTTOM w0.127: JNGFF1.10 265.38,52.13 265.59,51.92 267.17,51.92 v1(267.24,51.85)
CNV_RGI_PRX_DTX: length 143.3
  TOP w0.127: RC733.1 173.74,81.15 v2(173.74,80.73) 173.74,80.21 v1(173.25,79.72)
  IN1 w0.084: v1(254.31,40.43) 254.08,40.66 253.62,40.66 253.38,40.43 253.38,39.94 253.01,39.57 247.32,39.57 246.51,38.76 244.5,38.76 244.36,38.91 243.55,38.91 243.4,38.75 229.51,38.75 228.88,38.12 221.37,38.12 219,40.5 215.71,40.5 198.18,58.03 194.44,58.03 194.01,57.6 192.41,57.6 191.2,58.82 191.2,61.58 181.68,71.1 179.82,71.1 175.43,75.49 175.43,77.26 175.93,77.76 175.93,79.52 175.46,79.99 173.52,79.99 v1(173.25,79.72)
  IN1 w0.102: v1(173.25,79.72) 172.15,78.62 168.77,78.62 168.16,78.01 162.5,78.01 161.87,78.64 155.6,78.64 154.83,79.41 151.91,79.41 151.65,79.15 150.61,79.15 v1(150.22,79.55)
  BOTTOM w0.089: v1(150.22,79.55) UC1.CH19
  BOTTOM w0.127: RZ1383.2 251.77,47.22 251.51,46.97 251.51,44.31 252.2,43.62 253.28,43.62 254.31,42.59 v1(254.31,40.43)
CNV_RGI_PRX_DTX_R: length 16.7
  IN1 w0.084: v1(266.19,48.08) 265.75,48.08 265.13,48.7 263.89,48.7 263.4,48.21 259.59,48.21 257.72,46.33 v1(255.15,46.33)
  BOTTOM w0.127: RZ1383.1 254.83,47.22 255.15,46.9 v1(255.15,46.33) ; v1(266.19,48.08) 266.19,46.98 265.56,46.36 265.56,46.26 265.44,46.13 JNGFF1.34
CNV_RGI_PTX_DRX: length 29.4
  TOP w0.127: v1(173.66,79.32) 174.19,79.85 174.19,80.96 174.58,81.35 174.77,81.35 RC710.2
  IN1 w0.102: v1(173.66,79.32) 172.76,78.42 168.85,78.42 168.24,77.81 162.42,77.81 161.77,78.45 155.52,78.45 154.77,79.2 152.02,79.2 151.72,78.9 150.23,78.9 v1(149.59,79.55)
  BOTTOM w0.089: v1(149.59,79.55) UC1.CG19
CNV_RGI_PTX_DRX_R: length 119.5
  TOP w0.127: RC832.1 RC842.1 ; RC832.1 176.09,83.48 v2(176.54,83.04) 176.88,82.7 v1(177.67,82.7) ; RC832.1 RC710.1
  IN1 w0.084: v1(177.67,82.7) 177.67,82.53 178.89,81.31 178.89,80.55 179.22,80.22 180.14,80.22 181.93,78.43 183.38,78.43 184.35,77.46 184.35,75.1 189.3,70.15 189.3,68.15 194.61,62.84 198.42,62.84 216.87,44.38 221.41,44.38 222.71,43.09 229.62,43.09 230.3,42.4 241.6,42.4 242.69,43.49 243.9,43.49 245.6,45.2 249.17,45.2 250.13,46.16 252.62,46.16 253.57,47.11 255.52,47.11 255.92,46.71 257.57,46.71 259.44,48.58 263.24,48.58 263.68,49.02 263.73,49.07 265.29,49.07 265.69,48.67 266.05,48.67 v1(266.22,48.83)
  BOTTOM w0.127: JNGFF1.32 265.51,46.63 265.79,46.91 265.79,48.41 v1(266.22,48.83)
CNV_WT_RCOMP: length 18.1
  TOP w0.127: v1(167.82,70.35) v2(168.36,69.81)
  TOP w0.203: RC448.2 v1(167.82,70.35)
  IN1 w0.203: v1(156.28,70.66) 156.74,71.11 159.1,71.11 159.1,71.12 159.45,71.12 159.46,71.11 160.66,71.11 162.06,72.51 164.96,72.51 165.28,72.19 165.45,72.19 167.29,70.35 v1(167.82,70.35)
  BOTTOM w0.2: v1(156.28,70.66) 155.8,70.66 155.01,71.44 154.03,71.44 UC1.CR32 153.92,71.55 UC1.CP32
CNVI_EN#: length 147.2
  TOP w0.127: v2(188.88,58.08) RC868.2 186.81,58.08 186.43,58.46 v1(186.43,59.23) ; RZ827.1 268.17,55.15 268.17,53.89 266.76,52.48 v1(266.76,51.48)
  IN2 w0.089: v1(150.3,72.59) 151.13,71.76 151.63,71.76
  IN2 w0.122: 151.63,71.76 152.93,70.47 154.5,70.47 158.23,66.74 159.61,66.74 160.17,66.18 161.72,66.18 162.46,65.44 167.98,65.44 168.73,66.19 169.44,66.19 169.87,65.77 169.87,65.41 170.18,65.1 172.09,65.1 172.42,65.43 173.26,65.43 173.45,65.25 175.95,65.25 177.76,63.44 178.86,63.44 179.26,63.03 181.49,63.03 182.1,62.42 182.1,61.89 181.79,61.58 181.79,60.48 182.6,59.66 184.23,59.66 184.67,59.23 v1(186.43,59.23)
  IN3 w0.122: v1(266.76,51.48) 266.72,51.52 265.37,51.52 264.37,50.52 264.37,50.21 262.53,48.37 260.1,48.37 259,47.28 257.69,47.28 256.04,45.63 254.09,45.63 253.37,44.92 251.95,44.92 249.59,42.56 248,42.56 246.6,41.15 244.95,41.15 244.79,41.31 243.61,41.31 242.44,40.14 236.91,40.14 236.76,39.99 229.43,39.99 227.61,41.81 217.61,41.81 207.29,52.13 195.32,52.13 189.73,57.72 186.88,57.72 186.43,58.18 v1(186.43,59.23)
  BOTTOM w0.076: UC1.CH30 v1(150.3,72.59)
COMP_A_GT: length 5.9
  TOP w0.203: PR639.2 71.97,59.21 v2(70.03,59.21) PU602.16
  TOP w0.254: PC636.2 73.3,57.02 PR639.2
COMP_B_IA: length 4.2
  TOP w0.203: PU602.4 65.72,55.76 65.33,55.38 65.33,54.71 v2(65.12,54.49) 64.36,54.49 PC616.2 PR617.2
COMP_C_SA: length 6.1
  TOP w0.203: PU602.24 66.92,62.57 v2(67.25,62.9) 69.37,65.02 PC628.1 PR630.1
COMP_CHG: length 3.5
  TOP w0.203: PR728.1 45.51,49.28 PC749.1 46.36,50.37 v2(46.39,50.41) 46.73,50.74 PU700.28
CONTACTLESS_DET#: length 155
  TOP w0.127: v1(180.81,62.22) 180.9,62.13 RC278.1
  IN1 w0.084: v1(180.81,62.22) 181.34,61.69 181.95,61.69 182.36,62.1 183.56,62.1 184.36,61.3 184.36,59.39 188.52,55.23 189.28,55.23 190.82,53.69 191.6,53.69 193.64,51.65 195.18,51.65 197.71,49.13 199.13,49.13 207.65,40.61 207.65,35.94 207.18,35.47 207.18,34.95 207.3,34.83 207.3,33.25 207.71,32.84 217.48,32.84 219.9,30.42 223.24,30.42 224.78,28.88 224.78,28.65 226.96,26.47 229.74,26.47 233.42,30.16 235.63,30.16 237.84,27.95 253.68,27.95 254.33,28.59 254.64,28.59 255.28,27.95 276.05,27.95 277.12,29.01 v1(277.25,29.01)
  IN2 w0.122: v1(180.81,62.22) 180.23,62.81 179.17,62.81 178.81,63.17 176.48,63.17 175.53,64.11 174.95,64.11 174.69,64.36 166.66,64.36 165.85,65.17 162.41,65.17 161.62,65.96 159.99,65.96 159.44,66.5 158.07,66.5 155.64,68.93 v1(155.01,68.93)
  BOTTOM w0.076: v1(155.01,68.93) 155.01,69.43 154.48,69.96 153.85,69.96 153.63,69.75 153.63,69.65 153.52,69.53 152.95,69.53 UC1.CN35
  BOTTOM w0.127: v1(277.25,29.01) 277.82,29.01 277.95,28.89 DZ8.2
CONTACTLESS_DET#_R: length 20.1
  TOP w0.127: v1(276.29,30.73) 276.29,30.53 v2(276.61,30.21)
  IN3 w0.122: v1(262.85,31.03) 263.21,30.67 263.6,30.67 264.04,31.1 266.63,31.1 266.63,31.1 267.99,31.1 268.25,30.83 269.55,30.83 270.07,31.36 270.07,31.88 270.84,32.64 273.79,32.64 274.8,31.63 275.6,31.63 276.29,30.94 v1(276.29,30.73)
  BOTTOM w0.127: v1(262.85,31.03) 262.93,31.11 JUSH1.4 ; v1(276.29,30.73) 276.37,30.65 277.82,30.65 277.95,30.52 DZ8.1
CORE_VID0: length 89.9
  TOP w0.127: v2(179.71,29.52) 179.39,29.2 v1(179.39,28.95)
  TOP w0.254: v1(179.39,28.95) 179.39,28.87 179.76,28.51 PR408.1
  IN2 w0.122: v1(181.33,52.21) 181.33,52.79 180.09,54.03 179.02,54.03 v1(178.09,54.96)
  IN4 w0.084: v1(148.15,64.34) 149.88,64.34 150.41,63.81 150.6,63.81 151.31,63.1 151.31,59 151.71,58.6 151.71,56.79 152.13,56.36 156.66,56.36 157,56.02 157.25,56.02 159.11,54.16 166.11,54.16 166.81,53.46 169.4,53.46 171.39,55.45 176.31,55.45 176.8,54.96 178.08,54.96 v1(178.09,54.96) ; v1(181.33,52.21) 181.33,51.44 180.91,51.01 180.91,49.86 189.56,41.21 189.56,40.47 192.61,37.42 192.61,33.04 190.98,31.41 181.27,31.41 179.82,29.96 179.82,29.42 179.39,28.99 v1(179.39,28.95)
  BOTTOM w0.076: UC1.CB36 146.73,67.55 148.38,65.9 148.38,64.57 v1(148.15,64.34)
CORE_VID1: length 79.3
  TOP w0.127: v1(185.76,32.74) 185.76,33.13 v2(185.57,33.33)
  TOP w0.254: PR411.1 v1(185.76,32.74)
  IN2 w0.122: v1(175.53,52.32) 177.71,54.49 v1(177.74,54.49)
  IN4 w0.084: v1(148.15,63.79) 150.19,63.79 150.34,63.64 150.53,63.64 151.01,63.16 151.01,58.79 151.52,58.29 151.52,56.72 152.06,56.18 156.58,56.18 156.92,55.84 157.18,55.84 159.04,53.97 164.92,53.97 166.19,52.7 168.91,52.7 170.72,54.51 171.47,55.26 176.24,55.26 176.72,54.78 177.46,54.78 v1(177.74,54.49) ; v1(175.53,52.32) 175.39,52.18 175.39,50.6 175.88,50.11 177,50.11 188,39.11 188.16,39.11 189.19,38.08 189.19,33.79 187.87,32.47 186.04,32.47 v1(185.76,32.74)
  BOTTOM w0.076: v1(148.15,63.79) 147.79,64.14 147.79,64.66 147.99,64.85 147.99,66.07 146.56,67.5 146.56,68.52 146.47,68.77 146.47,68.95 146.51,69.07 146.51,69.29 UC1.CB35
CPU_C10_GATE#: length 268.6
  TOP w0.127: RZ1420.1 154.31,110.31 154.15,110.47 v1(154.09,110.47)
  TOP w0.254: v1(75.95,29.71) v2(75.95,30.79) 75.95,31.24 76.46,31.74 78.68,31.74 79.03,31.4 PR429.1
  IN2 w0.122: v1(121.06,45.5) 121.27,45.71 132.07,45.71 133.35,44.44 133.81,44.44 134.37,43.87 135.01,43.87 136.28,42.6 157.67,42.6 159.87,44.81 183.96,44.81 189.14,49.98 189.14,50.77 189.84,51.47 191.31,51.47 195.3,55.46 195.3,56.78 v1(194.71,57.37) ; v1(154.09,110.47) 154.69,109.87 156.49,109.87 158.33,111.71 164.46,111.71 170.77,105.4 170.77,103.11 171.08,102.8 171.08,102.38 v1(170.96,102.26)
  IN3 w0.122: v1(157.36,74.42) 157.36,74.89 158.76,76.28 158.76,78.95 163.95,84.14 165.78,84.14 166.57,84.93 169.86,84.93 170.94,86 171.82,86.89 171.82,87.64 171.41,88.04 171.41,89 170.8,89.61 170.8,91.68 169.73,92.75 169.73,96.23 168.99,96.98 168.99,97.65 170.77,99.43 170.77,100.01 169.69,101.09 169.69,101.62 170.33,102.26 v1(170.96,102.26)
  IN4 w0.084: v1(75.95,29.71) 77.48,31.24 118.18,31.24 118.81,31.87 118.81,37.01 119.77,37.97 119.77,39.49 120.59,40.32 120.59,45.03 v1(121.06,45.5) ; v1(194.71,57.37) 192.64,57.37 191.03,58.98 191.03,61.45 191.45,61.88 191.45,66.01 190.25,67.21 190.25,68.54 189.08,69.71 186.49,69.71 181.7,74.5 176.89,74.5 176.27,75.11 173.36,75.11 173.1,74.85 171.85,74.85 169.76,76.95 162.65,76.95 161.27,75.57 158.51,75.57 v1(157.36,74.42)
  BOTTOM w0.076: UC1.CN27 153.37,74.41 154.46,74.41 155.02,73.85 156.79,73.85
  BOTTOM w0.102: 156.79,73.85 v1(157.36,74.42)
CPU_DP1_AUXN: length 124.8
  TOP w0.104: v1(38.38,80.88) 38.18,80.68 38.06,80.68 37.15,81.59 36.92,81.59 CT19.1
  IN4 w0.094: v1(38.38,80.88) 40.19,80.88 41.38,82.07 41.38,82.84 45.08,86.54 45.27,86.54 45.6,86.87 45.6,92.08 45.45,92.23 45.45,94.68 48.29,97.52 48.29,98.88 52.8,103.39 54.83,103.39 56.27,104.83 59.85,104.83 61.5,103.17 72.73,103.17 73.44,102.46 78.15,102.46 79.35,103.66 83.8,103.66 84.37,104.24 92.06,104.24 93.63,105.82 119.38,105.82 120.78,104.42 120.78,104.37 125.1,100.05 125.1,91.18 123.89,89.97 123.89,89.47 124.33,89.03 124.33,87.75 123.98,87.4 v1(122.85,87.4)
  BOTTOM w0.089: v1(122.85,87.4) UC1.AC7
CPU_DP1_AUXN_C: length 9.1
  TOP w0.104: CT19.2 36.02,81.64 34.64,81.64 v1(34.41,81.88)
  IN4 w0.094: v1(29.7,78.44) 29.94,78.68 29.94,78.89 30.14,79.09 31.22,79.09 32.07,79.94 32.77,79.94 33.39,80.56 33.39,81.38 33.86,81.86 34.39,81.86 v1(34.41,81.88)
  BOTTOM w0.104: UT1.W11 v1(29.7,78.44)
CPU_DP1_AUXP: length 124.8
  TOP w0.104: CT18.1 36.93,81.4 37.07,81.4 37.98,80.49 38.21,80.49 v1(38.39,80.31)
  IN4 w0.094: v1(38.39,80.31) 38.7,80.31 38.79,80.4 38.79,80.6 38.89,80.7 40.26,80.7 41.56,81.99 41.56,82.76 45.15,86.35 45.35,86.35 45.78,86.79 45.78,92.16 45.63,92.31 45.63,94.6 48.47,97.44 48.47,98.8 52.88,103.21 54.91,103.21 56.34,104.64 59.77,104.64 61.43,102.99 72.65,102.99 73.36,102.28 78.23,102.28 79.43,103.48 83.87,103.48 84.45,104.06 92.13,104.06 93.71,105.63 119.31,105.63 120.6,104.34 120.6,104.29 124.92,99.97 124.92,91.26 123.71,90.05 123.71,89.39 124.15,88.95 124.15,87.83 123.9,87.58 123.29,87.58 123.2,87.68 123.2,87.94 123.1,88.04 v1(122.85,88.04)
  BOTTOM w0.089: v1(122.85,88.04) UC1.AC6
CPU_DP1_AUXP_C: length 9
  TOP w0.104: v1(34.41,81.29) 34.57,81.45 35.9,81.45 CT18.2
  IN4 w0.094: v1(34.41,81.29) 34.03,81.67 33.94,81.67 33.57,81.31 33.57,80.49 32.84,79.76 32.15,79.76 31.3,78.9 30.21,78.9 30.12,78.81 30.12,78.68 v1(30.35,78.44)
  BOTTOM w0.104: UT1.Y11 30.53,78.12 30.35,78.29 v1(30.35,78.44)
CPU_DP1_CTRL_CLK: length 192.6
  TOP w0.127: v1(171.33,87.57) 171.33,87.57 171.51,87.57 171.57,87.62 RC503.1
  IN4 w0.084: v1(30.35,80.4) 31.14,80.4 31.23,80.48 31.23,83.31 31.69,83.77 32.41,83.77 32.69,84.05 32.69,84.56 33.81,85.68 35.06,85.68 38.34,88.96 38.34,91.88 37.85,92.36 37.85,98.94 39.81,100.9 43.88,100.9 49.78,106.79 50.49,106.79 52.49,108.79 60.9,108.79 62.52,107.17 63.56,107.17 66.03,109.63 78.03,109.63 78.24,109.85 87.27,109.85 88.32,110.9 88.32,111.39 88.78,111.85 105.47,111.85 106.5,110.82 110.39,110.82 111.42,111.85 126.07,111.85 129.69,108.23 129.69,104.98 130.5,104.17 130.5,102.29 131.23,101.56 131.23,92.67 131.13,92.58 131.13,91.05 131.78,90.4 137.62,90.4 139.09,88.93 139.09,86.65 139.39,86.35 139.79,86.35 140.21,85.93 140.63,85.93 140.79,85.77 141.67,85.77 142,86.1 143.06,86.1 143.95,85.21 146.46,85.21 147.25,86 147.25,86.29 147.44,86.47 147.5,86.47 v1(147.8,86.77) 147.87,86.77 148.36,86.27 148.36,85.89 148.83,85.42 152.45,85.42 154.09,87.06 154.09,87.77 154.64,88.32 159.05,88.32 159.09,88.28 160.51,88.28 161.51,87.28 166.3,87.28 166.4,87.38 168.14,87.38 168.54,86.99 170.6,86.99 171.06,87.45 171.21,87.45 v1(171.33,87.57)
  BOTTOM w0.089: v1(147.8,86.77) UC1.CC8
  BOTTOM w0.127: UT1.Y5 v1(30.35,80.4)
CPU_DP1_CTRL_DATA: length 196
  TOP w0.127: RC178.1 171.57,86.86 171.44,86.99 v1(171.33,86.99)
  IN4 w0.084: v1(27.75,81.04) 27.75,80.92 28.71,79.97 29.49,79.97 30.07,79.39 30.79,79.39 31.69,80.29 31.69,83.12 31.88,83.31 32.6,83.31 33.15,83.86 33.15,84.36 34,85.21 35.25,85.21 38.8,88.77 38.8,92.07 38.32,92.56 38.32,98.75 40,100.43 44.08,100.43 49.97,106.32 50.68,106.32 52.69,108.33 60.7,108.33 62.33,106.7 63.76,106.7 66.22,109.17 78.22,109.17 78.44,109.39 87.47,109.39 88.78,110.7 88.78,111.19 88.98,111.39 105.28,111.39 106.3,110.36 110.59,110.36 111.61,111.39 125.88,111.39 129.23,108.04 129.23,104.78 130.03,103.98 130.03,102.1 130.76,101.37 130.76,92.91 130.63,92.77 130.63,91.32 131.71,90.23 137.55,90.23 138.92,88.86 138.92,86.58 139.31,86.18 139.72,86.18 140.14,85.76 140.56,85.76 140.72,85.6 141.74,85.6 142.07,85.93 142.99,85.93 143.88,85.04 146.53,85.04 147.43,85.93 147.43,86.21 147.51,86.3 147.63,86.3 v1(147.8,86.13) 147.97,86.3 148.09,86.3 148.19,86.2 148.19,85.74 148.26,85.66 148.67,85.26 148.79,85.14 152.57,85.14 154.37,86.94 154.37,87.65 154.79,88.07 159.05,88.07 159.09,88.11 160.44,88.11 161.44,87.11 162.16,87.11 162.45,86.82 166.49,86.82 166.59,86.92 167.95,86.92 168.34,86.52 170.79,86.52 171.25,86.99 v1(171.33,86.99)
  BOTTOM w0.089: v1(147.8,86.13) UC1.CC9
  BOTTOM w0.127: UT1.R4 v1(27.75,81.04)
CPU_DP1_HPD: length 299.9
  TOP w0.127: v2(56.67,49.47) 56.67,49.79 v1(56.33,50.14)
  IN2 w0.102: v1(156.41,88.89) 156.87,89.36 160.33,89.36 162.44,87.24 165.17,87.24 167.01,89.08 169.23,89.08 169.41,89.26 v1(169.68,89.26)
  IN3 w0.122: v1(18.62,28.12) 17.44,29.31 17.44,33.42 19.8,35.79 19.8,45.04 20.86,46.11 20.86,47.35 22.26,48.75 22.26,51.81 22.87,52.41 22.87,54.98 24.45,56.57 24.45,56.59 24.46,56.6 24.46,56.84 24.93,57.3 24.93,59.52 26.2,60.8 26.2,63.71 25.46,64.46 25.46,68.93 26.02,69.5 33.56,69.5 34.63,68.43 35.42,68.43 35.79,68.8 35.79,69.23 36.46,69.9 36.46,72.12 36.78,72.45 36.78,75.55 37.63,76.4 37.63,77.77 36.72,78.68 36.72,83.45 36.05,84.12 35.29,84.12 v1(34.83,83.66) ; v1(56.33,50.14) 56.93,50.75 60.65,50.75 60.7,50.79 62.13,50.79 62.84,51.51 64.4,51.51 65.79,52.9 69.25,52.9 70.04,52.11 72.72,52.11 73.14,52.53 87.1,52.53 90.34,55.77 132.06,55.77 134.57,58.28 134.57,66.25 134.76,66.45 134.76,67.87 135.37,68.48 140.61,68.48 142.39,66.7 142.56,66.7 143.12,66.14 143.12,62.76 143.96,61.92 144.83,61.92 145.44,61.31 146.67,61.31 147.33,61.97 147.33,64.18 148.36,65.21 148.36,66.81 148.94,67.39 148.94,68.6 150.01,69.67 151.68,69.67 153.68,71.68 153.68,76.18 154.01,76.51 155.51,76.51 155.67,76.67 157.68,76.67 157.86,76.85 157.86,79.32 163.58,85.04 165,85.04 165.89,85.93 167.82,85.93 168.92,87.02 168.92,88.5 v1(169.68,89.26)
  IN4 w0.084: v1(18.62,28.12) 20.67,28.12 24.05,31.5 25.51,31.5 26.91,32.9 26.91,33.7 28.88,35.67 30.92,35.67 31.24,35.35 35.71,35.35 40.86,40.5 40.86,41.4 43.13,43.68 46.61,43.68 48.28,45.35 48.28,46.1 49.22,47.04 49.99,47.04 53.17,50.23 56.21,50.23 56.3,50.14 v1(56.33,50.14)
  BOTTOM w0.076: 32,83.43 31.79,83.23 31.79,83.15 31.46,82.82 31.29,82.82 31.16,82.69 31.16,82.31 UT1.AA2 ; v1(156.41,88.89) 156.08,88.56 155.69,88.56 155.64,88.61 154.06,88.61 153.86,88.54 153.86,88.53 153.79,88.5 153.78,88.5 153.36,88.33 153.11,88.33 152.85,88.07 UC1.CN6
  BOTTOM w0.127: 32,83.43 32.52,83.43 32.84,83.75 33.34,83.75 33.47,83.62 33.6,83.62 33.88,83.34 RT24.1 34.23,83.66 v1(34.83,83.66)
CPU_DP1_N0: length 134.9
  IN4 w0.094: v1(127.47,88.67) 127.47,88.48 127.38,88.39 127.19,88.39 127.1,88.48 127.1,89.11 127.32,89.34 127.32,90.04 127,90.37 127,97.84 127.6,98.45 127.6,102.08 124.97,104.71 124.97,105.11 121.03,109.06 112.56,109.06 111.58,108.08 103.51,108.08 102.9,108.68 91.93,108.68 89.98,106.73 83.43,106.73 82.58,105.88 77.98,105.88 77.19,105.08 71.47,105.08 70.44,106.11 64,106.11 63.74,105.85 61.98,105.85 60.69,107.14 53.64,107.14 48.2,101.7 46.98,101.7 44.95,99.67 44.95,98.98 43.68,97.71 43.68,92.31 43.1,91.74 43.1,88.56 39.63,85.09 39.63,83.58 39.32,83.27 37.81,83.27 36.06,81.52 35.26,81.52 35.06,81.72 35.06,81.94 35.15,82.04 35.3,82.04 35.39,82.13 v1(35.39,82.39)
  BOTTOM w0.089: v1(127.47,88.67) UC1.AL5
  BOTTOM w0.104: CT11.1 34.48,80.26 35.09,80.26 35.39,80.56 v1(35.39,82.39)
CPU_DP1_N0_C: length 3
  BOTTOM w0.076: UT1.AC7 31.74,79.77 arc(31.66,79.74) 31.62,79.66 arc(31.66,79.57) 31.74,79.54 32.18,79.54 32.35,79.71 32.78,79.71 33.45,80.38 33.69,80.38 CT11.2
CPU_DP1_N1: length 131.8
  IN4 w0.094: v1(35.36,79.76) 35.57,79.55 36.68,79.55 36.92,79.79 36.92,81.29 37.67,82.05 39.65,82.05 40.21,82.61 40.21,83.85 42.87,86.51 42.87,87.5 44.44,89.07 44.44,91.55 44.28,91.71 44.28,95.3 45.21,96.23 45.21,98.29 47.67,100.75 48.18,100.75 53.99,106.56 60.28,106.56 61.91,104.93 70.62,104.93 71.11,104.44 77.41,104.44 78.27,105.29 83.53,105.29 83.7,105.46 91.56,105.46 94.01,107.91 101.07,107.91 101.73,107.25 111.85,107.25 112.85,108.25 121.01,108.25 124.21,105.05 124.21,104.65 127.02,101.84 127.02,98.7 126.36,98.04 126.36,90.39 126.18,90.21 126.18,88.59 126.26,88.51 126.38,88.51 v1(126.55,88.68)
  BOTTOM w0.089: UC1.AJ5 v1(126.55,88.68)
  BOTTOM w0.104: CT13.1 34.58,79.5 34.58,79.5 35.09,79.5 v1(35.36,79.76)
CPU_DP1_N1_C: length 2.8
  BOTTOM w0.076: UT1.AC9 31.74,78.85 arc(31.66,78.88) 31.63,78.96 arc(31.67,79.04) 31.75,79.08 32.25,79.08 32.35,79.18 32.79,79.18 32.96,79.34 33.54,79.34 CT13.2
CPU_DP1_N2: length 130.2
  IN4 w0.094: v1(124.7,88.04) 125.09,88.23 125.26,88.4 125.26,89.93 125.73,90.4 125.73,100.25 124.52,101.46 124.52,103.19 123.56,104.15 123.56,104.88 121.52,106.92 112.39,106.92 112.08,106.61 101.23,106.61 100.53,107.3 94.29,107.3 91.81,104.82 84.13,104.82 84.02,104.71 78.94,104.71 77.98,103.76 70.68,103.76 70.27,104.17 65.64,104.17 65.22,103.76 62,103.76 60.35,105.41 55.96,105.41 54.57,104.01 52.6,104.01 45.88,97.29 45.88,95.96 44.86,94.94 44.86,91.99 45.02,91.84 45.02,88.83 43.45,87.26 43.45,86.26 40.8,83.61 40.8,82.34 39.92,81.46 38.17,81.46 37.68,80.98 37.68,79.38 36.55,78.25 35.11,78.25 35.04,78.31 34.9,78.31 v1(34.71,78.49)
  BOTTOM w0.089: v1(124.7,88.04) UC1.AF6
  BOTTOM w0.104: v1(34.71,78.49) 34.52,78.3 34.38,78.3 CT15.1
CPU_DP1_N2_C: length 2.5
  BOTTOM w0.076: CT15.2 33.39,78.26 33.15,78.26 33.04,78.16 31.75,78.16 arc(31.67,78.12) 31.63,78.04 arc(31.66,77.96) 31.74,77.93 UT1.AC11
CPU_DP1_N3: length 122.4
  IN4 w0.094: v1(123.78,88.67) 123.59,88.49 123.5,88.49 123.4,88.59 123.4,96.63 123.12,96.9 123.12,99.58 119.86,102.85 116.35,102.85 114.57,104.63 94.21,104.63 91.55,101.97 81.22,101.97 80.08,100.83 77.09,100.83 76.74,101.19 71.37,101.19 70.64,101.91 61.12,101.91 60.85,102.18 53.27,102.18 49.58,98.49 49.58,96.88 48.2,95.5 48.2,93.77 47.19,92.77 47.19,88.97 46.79,88.56 46.79,85.35 45.71,84.27 44.92,84.27 44.04,83.39 44.04,83.03 38.67,77.65 37.84,77.65 37.02,76.83 35.63,76.83 v1(35.39,77.06)
  BOTTOM w0.089: v1(123.78,88.67) UC1.AE5
  BOTTOM w0.104: CT17.1 34.21,76.9 35.23,76.9 v1(35.39,77.06)
CPU_DP1_N3_C: length 2.5
  BOTTOM w0.076: UT1.AC13 31.74,77.01 arc(31.66,77.04) 31.63,77.12 arc(31.67,77.2) 31.75,77.24 32.11,77.24 32.29,77.06 32.8,77.06 33.03,76.83 33.29,76.83 CT17.2
CPU_DP1_P0: length 134.9
  IN4 w0.094: v1(127.47,88.04) 127.3,88.2 127.12,88.2 126.92,88.4 126.92,89.19 127.14,89.41 127.14,89.97 126.82,90.29 126.82,97.92 127.42,98.52 127.42,102 124.79,104.63 124.79,105.04 120.95,108.88 112.63,108.88 111.65,107.89 103.43,107.89 102.83,108.49 92,108.49 90.05,106.55 83.51,106.55 82.66,105.69 78.06,105.69 77.26,104.9 71.39,104.9 70.36,105.93 64.07,105.93 63.81,105.67 61.91,105.67 60.62,106.95 53.72,106.95 48.28,101.52 47.05,101.52 45.13,99.59 45.13,98.9 43.86,97.64 43.86,92.24 43.29,91.66 43.29,88.48 39.82,85.01 39.82,83.51 39.4,83.09 37.89,83.09 36.14,81.34 35.19,81.34 34.88,81.65 34.88,82.32 v1(34.81,82.39)
  BOTTOM w0.089: v1(127.47,88.04) UC1.AL6
  BOTTOM w0.104: v1(34.81,82.39) 35.2,82 35.2,80.64 35.01,80.45 34.79,80.45 34.45,80.79 CT10.1
