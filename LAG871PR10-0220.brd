# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I_BATT_R: length 13
  TOP w0.127: UE1.J4 279.4,79.77 v1(279.4,79.74) ; RE64.1 CE3.1 277.58,69.88 v1(278.02,70.31)
  BOTTOM w0.127: v1(279.4,79.74) 279.02,79.35 279.02,78.36 278.58,77.93 278.58,75.16 278.01,74.59 278.01,72.26 277.48,71.73 277.48,70.44 277.6,70.31 v1(278.02,70.31)
I_SYS: length 306.9
  TOP w0.127: v2(49.93,47.14) 49.69,47.38 v1(49.69,47.77) ; v1(289.86,80.35) 289.96,80.45 289.96,82.21 RE312.2
  TOP w0.254: v1(58.17,54.92) 58.74,54.92 PR620.1 ; PR731.2 v1(49.69,47.77)
  IN3 w0.122: v1(49.69,47.77) 52.76,44.7 58.34,44.7 58.49,44.55 67.68,44.55 68.19,45.06 93.35,45.06 95.43,47.14 137.4,47.14 141.08,43.46 153.9,43.46 154.55,44.11 200.65,44.11 201.29,43.46 204.85,43.46 207.6,40.71 210.05,40.71 214.7,36.06 218.9,36.06 220.77,34.19 224.85,34.19 225.85,33.19 231.01,33.19 231.87,34.04 236.89,34.04 237.66,33.27 239.21,33.27 240.32,32.16 244.11,32.16 246.52,34.57 248.51,34.57 248.61,34.47 250.51,34.47 250.62,34.37 251.16,34.37 251.73,34.93 255.84,34.93 256.61,35.71 258.33,35.71 259.05,36.43 259.83,36.43 261.44,38.03 262.97,38.03 265.15,40.21 269.8,40.21 272.05,42.46 273.05,42.46 273.74,43.15 273.74,47.41 273.38,47.77 273.38,48.77 275.3,50.68 275.72,50.68 278.51,53.48 280.41,53.48 281.58,54.64 281.58,55.79 282.64,56.85 282.64,61.08 281.91,61.82 281.91,62.59 281.8,62.7 281.8,63.11 281.9,63.2 281.9,65.01 281.8,65.11 281.8,65.88 281.49,66.19 281.49,67.55 282.84,68.9 282.84,69.78 283.73,70.67 283.73,71.12 283.9,71.29 283.9,72.37 284.06,72.53 284.06,74.9 283.73,75.23 283.73,76.28 284.58,77.13 284.58,79.93 286.61,81.96 286.94,81.96 287.05,81.85 288.66,81.85 289.86,80.65 v1(289.86,80.35)
  IN4 w0.254: v1(58.17,54.92) 55.51,54.92 53.16,52.57 52.88,52.57 49.69,49.38 v1(49.69,47.77)
I_SYS_R: length 12.9
  TOP w0.127: 288.62,81.01 288.24,81.01 v1(287.89,81.35) ; 288.62,81.01 RE313.1 288.62,82.63 RE312.1 ; 288.62,81.01 CE4.1 ; v1(279.37,80.53) 279.02,80.89 UE1.J5
  IN4 w0.084: v1(279.37,80.53) 279.37,80.61 279.72,80.96 281.24,80.96 282.12,80.07 286.97,80.07 287.89,81 v1(287.89,81.35)
ILIM_SEL: length 2.6
  TOP w0.127: RI13.1 291.15,74.05 v2(291.15,74.76) 291.95,75.56 UI3.4
ILMT_1.05VALWP: length 4.9
  TOP w0.127: PR310.1 195.39,104.38 v2(195.18,104.17)
  TOP w0.254: PR310.1 PR307.2 195.03,106.45 195.03,106.45 194.83,106.64 194.83,107.38 194.64,107.57 194.64,107.86 194.46,108.04 PU301.13
ILMT_DDR: length 14.4
  TOP w0.127: v1(217.63,25.23) v2(217.63,24.43)
  TOP w0.254: v1(219.84,27.87) 220.05,27.87 220.37,28.2 PU200.17 ; PR205.2 PR207.1 v1(217.63,25.23)
  BOTTOM w0.254: v1(219.84,27.87) 221.57,27.87 221.86,27.58 221.86,26.44 222.15,26.14 222.15,24.25 221.91,24.01 217.99,24.01 217.63,24.37 v1(217.63,25.23)
IMON_A_GT: length 7.8
  TOP w0.203: PC625.2 72.9,55.67 72.9,55.68 72.28,56.29 v2(72.28,56.66) 72.28,56.9 72.42,57.04 72.42,57.89 71.9,58.41 PU602.14
  TOP w0.254: PC625.2 PR629.2
IMON_B_IA: length 5.5
  TOP w0.203: PU602.2 64.92,55.95 64.57,55.61 v2(62.74,55.61) 62.07,55.61 61.58,55.12 PC613.2 60.77,54.71 PR613.2
IMON_C_SA: length 7.4
  TOP w0.203: PU602.23 67.32,62.44 67.77,62.89 67.77,62.99 69.19,64.41 v2(70.03,64.41) 70.31,64.41 PC643.1 PR651.1
IMVP_VR_ON: length 170.7
  TOP w0.127: v2(57.59,54.98) 58.1,55.49 v1(58.36,55.49) 58.47,55.61 PR616.1
  IN1 w0.084: v1(156.69,68.91) 157.16,68.45 v1(159.84,68.45)
  IN2 w0.122: v1(57.43,49.76) 57.43,50.87 57.67,51.11 58.56,51.11 59.32,51.87 59.32,55.11 58.93,55.49 v1(58.36,55.49)
  IN3 w0.122: v1(156.69,68.91) 156.58,68.91 155.58,69.92 154.49,69.92 151.2,66.63 151.2,62.21 150.6,61.6 150.24,61.6 146.19,57.55 144.19,57.55 140.97,60.77 140.97,62.3 140.36,62.9 139.52,62.9 139.27,62.65 139.27,59.6 133.88,54.21 90.99,54.21 87.03,50.25 83.22,50.25 82.2,49.23 61.35,49.23 60.74,48.63 57.56,48.63 57.43,48.75 v1(57.43,49.76) ; v1(177.81,80.48) 177.65,80.48 176.56,81.56 176.56,82.06 176.22,82.41 176.22,82.73 176.06,82.89 175.61,82.89 175.3,82.57 174.01,82.57 173.46,83.13 167.29,83.13 166.52,82.35 164.7,82.35 163.01,80.66 163.01,76.77 162.75,76.51 162.75,74.93 162.55,74.73 162.55,72.55 160.6,70.6 160.6,69.11 159.94,68.45 v1(159.84,68.45)
  BOTTOM w0.127: v1(177.81,80.48) 178.42,80.48 178.55,80.35 UE3.4 178.55,79.64 178.77,79.42 179.92,79.42 180.22,79.72 RE304.1 181.02,79.72 182.59,81.3 UE4.2
IMVP_VR_ON_EC: length 191
  TOP w0.127: RE811.2 286.58,92.44 286.58,91.17 286.45,91.04 286.45,90.04 285.92,89.5 v1(285.92,88.92) ; UE1.N7 282.45,82.79 284.63,82.79 284.98,83.14 v1(284.98,83.22)
  IN1 w0.084: v1(275.97,88.05) 276.4,88.49 276.62,88.49 277.2,89.07 279.5,89.07 279.93,88.64 282.37,88.64 282.53,88.49 285.34,88.49 285.78,88.92 v1(285.92,88.92)
  IN2 w0.122: v1(285.92,88.92) 285.34,88.34 285.34,85.66 284.98,85.3 v1(284.98,83.22)
  IN3 w0.122: v1(180.31,78.66) 180.76,78.21 180.9,78.21 180.91,78.2 182.13,78.2 182.77,77.56 182.77,76.95 184.42,75.3 184.42,71.99 185.09,71.32 185.09,57.94 186.96,56.06 188.22,56.06 192.82,51.46 207.01,51.46 217.33,41.14 227.33,41.14 229.16,39.32 237.04,39.32 237.19,39.47 242.75,39.47 243.13,39.86 243.14,39.86 243.32,39.86 243.32,39.86 245.99,39.86 246.43,40.3 248.71,40.3 249.27,40.86 250.21,40.86 253.29,43.94 253.67,43.94 254.46,44.73 256.41,44.73 257.29,45.62 258.61,45.62 260.47,47.48 262.9,47.48 265.47,50.04 266.29,50.04 266.29,50.04 267.06,50.04 269.23,52.21 269.23,52.98 270.07,53.83 270.44,53.83 270.96,54.35 270.96,54.86 270.6,55.22 270.6,56.36 271.81,57.57 271.81,58.51 272.38,59.08 272.38,59.98 273.67,61.26 273.67,62.41 273.24,62.84 273.24,64.09 274.52,65.36 274.52,65.72 273.75,66.48 273.75,70.41 274.67,71.33 274.67,72.99 276.41,74.73 276.41,77.47 275.02,78.85 275.02,83.5 275.09,83.56 275.09,84.07 275.21,84.19 276.33,84.19 276.61,84.47 276.61,87.88 276.43,88.05 v1(275.97,88.05)
  BOTTOM w0.127: v2(180.5,77.32) 179.85,77.97 UE3.1 179.85,78.53 179.98,78.66 v1(180.31,78.66) 180.79,79.14 RE304.2
INPUT3VSEL: length 37.9
  TOP w0.127: v1(156.09,55.2) 156.09,54.73 156.58,54.24 156.58,53.5 v2(156.32,53.25) 154.44,51.37 RC451.1 RC452.2
  IN2 w0.076: v1(143.06,74.34) 142.67,73.95 142.67,71.7 142.33,71.36 142.33,70.88
  IN2 w0.102: 142.33,70.88 142.33,69.11 143.47,67.96 143.47,62.2 143.56,62.11 143.56,58.1 145.12,56.54 154.75,56.54 v1(156.09,55.2)
  BOTTOM w0.089: v1(143.06,74.34) 142.57,74.65 UC1.BT27
INT_SPK_L+: length 49.8
  TOP w0.127: v1(303.09,23.23) v3(304.03,23.23)
  IN4 w1.016: 302.04,22.76 301.09,22.76 295.7,28.15 295.15,28.15 293.21,30.09 290.86,30.09 290.04,29.27 286.38,29.27 285.49,30.16 282.9,30.16 278.83,34.22 278.83,35.65 276.77,37.71 276.77,46.38 278.33,47.94 281.13,47.94 282.07,47 282.07,46.16
  vias: v1(281.75,45.38) v1(281.75,44.77) v1(302.52,23.23)
INT_SPK_L-: length 41.5
  TOP w0.127: v3(303.19,24.82) 303.14,24.87 v1(302.27,24.87)
  IN4 w1.016: 301.37,24.63 296.3,29.71 295.75,29.71 293.85,31.61 290.22,31.61 289.4,30.79 287.01,30.79 286.12,31.68 283.53,31.68 280.36,34.86 280.36,36.28 278.29,38.34 278.29,45.75 278.96,46.41 280.43,46.41 280.73,46.12
  vias: v1(281.17,45.39) v1(281.18,44.83) v1(302.27,24.3)
INT_SPK_R+: length 38.1
  TOP w0.102: v1(299.15,23.3) v3(299.97,23.3)
  IN2 w1.016: 278.9,45.02 278.9,44.25 278.45,43.81 278.45,38.09 280.36,36.19 280.36,34.86 283.79,31.43 286.33,31.43 287.09,30.66 289.21,30.66 290.09,31.55 293.88,31.55 294.64,30.79 296.55,30.79 299.41,27.93 299.41,24.44
  vias: v1(279.22,45.46) v1(279.66,45.02) v1(298.58,23.3)
INT_SPK_R-: length 41.5
  TOP w0.102: v3(298.06,22.63) 297.61,23.08 v1(297.61,23.3)
  IN2 w1.016: 279.66,46.48 278.2,46.48 277.5,45.78 277.5,45.14 277.37,45.02 277.37,44.88 276.93,44.44 276.93,37.46 278.83,35.55 278.83,34.22 283.16,29.9 285.7,29.9 286.46,29.14 289.84,29.14 290.73,30.03 293.25,30.03 294.01,29.27 295.92,29.27 297.88,27.3 297.88,25.08 297.38,24.57
  vias: v1(280.1,45.52) v1(280.49,45.08) v1(297.03,23.3)
INT_SPKR_L+: length 8.9
  TOP w0.102: v1(303.07,15.77) v3(303.07,16.3)
  BOTTOM w1.016: 303.07,17.62 v1(303.07,15.77) 303.07,10.94 301.85,9.72
INT_SPKR_L-: length 8.8
  TOP w0.102: v3(301.54,15.46) v1(301.54,14.93)
  BOTTOM w1.016: 300.13,9.98 301.54,11.39 v1(301.54,14.93) 301.54,17.67
INT_SPKR_R+: length 8.1
  TOP w0.102: v1(298.74,14.31) v3(299.52,14.31)
  BOTTOM w1.016: 298.93,17.6 298.74,17.41 v1(298.74,14.31) 298.74,10.36
INT_SPKR_R-: length 8.2
  TOP w0.102: v1(297.25,14.31) v3(296.58,14.31)
  BOTTOM w1.016: 297.25,17.69 v1(297.25,14.31) 297.25,10.18
INTRUDER#: length 21.4
  TOP w0.127: v1(148.79,54.51) 149.38,53.92 RC69.1
  IN4 w0.084: v1(144.1,64.29) 144.6,63.79 144.6,61.87 144.79,61.68 144.79,55.01 144.93,54.86 148.44,54.86 v1(148.79,54.51)
  BOTTOM w0.076: UC1.BR35 142.09,69.58 142.09,69.1 142.11,69.04 142.11,68.68 142.09,68.62 142.09,67.51 143.28,66.33 143.28,65.11 v1(144.1,64.29)
IR_CAM_DET#: length 141.2
  TOP w0.127: v1(163.8,108.69) v3(163.01,108.69)
  IN1 w0.084: v1(169.39,75.93) 168.3,77.02 161.23,77.02 160.98,76.77 159.26,76.77 158.57,77.46 v1(157.47,77.46)
  IN2 w0.122: v1(168.4,101.35) 168.15,101.61 168.15,104.59 164.04,108.69 v1(163.8,108.69)
  IN3 w0.122: v1(157.47,77.46) 157.47,79.26 163.21,85 163.21,85.86 163.42,86.07 164.39,86.07 164.72,85.73 165.38,85.73 166.41,86.76 168.34,86.76 168.69,87.12 168.69,92.42 169.06,92.78 169.06,95.83 168.27,96.62 168.27,97.9 168.98,98.6 168.98,99.62 168.4,100.19 v1(168.4,101.35) ; v1(91.74,111) 93.04,109.69 102.03,109.69 103.33,110.99 105.3,110.99 106.1,110.2 110.74,110.2 112.95,112.4 138.19,112.4 138.97,111.62 141.82,111.62 142.6,112.4 145.47,112.4 147.1,110.77 149.2,110.77 149.81,111.38 152.93,111.38 153.95,112.4 161.07,112.4 162.25,111.22 162.25,109.59 163.15,108.69 v1(163.8,108.69)
  BOTTOM w0.076: 155.85,77.85 155.7,78.01 155.18,78.01 154.95,77.78 154.88,77.71 153.85,77.71 153.74,77.76 153.5,77.76 153.39,77.71 153.2,77.71 153.14,77.74 153.09,77.75 153.09,77.75 152.92,77.81 152.89,77.83 UC1.CN22
  BOTTOM w0.102: v1(157.47,77.46) 157.08,77.85 155.85,77.85
  BOTTOM w0.127: JIRTS1.5 91.52,111.21 v1(91.74,111) ; v1(169.39,75.93) 169.7,76.24 RC345.2
ISEN1_IA: length 68.7
  TOP w0.127: v2(87.23,75.9) 87.65,76.32 v1(87.76,76.32)
  TOP w0.203: PU602.9 67.72,55.96 68.46,55.21 v1(70.83,55.21)
  TOP w0.254: v1(70.83,55.21) 71.06,55.21 71.88,54.38 71.88,54.06 PC635.2 72.41,53.56 PR634.1 ; PR668.2 v1(88.33,90.35) ; PR670.2 87.8,76.35 v1(87.76,76.32)
  IN2 w0.254: v1(88.33,90.35) 85.73,87.75 85.73,77.53 86.94,76.32 v1(87.76,76.32)
  IN3 w0.254: v1(70.83,55.21) 70.59,55.21 70.04,54.67 70.04,53.78 70.53,53.3 72.23,53.3 73.84,54.91 80.51,54.91 89.85,64.24 89.85,65.91 89.07,66.68 87.19,66.68 86,67.88 86,73.35 87.76,75.11 v1(87.76,76.32)
ISEN1N_IA: length 24.6
  TOP w0.127: PR677.1 83.11,74.8 v3(82.77,74.45)
  TOP w0.254: v1(84.08,75.56) 83.88,75.36 PR677.1 ; v1(85.18,90.14) 84.76,90.14 83.93,89.31 PR666.1
  IN2 w0.254: v1(84.08,75.56) 84.08,75.81 84.4,76.13 84.4,85.02 83.19,86.23 82.68,86.23 82.3,86.61 82.3,87.99 84.45,90.14 v1(85.18,90.14)
  BOTTOM w0.254: PL610.2 85.24,90.08 v1(85.18,90.14)
ISEN1P_IA: length 5.7
  TOP w0.254: PR668.1 88.21,92.44 PR667.2 86.48,92.44 v2(85.61,91.57) 85.18,91.14 v1(85.18,90.86)
  BOTTOM w0.254: v1(85.18,90.86) 85.24,90.93 PL610.3
ISEN2_IA: length 40.6
  TOP w0.127: v2(85.03,73.55) 85.03,73.58 84.49,74.12 v1(84.46,74.12)
  TOP w0.203: PC638.2 73.23,53.56 PR615.1 71.15,55.64 v1(69.68,55.64) 68.54,55.64 68.12,56.07 PU602.10
  TOP w0.254: PR675.2 84.77,74.81 PR677.2 84.79,74.45 v1(84.46,74.12)
  IN2 w0.254: v1(69.68,55.64) 70.01,55.64 70.98,56.61 75.07,56.61 75.92,57.46 81.1,57.46 85.48,61.84 85.48,69.78 84.02,71.24 84.02,73.86 84.29,74.12 v1(84.46,74.12)
ISEN2N_IA: length 4.6
  TOP w0.127: v1(88.4,78.59) 88.78,78.59 v2(89.02,78.35)
  TOP w0.254: PR673.1 PR670.1 88.4,77.29 v1(88.4,78.59)
  BOTTOM w0.254: v1(88.4,78.59) 88.5,78.69 PL613.2
ISEN2P_IA: length 5.9
  TOP w0.254: v1(87.51,78.59) 87.51,77.97 v2(87.07,77.54) PR674.2 85.79,77.47 PR675.1
  BOTTOM w0.254: v1(87.51,78.59) 87.41,78.69 PL613.3
ISH_ACC1: length 8.8
  TOP w0.127: v1(145.89,62.93) 146.07,62.93 T395.1
  BOTTOM w0.076: UC1.BW35 144.64,69.61 144.64,69.39 144.6,69.28 144.6,69.09 144.64,68.98 144.64,68.74 144.61,68.66 144.61,67.61 146.11,66.12 146.11,65.12 146.36,64.87 146.36,63.06 146.23,62.93 v1(145.89,62.93)
ISH_ACC2: length 5.4
  BOTTOM w0.076: UC1.BW34 145.17,69.86 145.17,68.92 145.29,68.69 145.29,68.31 145.12,68.14 145.12,67.79 146.75,66.16 T396.1
ISH_ALS_INT#: length 291.7
  TOP w0.127: RV742.2 v2(98.75,109.38) 98.75,109.38 v1(97.12,111.01)
  IN3 w0.122: v1(97.12,111.01) 97.08,111.01 96.11,111.98 89.54,111.98 87.92,110.36 82.8,110.36 82.64,110.51 81.83,110.51 81.8,110.55 79.6,110.55 78.1,112.04 67.18,112.04 66.89,111.75 54.68,111.75 51.6,108.67 45.99,108.67 38.01,100.68 38.01,96.8 38.66,96.15 39.2,96.15 39.96,96.91 41.1,96.91 41.75,96.26 47.48,96.26 48.57,95.18 48.57,92.38 47.73,91.55 47.73,90.13 49.76,88.1 52.42,88.1 53.27,87.25 53.27,85.07 50.42,82.22 50.42,77.08 49.12,75.78 49.12,73.47 48.86,73.2 47.62,73.2 46.61,72.2 46.61,65.91 48.8,63.72 51.18,63.72 53.78,61.12 53.78,57.9 53.34,57.46 53.34,53.74 52.65,53.05 52.65,48.92 53.92,47.65 54.43,47.65 54.73,47.96 61.02,47.96 61.21,48.14 61.63,48.56 82.48,48.56 83.25,49.33 92.48,49.33 94.82,51.68 141.37,51.68 145.13,47.93 146.15,47.93 147.11,46.97 151.72,46.97 153.68,48.92 155.49,48.92 159.33,52.76 162.31,52.76 162.88,52.19 v1(163,52.19)
  IN4 w0.084: v1(163,52.19) 163,53.09 162.67,53.42 158.81,53.42 156.94,55.28 156.69,55.28 156.35,55.62 151.79,55.62 149.16,58.25 149.15,58.25 148.91,58.48 148.91,62.48 148.74,62.66 v1(148.17,62.66)
  BOTTOM w0.076: UC1.CA36 146.08,69.13 145.82,68.65 145.82,68.38 146.03,68.17 146.03,67.34 147.19,66.18 147.19,65.84 147.31,65.72 147.31,64.86 147.27,64.82 147.27,63.1 147.71,62.67 148.16,62.67 v1(148.17,62.66)
  BOTTOM w0.127: JIRTS1.12 v1(97.12,111.01)
ISH_I2C0_ACC_SCL: length 18.5
  TOP w0.127: v1(166.02,75.58) 166.48,75.11 T416.1
  IN1 w0.102: v1(150.22,78.51) 150.87,77.86 151.65,77.86 151.82,77.7 154.64,77.7 155.51,76.83 157.88,76.83 159.28,75.43 161.61,75.43 161.93,75.75 165.85,75.75 v1(166.02,75.58)
  BOTTOM w0.089: UC1.CH20 v1(150.22,78.51)
ISH_I2C0_ACC_SDA: length 15.8
  TOP w0.127: v1(164.87,74.99) 164.88,74.98 T415.1
  IN1 w0.102: v1(151.49,77.47) 154.6,77.47 155.43,76.64 157.8,76.64 159.26,75.18 161.74,75.18 161.99,75.43 164.42,75.43 v1(164.87,74.99)
  BOTTOM w0.089: v1(151.49,77.47) UC1.CK22
ISH_I2C1_ALS_SCL: length 82.3
  TOP w0.127: v1(96.32,111) 96.32,110.8 96.97,110.15 96.97,109.72 97.34,109.34 DZ21.2 97.34,108.63 97.76,108.21 97.76,106.8 v1(97.99,106.57) 97.99,106.61 98.56,107.18 98.56,107.53 98.91,107.88 RV741.2
  IN2 w0.089: v1(150.86,77.47) 150.18,78.15 148.8,78.15 148.27,78.68 148.27,79.13 147.59,79.8 146.83,79.8 145.79,80.84 145.79,83.69 145.3,84.17 144.81,84.17 144.76,84.22 143.42,84.22 143.12,84.52 143.12,86.58 142.8,86.9 142.8,89.09 142.24,89.66 142.24,92.41
  IN2 w0.122: v1(97.99,106.57) 98.38,106.17 102.55,106.17 103.39,105.34 110.06,105.34 110.09,105.3 110.12,105.3 113.39,102.04 121.74,102.04 122.63,102.93 128.72,102.93 130.83,100.81 133.31,100.81 133.55,100.57 133.68,100.57 134.15,100.1 137.83,100.1 139.77,98.17 139.77,95.01 141.12,93.65 141.38,93.65 142.24,92.79 142.24,92.41
  BOTTOM w0.089: v1(150.86,77.47) UC1.CJ22
  BOTTOM w0.127: JIRTS1.11 v1(96.32,111)
ISH_I2C1_ALS_SDA: length 83.7
  TOP w0.127: RV740.2 98.99,107.25 98.48,106.73 98.48,106.47 98.18,106.17 97.76,106.17 v1(97.35,106.57) 97.5,106.72 97.5,108.11 97.1,108.52 96.97,108.52 96.34,109.14 DZ21.3 96.34,109.34 96.72,109.72 96.72,110.04 95.76,111 v1(95.76,111)
  IN2 w0.089: v1(150.22,77.47) 150.22,77.85 150.11,77.97 148.73,77.97 148.09,78.61 148.09,79.05 147.52,79.62 146.75,79.62 145.61,80.77 145.61,83.61 145.23,83.99 144.73,83.99 144.68,84.05 143.35,84.05 142.94,84.45 142.94,86.51 142.63,86.83 142.63,89.02 142.06,89.58 142.06,92.27 141.99,92.34 141.99,92.41
  IN2 w0.122: v1(97.35,106.57) 98,105.92 102.45,105.92 103.29,105.09 109.95,105.09 109.99,105.06 110.02,105.06 113.29,101.79 121.84,101.79 122.73,102.68 128.61,102.68 130.73,100.57 133.21,100.57 133.45,100.32 133.57,100.32 134.04,99.85 137.73,99.85 139.52,98.06 139.52,94.91 141.02,93.4 141.28,93.4 141.99,92.69 141.99,92.41
  BOTTOM w0.089: v1(150.22,77.47) UC1.CH22
  BOTTOM w0.127: v1(95.76,111) 95.52,111.24 JIRTS1.10
ISH_I2C2_SCL: length 170.7
  TOP w0.127: RZ76.1 276.1,61.11 276.1,60.52 276.31,60.31 v1(276.64,60.31)
  IN1 w0.084: v1(276.64,60.31) 275.6,59.27 275.6,57.82 276,57.42 276.4,57.42 277.52,56.3 277.52,51.42 275.09,48.99 275.09,47.74 274.44,47.09 273.62,47.09 271.44,44.91 271.19,44.91 270.38,44.1 270.38,40.68 269.44,39.75 268.34,39.75 267.95,39.36 266.11,39.36 264.39,37.63 258.37,37.63 256.85,36.12 252.57,36.12 252.08,36.61 246.68,36.61 246.05,35.98 243.75,35.98 242.75,36.97 230.24,36.97 228.96,35.69 220.19,35.69 217.52,38.35 214.71,38.35 198.67,54.39 194,54.39 192.6,55.79 191.69,55.79 188.66,58.82 188.66,60.74 185.74,63.67 185.74,64.13 182.1,67.77 180.67,67.77 178.94,69.49 178.94,70.22 175,74.16 170.87,74.16 168.92,72.21 167.75,72.21 v1(167.69,72.16) 167.61,72.24 167.46,72.24 167.14,71.92 166.37,71.92 165.66,72.64 165.66,73.02 165.36,73.32 162.35,73.32 162.29,73.38 161.99,73.38 161.15,72.53 152.94,72.53 151.82,73.65 151.66,73.65 v1(151.23,73.22)
  BOTTOM w0.089: UC1.CJ29 v1(151.23,73.22)
  BOTTOM w0.127: v1(167.69,72.16) 167.73,72.19 168.2,72.19 RC362.1
ISH_I2C2_SCL_R: length 2.6
  TOP w0.127: RZ76.2 276.42,62.54 v1(276.74,62.86)
  BOTTOM w0.127: v1(276.74,62.86) 276.74,63.23 276.93,63.42 JNGFF2.40
ISH_I2C2_SDA: length 169.6
  TOP w0.127: RZ77.1 277.08,61.28 v1(276.66,60.87)
  IN1 w0.084: v1(276.66,60.87) 276.54,60.87 275.13,59.46 275.13,57.63 275.81,56.95 276.21,56.95 277.05,56.11 277.05,51.62 274.09,48.65 274.09,48.21 271.25,45.38 271,45.38 269.91,44.29 269.91,40.88 269.25,40.21 268.15,40.21 267.76,39.82 265.91,39.82 264.19,38.1 258.17,38.1 256.66,36.58 252.76,36.58 252.27,37.07 246.48,37.07 245.86,36.44 243.94,36.44 242.94,37.44 230.05,37.44 228.76,36.15 220.38,36.15 217.72,38.82 214.9,38.82 198.87,54.86 194.19,54.86 192.79,56.25 191.88,56.25 189.12,59.01 189.12,60.94 186.2,63.86 186.2,64.33 182.3,68.23 180.86,68.23 179.41,69.68 179.41,70.41 175.19,74.63 170.67,74.63 168.73,72.68 167.75,72.68 v1(167.69,72.74) 167.65,72.7 167.27,72.7 166.95,72.38 166.57,72.38 166.12,72.83 166.12,73.21 165.55,73.78 162.54,73.78 162.48,73.84 162.11,73.84 161.75,73.48 161.75,73.38 161.07,72.7 153.01,72.7 v1(151.23,74.49)
  BOTTOM w0.089: UC1.CJ27 v1(151.23,74.49)
  BOTTOM w0.127: v1(167.69,72.74) 167.73,72.7 168.2,72.7 RC363.1
ISH_I2C2_SDA_R: length 2.5
  TOP w0.127: v1(277.36,62.86) 277.08,62.58 RZ77.2
  BOTTOM w0.127: v1(277.36,62.86) 277.43,62.93 JNGFF2.42
ISH_LID_CL#_NB: length 10.5
  TOP w0.127: v1(148.17,62.08) 147.64,62.62 T376.1
  BOTTOM w0.076: v1(148.17,62.08) 147.91,62.08 147.11,62.89 147.11,64.89 147.15,64.93 147.15,65.65 147.03,65.77 147.03,66.11 145.85,67.29 145.85,68.12 145.65,68.31 145.65,68.69 145.79,68.93 145.79,69.88 UC1.CA34
ISH_LID_CL#_TAB: length 8.2
  TOP w0.127: v1(145.89,62.37) 146.25,62.01 T377.1
  BOTTOM w0.076: UC1.BW37 144.8,68.46 144.8,67.66 146.27,66.19 146.27,65.19 146.54,64.91 146.54,62.45 146.47,62.37 v1(145.89,62.37)
ISH_NB_MODE: length 4.5
  BOTTOM w0.076: UC1.CA35 146.35,69.57 146.35,69.09 146.3,68.98 146.3,68.74 146.38,68.53 146.38,67.45 147.46,66.36 147.68,66.14 T375.1
ISH_P_SENSOR_INT#: length 291.4
  TOP w0.127: RV744.2 100.18,110.48 98.94,110.48 98.72,110.7 v1(98.72,111.01) ; v1(159.65,58.79) 159.65,57.84 160.04,57.45 160.04,54.29 v2(160.71,53.61) v1(162.13,52.2)
  IN3 w0.122: v1(98.72,111.01) 97.06,112.67 88.31,112.67 86.38,110.74 81.92,110.74 81.59,111.07 79.53,111.07 78.34,112.26 67.09,112.26 66.81,111.98 54.59,111.98 51.5,108.89 45.84,108.89 37.78,100.84 37.78,96.71 38.56,95.93 39.29,95.93 40.05,96.69 41.01,96.69 41.66,96.04 47.39,96.04 48.34,95.09 48.34,92.48 47.5,91.64 47.5,90.04 49.67,87.87 52.33,87.87 53.04,87.15 53.04,85.16 50.2,82.32 50.2,77.17 48.9,75.88 48.9,75.18 47.8,74.08 47.8,73.78 46.39,72.37 46.39,65.82 48.73,63.48 49.63,63.48 52.08,61.03 52.08,59.08 53.12,58.05 53.12,53.83 52.43,53.14 52.43,48.83 53.83,47.43 54.52,47.43 54.83,47.73 61.12,47.73 61.72,48.34 82.57,48.34 83.34,49.11 92.57,49.11 94.92,51.46 141.24,51.46 145,47.7 146.06,47.7 147.02,46.75 151.82,46.75 153.77,48.7 155.58,48.7 158.75,51.87 161.42,51.87 161.75,52.2 v1(162.13,52.2)
  BOTTOM w0.076: UC1.BW36 144.87,69.13 145.13,68.65 145.13,68.38 144.96,68.21 144.96,67.73 146.43,66.25 146.43,65.26 146.71,64.98 146.71,62.39
  BOTTOM w0.102: 146.71,62.39 146.71,62.23 147.92,61.02 153.17,61.02 154.56,59.62 156.15,59.62 157.36,58.41 159.39,58.41 159.65,58.67 v1(159.65,58.79)
  BOTTOM w0.127: JIRTS1.14 v1(98.72,111.01)
ISH_TABLE_MODE#: length 7.7
  TOP w0.127: v1(148.17,63.23) 147.95,63.23 147.57,63.61 T397.1
  BOTTOM w0.076: 147.44,63.96 147.43,63.97 147.43,64.75 147.47,64.79 147.47,65.78 147.35,65.9 147.35,66.24 146.2,67.39 146.2,68.41 UC1.CA37
  BOTTOM w0.102: v1(148.17,63.23) 148.12,63.18 147.71,63.18 147.44,63.44 147.44,63.96
ISH_UART0_CTS#_R: length 7
  TOP w0.127: v1(268.2,36.95) 268.57,37.32 RZ80.2 268.81,37.2 268.81,37.07 268.93,36.95 269.96,36.95 v2(270.19,36.72)
  BOTTOM w0.127: v1(268.2,36.95) 267.71,36.95 265.53,39.13 JNGFF1.62
ISH_UART0_RXD_R: length 5.4
  TOP w0.127: v2(267.71,38.36) 267.89,38.54 v1(268.17,38.54) 268.39,38.54 RZ78.2
  BOTTOM w0.127: JNGFF1.58 266,40.13 267.59,38.54 v1(268.17,38.54)
ISH_UART0_TXD_R: length 4.8
  TOP w0.127: v1(268.17,37.98) 268.59,37.98 RZ79.2
  BOTTOM w0.127: v1(268.17,37.98) 267.82,37.98 266.17,39.63 JNGFF1.60
ISUMN_A_GT: length 7.7
  TOP w0.203: PU602.20 69.13,60.81 69.87,61.55
  TOP w0.254: PR640.1 73.41,65.46 PC630.1 73.32,65.47 72.8,64.95 72.8,64.4 v2(72,63.61) 69.94,61.55 69.87,61.55
ISUMN_B_IA: length 13.4
  TOP w0.203: PU602.8 67.32,55.79 68.32,54.78 v2(70.16,54.78) 71.02,54.78 71.43,54.37 v1(71.43,54.15) PR638.2
  TOP w0.254: v1(72.18,49.75) 72.28,49.64 73.21,49.64 73.81,50.24 PC627.2
  IN1 w0.254: v1(72.18,49.75) 71.43,50.5 v1(71.43,54.15)
ISUMN_C_SA: length 6.2
  TOP w0.203: PU602.28 65.32,62.45 64.93,62.83 64.93,63.26 64.11,64.09 64.11,64.41 v2(63.89,64.62) 63.06,65.45 PR636.1 62.52,65.45 PC632.1
ISUMN_GT: length 24.8
  TOP w0.127: v1(84.78,68.13) v2(85.45,68.13)
  TOP w0.254: PR640.2 75.65,65.46 PC645.1 76.22,64.89 78.3,64.89 v1(78.49,65.08) ; PR640.2 75.15,65.86 74.72,66.29 PR644.2 ; PR640.2 75.15,64.64 PC646.2 PR656.2 PC642.2
  IN1 w0.254: v1(84.78,68.13) 84.78,68.45 84.59,68.64 82.62,68.64 79.06,65.08 v1(78.49,65.08)
  BOTTOM w0.254: PL612.2 84.97,69.59 84.78,69.4 v1(84.78,68.13) 84.78,66.97 85.03,66.72 PH605.2
ISUMN_IA: length 65.4
  TOP w0.127: v1(88.61,75.68) 88.61,75.46 v2(88.91,75.17)
  TOP w0.254: PC641.1 71.98,50.81 PR632.1 ; v1(88.61,75.68) 89.24,76.31 PR673.2 ; v1(82.81,87.31) 82.81,87.8 PR666.2 ; PC635.1 PR638.1 71.39,52.61 PR633.2 70.5,52.69 PC626.2 v1(70.5,54.24) ; PC635.1 72.45,52.65 72.9,52.19 74.75,52.19 75.51,52.95 75.51,53.65 75.24,53.92 74.56,53.92 PC638.1 ; PC635.1 71.98,52.25 PR632.1 ; PR632.1 71.15,51.63 PC624.2
  IN2 w0.254: v1(82.81,87.31) 83.95,87.31 85.38,85.88 85.38,77.38 86.89,75.86 88.43,75.86 v1(88.61,75.68) 88.61,75.39 86.67,73.45 86.67,61.96 81.37,56.66 76.13,56.66 75.36,55.9 72.5,55.9 71.33,54.73 70.99,54.73 v1(70.5,54.24)
  BOTTOM w0.254: v1(82.81,87.31) 82.32,86.82 PH602.2
ISUMN_SA: length 54
  TOP w0.203: PR643.2 64.37,69.64 PC637.2 63.44,69.65 PC633.2 62.93,69.67 62.14,68.87 PR641.2 62.94,68.69 PC644.1 62.99,67.89 63.48,67.39 63.48,66.92 PR636.2
  TOP w0.254: v1(70.07,72.5) 69.33,71.77 v2(69.33,71.54) 68.18,70.39 66.4,70.39 65.66,69.64 PR643.2
  IN1 w0.254: v1(89.92,87.94) 89.92,88.83 89.68,89.07 87.57,89.07 84.47,85.97 82.49,85.97 81.67,86.8 76.84,86.8 75.44,85.4 74.56,85.4 72.46,83.31 71.13,83.31 70.3,82.48 70.3,73.81 70.55,73.55 70.55,72.99 v1(70.07,72.5)
  BOTTOM w0.254: v1(89.92,87.94) PH604.2 90.54,90.21 90.94,90.61 92.91,90.61 93.04,90.48 PL614.2
ISUMP_GT: length 25
  TOP w0.203: PC642.1 72.91,63.66 70.42,61.17 70.13,61.17 69.37,60.41 PU602.19
  TOP w0.254: PC642.1 PR656.1 PC646.1 75.15,63.6 76.37,63.6 PR653.2 76.71,63.25 v1(78.23,63.25) ; PR657.1 v2(86.09,66.8) 85.38,66.8 84.4,67.77 84.4,67.87 v1(84.12,68.15) PR661.2
  IN1 w0.254: v1(84.12,68.15) 82.71,68.15 78.49,63.94 78.23,63.67 v1(78.23,63.25)
ISUMP_IA: length 64.3
  TOP w0.127: v1(85.79,75.43) 85.79,75.05 v2(86.1,74.73)
  TOP w0.203: PU602.7 66.92,55.58 68.14,54.35 69.22,54.35 v1(69.28,54.29)
  TOP w0.254: PR628.1 83.12,86.2 v1(83.12,86.8) 83.12,86.97 83.46,87.31 84.16,87.31 84.41,87.56 84.41,88.72 86.73,91.04 PR667.1 ; v1(69.28,54.29) 69.58,53.99 PC626.1 69.58,52.69 PR633.1 70.19,52.08 PC624.1 69.37,50.77 PR658.2 ; PR674.1 v1(85.79,75.43)
  IN2 w0.254: v1(83.12,86.8) 83.96,86.8 85.02,85.74 85.02,77.23 86.12,76.13 86.12,75.77 v1(85.79,75.43) 86.32,74.9 86.32,62.11 81.22,57.02 75.98,57.02 75.22,56.25 71.19,56.25 69.28,54.35 v1(69.28,54.29)
ISUMP_SA: length 56.8
  TOP w0.203: v1(63.1,64.76) 61.92,64.76 61.28,65.4 61.28,68.73 63.14,70.58 PC633.1 63.44,70.57 PC637.1 65.22,70.57 PR643.1 ; v1(65.5,63.68) 65.5,62.7 65.72,62.48 PU602.27
  TOP w0.254: v1(70.05,73.17) 67.68,70.81 v2(67.11,70.81) 65.48,70.81 PR643.1 ; v1(89.6,90.35) 89.85,90.61 PR624.2 90.63,90.27 PR642.1
  IN1 w0.254: v1(89.6,90.35) 89.6,90.35 89.6,89.72 89.35,89.47 87.32,89.47 84.19,86.34 82.7,86.34 81.83,87.21 76.75,87.21 75.32,85.78 74.36,85.78 72.27,83.69 70.94,83.69 69.92,82.67 69.92,73.3 v1(70.05,73.17)
  IN2 w0.203: v1(63.1,64.76) 64.42,64.76 v1(65.5,63.68)
ITP_PMODE: length 76
  TOP w0.127: v1(103.11,99.87) v2(103.11,100.46) 103.11,100.64 RC125.1
  IN1 w0.084: v1(60.9,98.15) 60.9,98.35 61.2,98.65 71,98.65 71.24,98.89 73,98.89 75.05,96.84 81.05,96.84 82.01,97.81 83.72,97.81 83.93,98.03 91.14,98.03 91.57,98.46 94.22,98.46 94.83,99.07 98.36,99.07 99.43,100.15 99.67,100.38 102.11,100.38 102.62,99.87 v1(103.11,99.87)
  IN1 w0.102: v1(119.43,92.96) 119.81,93.34 119.81,98.1 118.88,99.02 118.02,99.02 116.99,100.05 113.27,100.05 112.91,99.69 107.49,99.69 106.81,100.37 104.12,100.37 103.62,99.87 v1(103.11,99.87)
  BOTTOM w0.076: 119.73,92.65 119.81,92.58 119.81,91.54 119.66,91.39 119.66,91.05 119.69,90.95 119.69,90.73 119.66,90.63 119.66,90.38 119.8,90.04 119.8,89.73 120.08,89.45 UC1.W4
  BOTTOM w0.114: 119.73,92.65 v1(119.43,92.96)
  BOTTOM w0.127: JXDP1.46 60.38,98.88 60.51,98.75 60.53,98.75 60.9,98.39 v1(60.9,98.15)
JDIMM1_EVENT#: length 7
  TOP w0.127: RD14.1 94.39,27.11 v1(94.13,27.38)
  IN2 w0.122: v1(90.64,29.76) 90.64,28.92 92.18,27.38 v1(94.13,27.38)
  BOTTOM w0.127: JDIMM1.134 90.71,29.83 v1(90.64,29.76)
JDIMM2_EVENT#: length 78.5
  TOP w0.127: v1(96.2,28.39) 95.34,28.39 RD27.1 94.69,27.45 v2(95.33,26.8)
  IN4 w0.084: v1(167.68,29.8) 167.23,30.25 129.88,30.25 126.8,27.17 116.21,27.17 115.83,26.79 113.48,26.79 111.33,28.95 96.77,28.95 96.21,28.39 v1(96.2,28.39)
  BOTTOM w0.107: v1(167.68,29.8) 167.91,30.03 JDIMM2.134
JTAG_CLK: length 29.1
  TOP w0.127: v1(273.82,83.85) 273.82,83.75 UE1.C8 ; v1(294.52,89.08) 295.16,89.72 RE815.2
  IN1 w0.084: v1(273.82,83.85) 274.04,83.85 274.35,84.16 275.16,84.16 275.18,84.13 275.98,84.13 275.99,84.13 276.01,84.13 276.05,84.16 276.35,84.16 276.39,84.13 276.52,84.13 276.55,84.16 277.22,84.16 278.36,83.01 282.06,83.01 282.51,82.56 283.88,82.56 284.08,82.36 286.1,82.36 287.04,83.3 288.98,83.3 290.1,84.42 290.72,84.42 292.02,85.72 293.5,85.72 v1(294.52,86.73)
  IN2 w0.122: v1(294.52,86.73) v1(294.52,89.08)
  BOTTOM w0.127: v1(294.52,89.08) 295.85,89.08 JDEG1.4
JTAG_RST#: length 13.3
  TOP w0.127: UE1.G13 277.24,87.36 276.87,87.74 276.87,89.59 276.07,90.39 276.07,92.74 v2(274.87,93.94) 274.05,94.76 JTAG1.1 273.99,96.32 CE30.1 RE65.1 RE63.1
JTAG_TDI: length 30.3
  TOP w0.127: v1(293.76,88.2) 293.24,88.72 v2(293.24,89.58) 293.24,90.09 294.53,91.39 294.53,92.28 294.77,92.52 295.27,92.52 RE813.2 ; v1(275.38,84.6) UE1.E9
  IN1 w0.084: v1(293.76,88.2) 293.26,87.7 290.83,87.7 290.46,87.33 290.46,85.99 290.2,85.73 286.02,85.73 285.52,85.23 282.48,85.23 281.82,85.89 280.78,85.89 280.61,85.72 279.31,85.72 279.25,85.78 277.19,85.78 277.19,85.78 276.93,85.78 276.55,85.4 276.55,85.08 276.43,84.97 275.99,84.97 275.72,84.7 275.72,84.68 275.64,84.6 v1(275.38,84.6)
  BOTTOM w0.127: JDEG1.2 294.69,88.09 294.58,88.2 v1(293.76,88.2)
JTAG_TDO: length 35.5
  TOP w0.102: v1(276.24,81.38) UE1.F6
  TOP w0.127: RE816.2 294.93,91.37 293.77,90.21 v1(293.77,89.86) ; v2(275.74,90.34) 276.37,89.71 v1(276.37,89.38)
  IN1 w0.084: v1(276.37,89.38) 276.78,89.79 280.04,89.79 280.66,90.42 281.68,90.42 282.31,89.79 283.63,89.79 283.75,89.91 286.51,89.91 286.64,90.03 288.45,90.03 289.98,88.51 292.42,88.51 v1(293.77,89.86)
  IN3 w0.122: v1(276.24,81.38) 276.28,81.38 276.65,81.75 276.65,82.69 276.64,82.71 276.64,84.03 276.75,84.14 277.36,84.14 277.6,84.38 277.6,87.61 276.96,88.24 276.96,88.79 v1(276.37,89.38)
  BOTTOM w0.127: JDEG1.5 294.04,89.59 v1(293.77,89.86)
JTAG_TMS: length 46.4
  TOP w0.127: RE814.2 294.6,90.54 v2(294.47,90.42) 294.24,90.19 294.24,89.68 293.88,89.32 v1(293.88,89.08) ; v1(273.82,80.56) UE1.C5
  IN1 w0.084: v1(268.25,87.62) 268.58,87.95 270.96,87.95 271.3,87.61 272.37,87.61 272.65,87.89 273.59,87.89 274.74,89.04 275.73,89.04 275.9,88.86 276.46,88.86 277.21,89.6 280.11,89.6 280.74,90.23 281.6,90.23 282.79,89.04 284.89,89.04 285.57,89.72 286.58,89.72 286.71,89.85 288.38,89.85 289.9,88.32 292.52,88.32 293.26,89.06 293.86,89.06 v1(293.88,89.08)
  IN3 w0.122: v1(268.25,87.62) 268.08,87.46 268.08,85.83 268.72,85.19 268.95,84.97 272.1,84.97 272.58,84.49 272.58,80.68 272.71,80.56 v1(273.82,80.56)
  BOTTOM w0.127: JDEG1.3 294.38,88.59 v1(293.88,89.08)
KB_DET#: length 131.2
  TOP w0.127: v1(167.81,71.05) 167.81,71.6 167.94,71.72 RC288.1 ; v1(244.19,33.7) v3(244.19,34.41)
  IN1 w0.084: v1(151.46,75.4) 150.82,74.76 150.82,72.85 150.9,72.76 152.46,72.76 152.87,72.36 161.46,72.36 162.19,73.08 164.74,73.08 165.16,72.66 165.34,72.66 166.95,71.05 v1(167.81,71.05)
  IN2 w0.122: v1(167.81,71.05) 167.29,70.53 167.29,68.23 167.77,67.75 167.96,67.75 168.32,67.39 168.32,67.2 169.11,66.41 170.06,66.41 170.34,66.7 173.23,66.7 174.46,65.47 176.04,65.47 177.86,63.66 178.95,63.66 179.35,63.25 181.63,63.25 182.32,62.56 182.32,61.8 182.01,61.49 182.01,60.57 182.7,59.89 186.92,59.89 189.4,62.36 191.79,62.36 192.19,62.77 195.06,62.77 196.92,60.91 196.92,59.91 201.18,55.65 201.18,46.35 203.89,43.64 206.25,43.64 208.16,41.74 212.03,41.74 217.39,36.37 218.61,35.15 239.86,35.15 239.97,35.04 243.64,35.04 244.19,34.49 v1(244.19,33.7)
  BOTTOM w0.089: v1(151.46,75.4) 151.35,75.8 UC1.CK25
  BOTTOM w0.127: JKBTP1.1 245.08,34.05 CZ84.1 244.57,34.08 v1(244.19,33.7)
LAN_WAKE#: length 184.9
  TOP w0.102: UE1.L3 281.03,78.95 v1(281.03,78.87)
  TOP w0.127: RC323.1 158.65,59.46 158.65,59.28 159.09,58.85 v1(159.09,58.79) ; v1(143.93,71.31) v2(143.93,70.34)
  IN3 w0.122: v1(159.09,58.79) 159.14,58.74 159.14,58.6 159.52,58.22 161.49,58.22 161.93,57.78 166.95,57.78 167.95,58.78 169.71,58.78 170.38,59.44 173.96,59.44 175.43,57.97 182.14,57.97 190.28,49.82 196.46,49.82 197.13,50.49 200.22,50.49 200.79,49.92 207.29,49.92 216.96,40.25 225.44,40.25 227.27,38.42 237.41,38.42 237.56,38.58 243.12,38.58 243.51,38.96 246.36,38.96 246.81,39.41 250.02,39.41 253.66,43.05 255.99,43.05 256.76,43.81 258.32,43.81 261.09,46.58 265.92,46.58 267.82,48.47 267.82,49.85 269.9,51.94 269.9,52.71 270.35,53.16 270.72,53.16 271.83,54.27 271.83,56.6 272.37,57.14 273.06,57.83 273.06,58.77 273.39,59.1 273.59,59.1 273.79,59.29 273.79,60.32 274.53,61.07 274.53,64.43 275.19,65.09 275.19,68.63 275.93,69.38 275.93,70.5 277.41,71.98 277.67,71.98 278.01,72.32 278.01,72.33 278.04,72.36 278.04,74.32 279.47,75.75 280.59,75.75 280.78,75.94 280.78,76.35 280.36,76.77 280.36,77.53 280.68,77.84 280.68,78.52 v1(281.03,78.87)
  IN4 w0.102: v1(159.09,58.79) 159.09,58.85 154,63.93 153.24,63.93 151.58,65.59 151.22,65.59 149.82,67 146.78,67 146.09,67.68 146.09,68.22 144.39,69.92 144.39,70.57 143.93,71.02 v1(143.93,71.31)
  BOTTOM w0.089: UC1.BU32 v1(143.93,71.31)
LCD_CBL_DET#: length 184.7
  TOP w0.127: v1(170.38,81.21) 170.38,80.83 v3(170.03,80.49)
  IN1 w0.102: v1(148.95,83.7) 149.41,83.24 149.9,83.24 149.96,83.3 151.67,83.3 152.03,82.95 152.53,82.95 153.62,81.86 156.78,81.86 156.86,81.78 162.21,81.78 162.68,82.26 165.93,82.26 166.97,81.22 170.37,81.22 v1(170.38,81.21)
  IN2 w0.122: v1(187.12,80.88) 186.39,80.88 185.81,81.46 182,81.46 181.56,81.03 178.91,81.03 177.97,80.09 176.95,80.09 176.87,80.18 174.4,80.18 174.16,80.41 174.16,81.61 173.57,82.21 172.36,82.21 171.58,82.99 170.88,82.99 170.38,82.49 v1(170.38,81.21)
  IN3 w0.122: v1(187.12,80.88) 186.79,80.88 185.8,81.87 185.8,83.21 185.63,83.37 185.63,85.41 182.1,88.94 182.1,92.61 180.63,94.08 180.63,94.95 179.12,96.46 179.12,99.34 175,103.46 175,104.76 175.27,105.02 175.27,105.6 173.72,107.14 162.8,107.14 161.59,108.36 160.76,108.36 159.58,109.54 153.3,109.54 152.85,109.09 148.73,109.09 148.65,109.17 146.55,109.17 145.56,110.16 138.54,110.16 138.45,110.25 136.58,110.25 136.14,110.68 114.71,110.68 111.12,107.09 101.44,107.09 100.65,107.88 92.46,107.88 92.36,107.98 88.55,107.98 88.14,108.39 82.87,108.39 82.37,108.9 81.16,108.9 81.03,109.02 79.09,109.02 78.03,110.08 v1(76.55,110.08)
  BOTTOM w0.089: UC1.CF12 v1(148.95,83.7)
  BOTTOM w0.102: v1(76.55,110.08) 75.78,110.84 74.47,110.84 73.99,111.32 JEDP1.40
  BOTTOM w0.127: RC749.1 v1(170.38,81.21)
LCD_TST: length 302.2
  TOP w0.127: UE1.M2 281.45,78.56 281.87,78.14 282.31,78.14 283.09,77.36 283.39,77.36 v1(283.55,77.2) ; v1(274.33,76.51) 273.6,75.78 RE20.1 ; v1(67.37,110.19) 67.37,110.97 v3(67.56,111.16)
  IN1 w0.084: v1(265.36,72.67) 265.36,72.67 265.36,73.39 265.66,73.69 265.66,75.27 266.07,75.69 267.66,75.69 268.19,75.15 268.65,75.15 269.69,76.19 274.01,76.19 v1(274.33,76.51) 275.25,76.51 275.63,76.13 276.29,76.13 277.15,76.99 280.5,76.99 281.02,76.47 282.03,76.47 282.76,77.2 v1(283.55,77.2)
  IN3 w0.122: v1(265.36,72.67) 265.69,72.33 265.69,71.4 267.22,69.87 267.22,68.33 265.27,66.38 265.27,63.18 264.75,62.65 264.75,60.22 265.54,59.43 265.54,57.52 264.24,56.22 261.59,56.22 260.23,54.86 260.23,54.24 259.65,53.65 258.75,53.65 257.99,52.9 256.06,52.9 255.13,51.96 255.12,51.96 253.77,50.61 253.77,49.92 252.45,48.6 250.29,48.6 247.24,45.56 245.1,45.56 244.31,44.76 242.89,44.76 242.3,44.17 242.3,43.94 241.6,43.25 234.45,43.25 234.31,43.1 232.26,43.1 230.66,44.7 218.82,44.7 208.61,54.92 196.52,54.92 195.96,55.48 195.96,57.93 191.32,62.57 191.32,74.49 188.41,77.4 188.41,80.8 186.85,82.36 186.37,82.36 186.02,82.71 186.02,83.31 185.86,83.47 185.86,85.5 182.32,89.03 182.32,92.71 180.86,94.17 180.86,95.06 179.91,96 179.91,97.25 179.35,97.81 179.35,99.44 177.19,101.59 177.19,103.99 173.2,107.98 167.8,107.98 167.18,107.36 162.9,107.36 161.57,108.69 160.93,108.69 159.86,109.76 153.2,109.76 152.83,109.39 146.64,109.39 145.65,110.38 138.63,110.38 138.54,110.47 136.67,110.47 136.24,110.91 114.61,110.91 111.02,107.32 101.54,107.32 100.75,108.1 92.56,108.1 92.34,108.32 90.12,108.32 89.73,108.71 89.65,108.71 89.4,108.96 89.08,108.96 88.89,108.77 82.81,108.77 82.46,109.12 81.38,109.12 81.08,109.42 79.02,109.42 77.56,110.88 67.68,110.88 67.37,110.57 v1(67.37,110.19)
  BOTTOM w0.127: JEDP1.29 68.63,111.1 68.35,110.83 67.71,110.83 67.37,110.48 v1(67.37,110.19)
LCD_VCC_TEST_EN: length 259.3
  TOP w0.127: v2(106.98,96.93) v1(106.56,96.51) ; v1(275.75,77.11) 275.82,77.17 UE1.E1
  IN3 w0.122: v1(275.75,77.11) 275.4,76.76 275.4,76.39 275.57,76.22 275.57,75.59 274.21,74.23 274.21,73.34 272.98,72.11 272.98,68.1 271.59,66.71 271.59,64.5 271.32,64.24 271.32,62.75 270.72,62.15 270.72,60.5 268.77,58.54 268.77,56.63 269.26,56.14 269.26,53.99 268.64,53.37 268.64,52.26 267.21,50.83 266.4,50.83 266.18,51.05 265.53,51.05 264.81,50.34 264.81,50.02 262.71,47.92 260.28,47.92 259.19,46.83 257.87,46.83 256.22,45.18 254.27,45.18 253.48,44.39 253.11,44.39 250.83,42.11 248.19,42.11 246.79,40.71 245.06,40.71 244.45,40.09 243.06,40.09 242.66,39.69 237.09,39.69 236.94,39.54 229.25,39.54 227.42,41.37 217.42,41.37 207.1,51.69 195.13,51.69 189.54,57.28 186.69,57.28 185.76,58.22 185.76,71.03 186.2,71.47 186.2,72.11 185.09,73.23 185.09,75.58 183.44,77.22 183.44,78.36 180.36,81.44 180.36,83.29 178.14,85.51 178.14,86.26 177.21,87.19 177.21,90.39 175.18,92.42 175.18,93.57 174.55,94.2 174.55,94.77 172.53,96.79 172.53,101.36 170.87,103.02 165.2,103.02 160.2,98.02 157.26,98.02 155.34,99.94 153.37,99.94 150.81,97.38 149.57,97.38 148.64,96.44 145.22,96.44 143.51,94.73 140.79,94.73 140.09,95.43 140.09,99.36 139,100.45 124.58,100.45 120.58,96.44 117.49,96.44 116.92,97.01 116.92,98.8 116.61,99.1 116.29,99.1 113.92,96.72 107.07,96.72 106.86,96.51 v1(106.56,96.51)
  BOTTOM w0.127: DV3.3 105.04,94.74 105.42,95.12 105.42,96.01 105.75,96.34 106.39,96.34 v1(106.56,96.51)
LCDVDD_MONITOR: length 2.8
  TOP w0.127: QV21.2 91.88,100.3 RV630.2 92.87,100.3 v2(93.64,101.07)
LDO_3V: length 1.3
  TOP w0.127: PR105.1 193.49,93.44 v2(193.11,93.06)
LED_MASK#: length 79.8
  TOP w0.127: v2(265.69,92.55) 266.11,92.13 266.11,91.18 266.33,90.96 RE21.1 266.62,90.96 267.4,90.19 267.7,90.19 268.29,89.59 268.29,88.14 268.91,87.52 v1(269.44,87.52) 271.05,87.52 272.01,86.56 UE1.A12 ; UZ10.1 v1(308.52,70.86)
  IN2 w0.122: v1(308.52,70.86) 307.7,71.69 306.14,71.69 304.91,72.91 301.61,72.91 298.45,76.07 298.45,91.87 298.61,92.03 298.61,93.94 297.85,94.71 295.49,94.71 294.98,94.2 294.09,94.2 293.59,93.7 293.59,93.52 291.45,91.38 291.45,89.99 291.15,89.68 289.03,89.68 288.38,90.33 287.75,90.33 286.93,91.15 283.44,91.15 282.56,92.03 281.72,92.03 280.93,91.24 278.24,91.24 278.05,91.05 276.6,91.05 275.59,92.05 272.02,92.05 271.68,91.71 270.41,91.71 269.56,90.86 269.56,87.65 v1(269.44,87.52)
LG1_CHG: length 11.8
  TOP w0.127: v1(55.04,67.28) v2(55.57,67.28)
  IN1 w1.016: 50.07,57.35 51.64,58.92 51.64,65.25 52.11,65.72 52.93,65.72 53.83,66.62
  vias: v1(48.76,55.76) v1(49.14,56.18) v1(54.46,67.28)
LG2_CHG: length 20.3
  TOP w0.127: v3(59.37,76.24) 59.12,76 v1(58.74,76)
  IN4 w1.016: 51.12,57.46 51.12,58.13 51.66,58.67 51.66,61.95 57.73,68.02 57.73,74.35
  vias: v1(49.79,55.42) v1(50.2,55.85) v1(58.74,75.43)
LG_SA:
  vias: v1(90.65,94.52) v1(90.65,93.94) v1(96.31,93.58) v1(96.61,94.06)
LID_CL#: length 252.9
  TOP w0.127: v1(306.9,72.32) 307.54,72.32 307.87,71.98 UZ10.2 ; v2(168.83,112.49) UZ1.3 v1(170.76,110.93) ; RE26.1 287.34,92.26 287.5,92.41 v1(288.27,92.41)
  IN1 w0.084: v1(262.45,87.05) 263.79,88.39 267.5,88.39 268.21,89.11 269.16,89.11 269.76,88.51 271.15,88.51 271.48,88.84 273.75,88.84 275.61,90.7 278.36,90.7 278.82,91.16 281.98,91.16 282.6,90.54 283.33,90.54 284.07,91.28 287.14,91.28 v1(288.27,92.41)
  IN2 w0.122: v1(306.9,72.32) 305.03,74.19 300.65,74.19 298.68,76.16 298.68,91.78 298.84,91.94 298.84,94.03 297.94,94.93 295.4,94.93 294.89,94.42 293.99,94.42 293.37,93.79 293.37,93.68 291.62,91.94 288.74,91.94 v1(288.27,92.41)
  IN3 w0.122: v1(170.76,110.93) 171.52,110.93 178.34,104.1 178.34,102.6 180.24,100.7 180.24,98.29 180.86,97.67 180.86,96.32 183.22,93.96 183.22,89.4 187.38,85.24 187.38,84.22 187.33,84.17 187.33,83.61 188.05,82.89 188.05,82.21 189.08,81.18 189.08,77.67 191.99,74.76 191.99,62.85 196.63,58.21 196.63,55.76 196.8,55.59 208.89,55.59 219.1,45.37 230.94,45.37 232.54,43.77 234.03,43.77 234.17,43.92 239.79,43.92 240.24,44.37 240.24,44.96 240.82,45.53 244.13,45.53 244.82,46.23 246.97,46.23 251.71,50.97 252.69,50.97 255.28,53.57 257.72,53.57 261.04,56.89 263.2,56.89 263.71,57.4 263.71,57.52 264.07,57.89 264.07,62.93 264.6,63.46 264.6,67.36 265.97,68.73 265.97,70.39 262.59,73.77 262.59,79.81 263.39,80.62 263.39,81.91 262.31,82.99 262.31,86.92 v1(262.45,87.05)
LID_CL_SIO#: length 10.4
  TOP w0.102: UE1.N11 282.34,85.64 283.35,85.64 284.22,86.51 v3(284.22,86.58)
  TOP w0.127: v3(284.22,86.58) 284.22,88.32 284.41,88.51 CE8.1 285.32,88.51 285.44,88.4 286.79,88.4 287.27,88.88 287.27,89.38 287.34,89.45 RE26.2 RE25.2
LINE1_L: length 3
  TOP w0.203: UA1.36 284.71,42.64 284.8,42.74 284.8,43.25 v2(285.4,43.85) 285.02,44.23 CA43.2
LINE1_R: length 4.6
  TOP w0.203: UA1.35 284.78,42.24 285.12,42.59 285.12,43.1 285.54,43.52 286.45,43.52 286.71,43.77 v2(286.71,43.81) 286.71,44.39 CA44.2
LM393_P: length 35.8
  TOP w0.254: PU800.8 45.2,81.36 44.98,81.58 44.44,81.58 44.02,81.16 PR866.2 43.33,81.82 43.12,82.02 43.12,82.9 v1(43.36,83.14) 43.15,83.36 40.71,83.36 PC801.2 40.46,82.62 40.45,82.61 PD800.1 ; v1(42.79,65.6) 43.05,65.86 43.05,66.19 43.43,66.57 44.58,66.57 44.89,66.26 PU701.5 44.89,65.33 44.77,65.21 PC754.2 45.6,64.84 PR735.2
  IN2 w0.254: v1(44.01,72.96) 44.79,72.18 44.79,66.84 43.55,65.6 v1(42.79,65.6)
  IN3 w0.254: v1(43.36,83.14) 45.47,81.03 45.47,77.02 44.01,75.56 v1(44.01,72.96)
  BOTTOM w0.127: v2(43.5,65.63) 42.82,65.63 v1(42.79,65.6)
LOM_CABLE_DETECT#: length 14.8
  TOP w0.127: UE1.D2 274.63,78.17 274.63,77.39 v1(274.31,77.07) ; v2(281.61,69.92) v1(281.02,69.92) 280.42,69.92 RE505.1
  IN4 w0.084: v1(274.31,77.07) 274.75,77.07 275.8,76.02 275.8,74.73 276.04,74.49 276.04,72.96 276.83,72.16 279.05,72.16 281.02,70.2 v1(281.02,69.92)
LPM_1V_PRIM_CORE: length 6.8
  TOP w0.127: v3(183.82,24.65) v1(183.27,25.2)
  TOP w0.254: v1(183.27,25.2) 183.41,25.35 PU402.14 ; PR410.2 179.26,24.71 179.27,24.71 PR430.2 180.3,24.71 v1(180.45,24.86)
  IN2 w0.254: v1(183.27,25.2) 182.63,24.57 180.75,24.57 v1(180.45,24.86)
LPM_1VS_VCCIO: length 9.7
  TOP w0.127: v2(80.99,28.71) 80.63,29.08 v1(80.63,29.47)
  TOP w0.254: v1(80.63,29.47) 80.63,29.56 PR404.2 79.64,30.17 79.47,30.33 PR429.2 78.23,30.33 PR425.2 ; v1(84.91,29.78) 85.11,29.58 PU401.14
  IN1 w0.254: v1(80.63,29.47) 80.63,29.51 81.72,30.6 84.08,30.6 v1(84.91,29.78)
LX1_CHG: length 17.2
  IN1 w1.016: 49.22,58.58 49.8,59.16 49.8,60.18 48.61,61.37 48.61,63.46 49.09,63.94 49.09,68.51 ; 54.32,71.43 49.8,71.43 48.95,70.58 48.95,69.96
  vias: v1(48.22,68.76) v1(48.22,68.13) v1(48.45,57.28) v1(48.45,56.7) v1(55.63,71.05) v1(55.63,70.48) v2(56.2,70.81)
LX1_IA: length 1.8
  TOP w0.127: PR663.1 v2(84.51,93.5)
  vias: v1(81.86,93.4) v1(81.86,92.83)
LX2_CHG: length 32.5
  IN4 w1.016: 61.69,83.88 59.99,83.88 59.3,83.19 59.3,77.67 60.39,76.57 60.39,74.42 ; 59.85,73.12 58.96,72.23 58.96,67.67 54.18,62.9 54.18,59.42 53.68,58.91 53.68,58.38 52.3,57 52.3,56.09 51.95,55.75
  vias: v1(50.36,55.21) v1(50.77,55.62) v1(59.51,74.54) v1(59.51,73.97) v1(62.16,83.18) v1(62.73,83.18) v1(63.26,75.05) v1(63.26,74.42) v3(62.36,74.5)
LX2_IA: length 0.9
  TOP w0.127: v3(82.43,76.14) 82.54,76.26 v1(83.32,76.26)
  vias: v1(83.32,76.83)
LX_1.05VALWP:
  vias: v1(188.23,110.84) v1(188.23,110.2) v1(188.86,110.78) v1(188.86,110.14) v1(189.25,111.54) v1(189.47,110.78) v1(189.47,110.14) v1(189.82,111.55) v1(190.37,106.45) v1(190.7,110.78) v1(190.7,110.14) v1(190.96,106.45) v1(191.27,110.46) v2(186.85,111.65)
LX_1.8VALW: length 3.1
  BOTTOM w0.127: v2(178.82,103.33) 176.74,105.42 PL501.1
LX_1V_PRIM_CORE: length 1.4
  TOP w0.127: PR409.1 187.88,25.27 v2(188.27,24.87)
LX_1VS_VCCIO: length 1.4
  TOP w0.127: v2(80.18,23.2) 80.75,23.76 PR405.1
LX_3V:
  vias: v1(188.66,98.8) v1(189.24,98.8) v1(193.1,99.37) v1(193.1,98.74) v1(193.1,98.1) v1(193.74,99.37) v1(193.74,98.74) v1(193.74,98.1) v1(194.37,99.37) v1(194.37,98.74) v1(194.37,98.1) v1(195.01,99.37) v1(195.01,98.74) v1(195.01,98.1) v1(195.64,99.37) v1(195.64,98.74) v1(196.16,99.05) v3(196.11,97.71)
LX_5V:
  vias: v1(40.02,28.12) v1(40.02,27.54) v1(40.02,26.91) v1(40.33,26.32) v1(40.62,27.54) v1(40.62,26.91) v1(40.8,25.84) v1(41.22,27.54) v1(41.22,26.91) v1(41.26,25.39) v1(41.67,26.09) v1(41.81,27.54) v1(42.02,19.64) v1(42.02,19.06) v1(42.02,18.47) v1(42.02,17.89) v1(42.02,17.3) v1(42.26,26.7) v1(42.26,26.09) v1(42.65,19.64) v1(42.65,19.06) v1(42.65,18.47) v1(42.65,17.89) v1(42.65,17.3) v1(42.89,26.7) v1(42.89,26.09) v1(43.29,19.64) v1(43.29,19.06) v1(43.29,18.47) v1(43.29,17.89) v1(43.29,17.3) v1(46.02,26.84) v1(46.02,26.21) v1(45.98,16.85) v1(45.98,16.28) v3(41.07,26.34)
LX_DDR:
  vias: v1(210.57,30.03) v1(210.57,29.46) v1(211.14,30.03) v1(211.14,29.46) v1(211.72,30.03) v1(211.72,29.46) v1(212.29,30.03) v1(212.29,29.46) v1(212.82,30.69) v1(213.39,30.69) v1(213.96,30.69) v1(214.53,30.69) v3(211.91,28.45)
LX_GT: length 1.7
  TOP w0.127: PR669.1 81.03,69.58 v2(80.89,69.44)
  vias: v1(79.83,70.92) v1(79.83,70.35)
LX_SA:
  vias: v1(94.81,94.6) v1(94.81,92.84) v1(95.38,94.6) v1(95.38,92.84) v2(94.58,93.78)
M2280_DEVSLP: length 215.6
  TOP w0.127: v2(57.79,51.14) v1(59.65,51.14)
  IN1 w0.076: JNGFF3.38 24.63,20.89
  IN1 w0.084: 24.63,20.89 24.63,21.79 23.31,23.11 19.82,23.11 19.31,23.62 19.31,24.3 v1(20.43,25.42)
  IN2 w0.089: v1(160.53,87.25) 160.15,86.87 160.15,85.02 159.77,84.64 156.26,84.64 156.12,84.5 156.12,84.5 155.74,84.12 155.74,83.45 157.02,82.17 v1(157.02,80.71)
  IN3 w0.122: v1(59.65,51.14) 62.16,51.14 62.75,51.73 62.97,51.73 64.36,53.12 69.34,53.12 70.13,52.34 72.63,52.34 74.24,53.95 80.91,53.95 82.96,56 131.97,56 134.35,58.38 134.35,66.35 134.54,66.54 134.54,67.96 135.28,68.7 140.71,68.7 142.49,66.92 142.65,66.92 143.34,66.23 143.34,63.61 143.83,63.11 144.28,63.11 144.43,62.96 144.6,62.96 145.27,62.29 145.27,62.12 145.35,62.04 145.63,61.76 146.48,61.76 146.88,62.16 146.88,64.37 147.91,65.4 147.91,67.33 148.38,67.8 148.38,68.94 150.86,71.41 150.86,72.27 151.2,72.6 151.48,72.6 151.99,73.12 151.99,75 152.11,75.11 152.11,75.92 151.87,76.16 151.87,76.72 152.19,77.04 152.19,77.04 153.05,77.9 153.05,80.33 154.25,81.53 156.2,81.53 v1(157.02,80.71)
  IN4 w0.084: v1(20.43,25.42) 21.22,25.42 23.75,27.95 23.75,28.36 27.02,31.64 35.68,31.64 44.46,40.42 44.46,41.17 45.72,42.42 47.03,42.42 49.44,44.84 49.44,45.51 49.66,45.73 50.56,45.73 52.12,47.29 53.99,47.29 56.02,49.32 56.38,49.32 57.75,50.68 59.2,50.68 v1(59.65,51.14)
  BOTTOM w0.076: UC1.CM8 152.27,87.11 153.15,87.11 153.5,86.99 153.74,86.99 154.04,87.1 157.57,87.1
  BOTTOM w0.102: v1(160.53,87.25) 159.95,87.84 158.76,87.84 158.02,87.1 157.57,87.1
  BOTTOM w0.127: v1(20.43,25.42) 19.93,24.92 RN37.2
M2280_PCIE_SATA#: length 214.7
  TOP w0.127: v2(59.18,51.76) 59.78,51.76 v1(59.9,51.64)
  IN2 w0.089: v1(157.63,80.73) 157.63,81.81 155.92,83.52 155.92,84.05 156.33,84.46 159.85,84.46 160.33,84.95 160.33,85.9 v1(160.66,86.23)
  IN3 w0.122: v1(157.63,80.73) 156.61,81.75 154.15,81.75 152.83,80.42 152.83,77.99 151.64,76.81 151.64,76.07 151.85,75.86 151.85,75.17 151.77,75.09 151.77,73.21 151.39,72.83 151.1,72.83 150.63,72.36 150.63,71.51 147.6,68.47 147.6,67.8 147.63,67.77 147.63,65.43 146.66,64.46 146.66,62.25 146.39,61.98 145.72,61.98 145.57,62.13 145.49,62.21 145.49,62.61 144.9,63.2 144.5,63.2 144.37,63.34 143.93,63.34 143.56,63.7 143.56,66.34 142.75,67.15 142.61,67.15 140.84,68.93 135.19,68.93 133.71,67.45 133.71,66.51 134.12,66.1 134.12,58.47 131.87,56.22 82.87,56.22 80.82,54.17 74.15,54.17 72.54,52.56 70.22,52.56 69.44,53.35 62.17,53.35 61.23,52.4 61.23,51.76 61.11,51.64 v1(59.9,51.64)
  IN4 w0.084: v1(17.76,25.97) 18.97,27.17 20.24,27.17 24.2,31.13 25.66,31.13 27.6,33.07 36.85,33.07 44.28,40.5 44.28,41.25 45.64,42.61 46.95,42.61 49.26,44.92 49.26,45.58 49.58,45.91 50.48,45.91 52.04,47.48 53.91,47.48 55.94,49.51 56.31,49.51 57.86,51.06 59.04,51.06 59.62,51.64 v1(59.9,51.64)
  BOTTOM w0.076: 157.99,86.17 155.3,86.17 154.75,85.61 154.29,85.61 154.1,85.81 153.83,85.81 153.35,85.54 UC1.CP10
  BOTTOM w0.102: RC730.1 165.06,84.6 164.57,85.08 163.71,85.08 163.26,85.53 163.26,85.91 163.14,86.04 161.36,86.04 161.23,86.17 160.72,86.17 v1(160.66,86.23) 159.35,86.23 159.29,86.17 157.99,86.17
  BOTTOM w0.127: RC730.1 RC764.2 ; v1(17.76,25.97) 17.76,24.63 16.88,23.75 JNGFF3.69
M3042_DEVSLP: length 177.2
  TOP w0.127: v1(159.02,87.47) v2(158.36,87.47)
  IN1 w0.084: v1(270.39,65.59) 268.99,65.59 267.52,64.12 267.52,57.94 269.2,56.27 270.34,56.27 270.57,56.04 270.57,55.71 270.9,55.38 270.9,52.28 270.61,51.99 269.65,51.99 269.29,52.35 265.63,52.35 264.77,51.49 262.52,51.49 262.13,51.87 255.59,51.87 252.56,48.84 249.6,48.84 247.81,47.06 244.09,47.06 243.6,46.56 241.91,46.56 239.62,44.26 232.7,44.26 232.01,44.94 223.48,44.94 222.18,46.24 217.64,46.24 200.67,63.22 200.67,63.88 199.35,65.19 194.88,65.19 191.22,68.85 191.22,72.56 187.17,76.61 187.17,77.39 185.57,78.99 185.57,79.65 184.93,80.29 183.1,80.29 181.96,81.43 181.96,82.61 179.78,84.79 179.78,86.33 176.48,89.63 174.1,89.63 173.95,89.49 171.99,89.49 171.86,89.35 170.38,89.35 170.1,89.63 169.13,89.63 165.14,93.62 162.52,93.62 159.58,90.68 159.58,88.02 v1(159.02,87.47)
  BOTTOM w0.076: UC1.CR8 154.09,86.91 157.66,86.91
  BOTTOM w0.102: v1(159.02,87.47) 158.63,87.08 158.29,87.08 158.12,86.91 157.66,86.91
  BOTTOM w0.127: v1(270.39,65.59) 271.09,65.59 272.04,66.54 275.72,66.54 276.43,65.83 JNGFF2.38
M3042_PCIE#_SATA: length 212
  TOP w0.107: UE1.J12 279.02,86.65 279.37,87 v1(279.42,87)
  IN1 w0.084: v1(266.25,90.32) 266.48,90.56 271.81,90.56 272.03,90.33 272.55,90.33 272.8,90.08 v1(273.25,90.08)
  IN2 w0.122: v1(164.98,86.35) 165.24,86.35 165.97,87.08 167.24,87.08 169.99,84.32 169.99,82.35 169.93,82.29 169.93,80.76 170.05,80.64 170.73,80.64 170.85,80.76 170.85,82.64 170.97,82.77 171.49,82.77 172.31,81.94 173.52,81.94 173.94,81.52 173.94,80.32 174.31,79.95 176.77,79.95 176.86,79.87 178.06,79.87 178.4,80.21 185.7,80.21 185.72,80.19 189.6,80.19 194.19,75.6 195.67,75.6 198.38,72.89 198.38,70.47 198.92,69.93 198.92,69.81 200.61,65.35 200.61,61.21 219.59,42.22 228.46,42.22 229.27,41.41 230.16,40.53 241.77,40.53 243.67,42.42 244.56,42.42 245.42,43.28 253.75,43.28 254.62,44.16 259.75,44.16 260.42,43.49 262.52,43.49 262.83,43.8 262.83,45.01 261.71,46.13 261.71,48.11 260.78,49.03 260.78,51.34 263.47,54.03 263.47,57.7 264.02,58.24 264.02,61.72 264.81,62.51 264.81,65.23 264.24,65.8 264.24,72.92 264.67,73.36 264.67,80.76 264.9,80.99 264.9,84.16 264.72,84.34 264.72,85.77 266.13,87.17 266.13,89.02 266.58,89.46 266.58,89.99 v1(266.25,90.32) ; v1(273.25,90.08) 273.34,90.17 274.38,90.17 275.28,89.27 275.79,89.27 277.12,87.94 277.37,87.94 277.53,87.78 277.98,87.78 278.76,87 v1(279.42,87)
  BOTTOM w0.076: 157.91,86.35 155.26,86.35 154.68,85.78 154.36,85.78 154.17,85.97 153.79,85.97 153.59,85.86 152.4,85.86 UC1.CM10
  BOTTOM w0.102: 157.91,86.35 159.21,86.35 159.54,86.68 160.87,86.68 160.98,86.57 v2(162.72,86.57) 162.83,86.68 164.65,86.68 v1(164.98,86.35) 165.31,86.02 RC521.1
  BOTTOM w0.127: RC766.2 RC521.1
M_BIST: length 115.5
  TOP w0.127: RZ1415.2 v1(301.63,5.89) 301.83,5.68 v2(302.47,5.68) ; v1(282.87,83.76) 282.46,83.36 UE1.N8
  IN3 w0.122: v1(301.63,5.89) 301.63,6.95 299.69,8.89 299.69,24.41 293.85,30.25 286.93,30.25 286.33,30.85 283.91,30.85 277.98,36.79 277.98,45.93 280.07,48.02 280.07,48.03 280.77,48.73 281.28,48.73 281.78,49.23 281.78,49.5 281.89,49.62 281.89,49.88 281.98,49.97 281.98,50.25 283.16,51.43 284.57,51.43 288.6,55.46 288.6,55.91 289.85,57.15 290.78,57.15 v1(290.99,57.36)
  IN4 w0.084: v1(282.87,83.76) 282.87,83.3 281.4,81.83 281.4,81.06 282.2,80.26 286.84,80.26 287.41,80.83 287.41,82.02 287.49,82.1 288.25,82.1 288.33,82.02 288.33,79.15 287.39,78.21 287.39,75.62 287.19,75.42 287.19,74.51 287.02,74.34 287.02,72.96 287.56,72.42 287.56,71.52 288.83,70.25 288.83,68.87 289.78,67.92 289.78,64.87 290.06,64.6 290.06,63.07 290.65,62.47 290.65,61.44 291.38,60.71 291.38,57.75 v1(290.99,57.36)
