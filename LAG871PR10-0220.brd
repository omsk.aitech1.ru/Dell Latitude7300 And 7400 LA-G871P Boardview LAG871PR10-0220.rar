# Allegro board LAG871PR10-0220.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+0.9V_TBT_SVR on BOTTOM (solid shape): 26.92,78.87 26.92,78.42 26.84,78.34 26.81,78.35 26.67,78.32 26.57,78.22 26.35,78.22 26.17,78.4 26.04,78.4 26,78.33 25.88,78.21 25.87,78.22 25.81,78.21 25.74,78.22 25.68,78.25 25.53,78.4 25.53,78.55 25.35,78.73 25.35,78.83 25.45,78.93 26.85,78.93
+0.9V_TBT_SVR on BOTTOM (solid shape): 24.25,78.23 24.38,78.1 24.38,78.06 24.38,75.94 24.18,75.75 24.16,75.75 24.06,75.72 23.99,75.65 23.97,75.63 23.73,75.63 23.66,75.7 23.63,75.73 23.63,75.92 23.77,76.06 23.77,76.28 23.76,76.28 23.55,76.49 23.55,76.61 23.51,76.65 23.49,76.69 23.44,76.74 23.41,76.77 23.41,76.88 23.42,76.9 23.47,76.95 23.51,77.01 23.52,77.25 23.36,77.43 23.36,77.72 23.53,77.89 23.55,77.89 23.65,77.93 23.73,78.01 23.76,78.09 23.79,78.12 23.81,78.11 23.97,78.14 24.11,78.23
+0.9V_TBT_SVR on IN3: 26.4,71.94 22.65,71.94 16.45,78.14 16.45,88.47 16.84,88.85 20.45,88.85 20.89,88.41 20.89,84.92 19.34,83.37 19.34,82.07 20.21,81.2 20.21,80.25 21.46,79 21.46,78.97 22.36,78.07 25.2,78.07 25.54,78.41 25.54,78.46 25.52,78.48 25.52,78.72 25.79,78.99 27.92,78.99 28.67,78.24 28.67,77.31 28.08,76.71 28.08,76.06 28.17,75.97 28.17,73.71
+0.9V_TBT_SVR on IN4: 26.57,78.69 24.33,78.69 23.59,77.95 23.59,76.15 23.72,76.02 24.89,76.02 25.06,76.19 25.06,77.34 25.69,77.97 26.5,77.97 26.69,78.17 26.69,78.57
+1.0V_AMPHYPLL on TOP (solid shape): 147.91,98.8 147.98,98.77 148.01,98.7 148.04,98.57 148.11,98.45 148.34,98.22 148.34,95.57 147.86,95.09 147.86,94.57 147.64,94.35 147.15,94.35 146.95,94.56 146.95,98.67 147.07,98.8
+1.0V_APLL on TOP (solid shape): outline of 918 points within 141.49,81.74 146.64,104.31
+1.0V_APLL on BOTTOM (solid shape): 143.03,84.27 143.11,84.23 143.13,84.15 143.25,83.89 143.53,83.93 143.83,83.93 143.86,83.9 143.88,83.87 143.88,83.5 143.79,83.41 143.79,83.35 143.77,83.29 143.59,83.11 143.28,83.11 143.22,83.15 142.86,83.47 142.84,83.47 142.77,83.5 142.71,83.54 142.7,83.62 142.67,83.83 142.52,83.97 142.52,84.16 142.6,84.21 142.66,84.27
+1.0V_APLL on BOTTOM (solid shape): 142.07,83.52 142.14,83.48 142.25,83.4 142.38,83.37 142.45,83.33 142.47,83.26 142.49,83.18 142.53,83.11 142.54,83.08 142.66,82.97 142.66,82.7 142.61,82.64 142.6,82.64 142.47,82.42 142.61,82.21 142.64,82.19 142.64,82.09 142.64,82.09 142.64,81.92 142.64,81.85 142.54,81.75 142.47,81.75 142.47,81.75 142.32,81.75 142.27,81.75 142.09,81.94 142.09,81.96 142.09,82.04 142.07,82.15 141.99,82.25 141.91,82.31 141.84,82.38 141.45,82.76 141.45,82.96 141.45,83.02 141.49,83.03 141.61,83.11 141.66,83.26 141.74,83.36 141.76,83.37 141.88,83.4 141.99,83.48
+1.0V_MPHYGT on TOP (solid shape): outline of 3312 points within 144.09,82.59 171.01,97.63
+1.0V_MPHYGT on BOTTOM (solid shape): 144.81,84.2 144.85,84.2 144.86,84.2 145.05,84.18 145.23,84.26 145.37,84.26 145.48,84.16 145.48,82.96 145.11,82.6 144.84,82.6 144.67,82.67 144.5,82.6 144.19,82.6 144.12,82.64 144.05,82.66 144.03,82.67 143.88,82.82 143.88,83.38 144.04,83.68 143.97,83.9 143.97,83.92 143.86,84.02 143.86,84.17 143.96,84.26 144.11,84.26 144.15,84.22 144.48,84.22 144.53,84.27 144.73,84.27
+1.0V_MPHYGT on IN3: 143.45,83.31 144.34,82.42 161.23,82.42 161.96,83.15 165.14,83.15 168.73,86.73 168.73,95.18 167.07,96.83 167.01,96.83 166.69,97.15 156.31,97.15 152.28,93.12 145.96,93.12 143.45,90.61 ; 3 cut-outs
+1.0V_PRIM on TOP (solid shape): 143.29,81.39 143.36,81.34 143.37,81.26 143.44,80.95 143.74,80.84 143.82,80.81 143.85,80.74 143.85,79.91 143.82,79.84 143.74,79.81 143.65,79.81 143.57,79.79 143.56,79.79 143.39,79.79 143.32,79.71 143.32,78.33 143.2,78.21 142.65,78.21 142.56,78.3 142.56,78.38 142.7,78.7 142.47,78.97 142.46,78.97 142.41,79.02 141.53,79.02 141.49,79.07 141.49,79.59 141.82,79.92 141.82,79.94 141.85,79.99 141.9,80.01 142.09,80.27 141.99,80.57 141.93,80.62 141.87,80.65 141.85,80.66 141.82,80.71 141.82,80.78 141.85,80.83 141.87,80.83 141.94,80.87 142.01,80.93 142.08,80.96 142.15,80.93 142.57,80.88 142.7,81.28 142.71,81.37 142.8,81.41 143.29,81.41
+1.0V_PRIM on TOP (solid shape): outline of 1579 points within 140.75,97.9 171.1,112.96
+1.0V_PRIM on BOTTOM (solid shape): outline of 81 points within 162.69,97.65 171.72,110.59
+1.0V_PRIM on BOTTOM (solid shape): 144.71,81.78 144.98,81.65 145.25,81.76 145.44,81.76 145.58,81.63 145.58,81.01 145.55,80.98 145.22,80.98 145.17,80.94 145.15,80.92 145.08,80.85 145.07,80.74 145.08,80.68 145.08,79.96 145.07,79.9 145.08,79.81 145.14,79.73 145.21,79.69 145.3,79.59 145.3,79.56 145.32,79.33 145.49,79.17 145.52,79.15 145.52,79.01 145.4,78.9 145.23,78.9 145.16,78.95 145.07,78.99 145.06,78.99 144.89,79.16 144.84,79.24 144.76,79.29 144.72,79.33 144.72,79.63 144.49,79.87 144.49,80.83 144.51,80.85 144.69,81.15 144.53,81.46 144.5,81.49 144.5,81.71 144.57,81.78
+1.0V_PRIM on BOTTOM (solid shape): outline of 180 points within 141.01,78.07 143.52,81.37
+1.0V_PRIM on VCC: 141.36,78.41 141.36,89.3 142.12,90.06 142.12,92.85 143.88,94.61 144.51,94.61 145.27,95.37 156.58,95.37 162.54,101.34 164.49,101.34 165.49,100.35 165.49,97.42 168.28,94.63 168.28,87.22 166.02,84.96 162.33,84.96 160.3,82.92 147.35,82.92 146.82,82.4 146.82,78.8 146.55,78.8 146.17,78.41
+1.0V_PRIM_CORE on TOP (solid shape): 232.7,27.2 232.7,26.19 233.18,25.71 233.18,23.62 232.92,23.36 229.81,23.36 229.56,23.62 229.56,24.44 229.94,24.82 229.94,27.43 232.48,27.43
+1.0V_PRIM_CORE on TOP (solid shape): 194.6,29.24 194.6,27.25 193.63,26.11 193.22,24.68 193.22,24.63 192.22,24.63 192,24.85 192,25.64 191.75,25.89 191.75,26.2 191.75,26.22 191.74,26.28 191.75,26.35 191.75,26.38 191.84,26.47 191.84,27.05 192.33,27.05 192.33,27.51 191.84,27.51 191.84,27.85 192.33,27.85 192.33,28.31 191.84,28.31 191.84,29.14 192.16,29.46 194.38,29.46
+1.0V_PRIM_CORE on TOP (solid shape): outline of 5469 points within 143.44,70.62 177.94,84.66
+1.0V_PRIM_CORE on BOTTOM (solid shape): 146.67,84.29 146.71,84.26 146.74,84.23 146.97,84 147,83.98 147.19,83.79 147.19,83.58 147,83.39 147,83.38 146.79,83.16 146.74,83.14 146.71,83.11 146.54,83.11 146.13,83.52 146.04,83.52 145.98,83.53 145.82,83.53 145.67,83.67 145.67,84.22 145.75,84.29
+1.0V_PRIM_CORE on BOTTOM (solid shape): outline of 139 points within 143.18,77.54 147.2,82.69
+1.0V_PRIM_CORE on IN2: 215.72,28 225.11,28 226.51,26.6 232.67,26.6 233.18,26.09 233.18,23.49 233.05,23.36 199.21,23.36 199.12,23.41 199.11,23.5 196.73,27.02 194.35,23.5 194.34,23.41 194.25,23.36 192.09,23.36 191.33,24.12 191.33,30.35 192.41,31.43 199.44,31.43 200.11,30.76 203.56,30.76 203.84,30.47 203.84,28.31 204.54,27.62 215.33,27.62
+1.0V_PRIM_CORE on IN3: 143.52,82.29 147.14,82.29 147.17,82.26 148.82,82.26 149.17,81.91 149.17,78.04 149.14,78 149.14,77.56 148.66,77.08 145.23,77.08 144.91,77.4 143.64,77.4 143.39,77.65 143.39,82.16
+1.0V_PRIM_COREP on TOP (solid shape): 191.65,29.01 191.65,26.47 191.59,26.41 191.59,25.84 191.84,25.58 191.84,25.01 191.78,24.95 188.86,24.95 188.6,25.2 188.6,29.27 188.73,29.39 191.27,29.39
+1.0V_VCCST on TOP (solid shape): outline of 664 points within 139.9,84.27 147.52,107.44
+1.0V_VCCST on BOTTOM (solid shape): 119,107.59 119,105.87 118.95,105.81 118.88,105.81 118.87,105.82 118.75,105.84 118.63,105.82 118.63,105.81 118.44,105.81 118.37,105.75 115.71,105.75 115.64,105.81 115.64,107.64 115.8,107.8 118.79,107.8
+1.0V_VCCST_C on TOP (solid shape): 148.15,108.46 148.91,108.46 148.91,108.45 149.04,108.32 149.04,106.18 148.64,105.78 147.71,105.78 147.65,105.84 147.65,107.3 147.1,107.84 146.36,107.84 146.28,107.93 146.28,108.62 146.34,108.68 147.93,108.68
+1.0V_VCCSTG on TOP (solid shape): outline of 228 points within 100.65,95.54 107.95,98.95
+1.0V_VCCSTG on TOP (solid shape): outline of 292 points within 136.47,90.61 143.58,106.74
+1.0V_VCCSTG on BOTTOM (solid shape): 137.93,92.26 137.93,91.4 137.92,91.39 137.92,90.94 137.93,90.93 137.93,90.8 137.48,90.35 137.1,90.35 137.05,90.41 137.05,91.26 137.15,91.37 137.15,91.48 137.19,91.55 137.21,91.62 137.21,91.73 137.36,91.88 137.36,92.27 137.41,92.32 137.86,92.32
+1.0V_VCCSTG_C on TOP (solid shape): 143.23,108.48 143.23,107.75 143.36,107.63 144.15,107.63 144.28,107.5 144.28,107.05 144.15,106.93 141.55,106.93 141.33,106.71 140.01,106.71 139.9,106.83 139.9,107.56 140.09,107.75 141.27,107.75 141.39,107.88 141.39,108.55 141.46,108.62 143.09,108.62
+1.0VS_VCCIO on TOP (solid shape): 72.52,29.51 72.62,29.52 74.36,29.52 74.56,29.33 77.41,29.33 77.79,28.95 77.79,27.36 77.67,27.24 77.24,27.24 77.24,27.69 76.79,27.69 76.79,27.24 76.44,27.24 76.44,27.69 75.99,27.69 75.99,27.24 73.79,27.24 72.97,26.41 70.91,26.41 70.81,26.52 70.81,29.2 71.08,29.47 71.14,29.49 71.18,29.52 72.43,29.52
+1.0VS_VCCIO on TOP (solid shape): 141.36,81.85 141.36,81.15 141.17,80.96 140.72,80.96 140.47,80.7 140.47,80.26 140.28,80.07 139.2,80.07 139.11,79.98 139.08,79.98 138.97,79.87 138.97,77.53 138.72,77.28 138.72,77.07 138.52,76.86 138.52,76.68 138.68,76.51 138.68,76.42 138.81,76.28 138.85,76.24 138.85,74.84 138.66,74.65 138.68,74.56 138.69,74.46 138.66,74.37 138.64,74.34 138.64,74.28 138.55,74.18 137.41,74.18 137.32,74.28 137.32,74.62 137.39,74.69 137.71,74.69 137.74,74.72 137.98,74.72 137.98,74.76 138.02,74.8 138.02,76.35 137.92,76.44 137.81,76.44 137.62,76.62 137.48,76.62 137.41,76.7 137.41,77.98 138.07,77.98 138.11,78.02 138.13,78.02 138.24,78.14 138.63,78.14 138.73,78.23 138.73,78.28 138.73,78.28 138.73,78.76 138.73,78.76 138.73,78.8 138.62,78.91 138.36,78.91 138.3,78.97 138.3,79.6 138.48,79.78 138.48,80.21 138.56,80.3 138.73,80.3 138.75,80.32 138.76,80.32 138.84,80.4 138.84,80.41 138.86,80.43 138.86,81.99 138.97,82.1 141.1,82.1
+1.0VS_VCCIO on TOP (solid shape): outline of 86 points within 124.2,74.25 128.7,77.31
+1.0VS_VCCIO on BOTTOM (solid shape): outline of 190 points within 137.3,74.24 138.74,77.31
+1.0VS_VCCIO on BOTTOM (solid shape): outline of 240 points within 126.36,74.24 128.69,77.31
+1.0VS_VCCIO on IN2 (solid shape): outline of 552 points within 128.58,90.42 141.92,100.22
+1.0VS_VCCIO on IN4: outline of 147 points within 45.16,24.76 141.39,81.99
+1.2V_DDRP on TOP (solid shape): 224.23,32.24 224.23,30.12 223.96,29.86 223.15,29.86 223.06,29.94 223.06,32.28 223.14,32.36 224.11,32.36
+1.2V_DDRP on TOP (solid shape): outline of 352 points within 201.94,29.52 211.78,35.36
+1.2V_DDRP on BOTTOM (solid shape): 212.01,32.89 214.29,32.89 214.36,32.82 214.36,31.54 214.2,31.39 211.04,31.39 209.93,30.28 209.93,26.81 209.46,26.35 206.51,26.35 206.19,26.66 206.19,33.06 206.34,33.2 211.7,33.2
+1.2V_DDRP on IN3 (solid shape): 212.29,32.16 212.29,31.33 212.03,31.08 210.03,31.08 209.77,31.34 209.77,32.36 209.94,32.53 211.91,32.53
+1.2V_DDRP on IN3 (solid shape): 224.22,31.14 224.22,30.28 223.98,30.04 222.37,30.04 222.19,30.22 222.19,31.2 222.26,31.27 224.1,31.27
+1.2V_LDO on TOP (solid shape): 291.49,64.88 291.49,63.81 291.3,63.62 291.3,63.45 290.8,62.95 290.8,62.74 290.76,62.69 290.39,62.69 290.26,62.82 290.26,63.7 290.46,63.9 291.07,63.9 291.28,64.11 291.28,64.88 291.35,64.94 291.43,64.94
+1.2V_LDO on TOP (solid shape): 293.09,64.88 293.09,64.14 293.44,63.78 293.5,63.78 293.73,63.56 294.03,63.56 294.77,62.81 294.77,62.22 294.65,62.1 294.05,62.1 293.98,62.17 293.49,62.17 293.45,62.21 293.45,62.78 293.35,62.87 293.35,63.45 292.87,63.93 292.87,64.87 292.93,64.93 293.04,64.93
+1.2V_LDO on BOTTOM (solid shape): 294.18,63.58 294.18,62.95 294.08,62.85 293.8,62.85 293.43,63.22 293.41,63.22 292.89,63.73 291.9,63.73 291.48,63.78 291.31,63.4 291.18,63.27 290.84,63.27 290.73,63.38 290.72,63.38 290.72,63.41 290.69,63.43 290.69,64.05 291.21,64.57 293.19,64.57
+1.2V_MEM on TOP (solid shape): 95.94,44.12 85.94,44.12 85.94,59.12 95.94,59.12
+1.2V_MEM on TOP (solid shape): 113.99,48.44 105.99,48.44 105.99,56.44 113.99,56.44
+1.2V_MEM on TOP (solid shape): 132.66,45.78 124.66,45.78 124.66,53.78 132.66,53.78
+1.2V_MEM on TOP (solid shape): outline of 31300 points within 56.86,29.06 215.85,75.42
+1.2V_MEM on IN2: 85.25,30.4 90.1,30.4 90.33,30.17 90.33,29.07 90.12,28.86 85.36,28.86 85.14,29.08 85.14,30.28
+1.05VALWP on TOP (solid shape): 179.58,111.12 179.58,109.79 179.27,109.47 175.27,109.47 175.01,109.72 175.01,111.12 175.14,111.25 176.16,111.25 176.28,111.37 179.33,111.37
+1.05VALWP on BOTTOM (solid shape): 182.25,111.5 182.25,108.2 181.62,107.56 171.86,107.56 171.82,107.6 171.82,108.26 171.32,108.26 171.32,108.26 171.32,108.71 171.82,108.71 171.82,109.46 171.32,109.46 171.32,109.91 171.82,109.91 171.82,110.56 172.45,111.19 175.97,111.19 176.28,111.5 179.33,111.5 179.58,111.75 182,111.75
+1.8V_ANT on BOTTOM (solid shape): 305.58,98.09 306.21,98.09 306.25,98.05 306.25,97.95 306.22,97.91 305.64,97.91 305.41,97.68 304.45,97.68 304.32,97.81 304.32,98.11 304.46,98.24 305.42,98.24
+1.8V_ANT_R on TOP (solid shape): 299.02,94.27 299.02,93.32 298.44,92.74 297.77,92.74 297.71,92.8 297.71,93.66 297.72,93.68 298,93.97 298,94.12 298.26,94.38 298.91,94.38
+1.8V_ANT_R on IN3 (solid shape): 298.5,93.62 298.5,92.29 298.35,92.14 297.81,92.14 297.71,92.24 297.71,93.63 297.85,93.77 298.34,93.77
+1.8V_PRIM on TOP (solid shape): 30.56,30.96 30.56,29.92 30.42,29.78 28.95,29.78 28.82,29.91 28.82,30.88 29.03,31.1 30.42,31.1
+1.8V_PRIM on TOP (solid shape): 294.01,20.8 294.01,19.46 293.82,19.27 292.84,19.27 292.73,19.37 292.73,20.74 292.88,20.88 293.92,20.88
+1.8V_PRIM on TOP (solid shape): 287.56,81.85 287.56,80.53 287.5,80.47 287.05,80.47 286.97,80.39 285.61,80.39 285.57,80.43 285.57,80.75 286.11,80.75 286.11,81.17 285.57,81.17 285.57,81.59 285.56,81.6 285.56,81.71 285.82,81.97 287.43,81.97
+1.8V_PRIM on TOP (solid shape): outline of 129 points within 171.14,94.2 174,106.42
+1.8V_PRIM on BOTTOM (solid shape): 173.36,106.05 173.36,105.4 172.95,104.99 172.88,104.99 172.29,104.4 172.29,102.94 172.15,102.8 170.63,102.8 170.44,102.99 170.44,105.91 170.9,106.37 173.03,106.37
+1.8V_PRIM on BOTTOM (solid shape): 148.5,82.15 148.51,82.08 148.53,82.02 148.53,81.22 148.53,81.21 148.5,81.1 148.53,81 148.53,80.99 148.53,80.23 148.01,79.7 147.24,79.7 147.11,79.83 147.11,79.98 147.32,80.19 147.32,80.45 147.08,80.7 147.08,80.84 147.11,80.85 147.16,80.89 147.2,80.93 147.22,80.94 147.31,80.94 147.33,80.93 147.5,80.82 147.7,80.83 147.71,80.83 147.76,80.83 147.9,80.97 147.9,80.99 147.9,81 147.92,81.3 147.7,81.5 147.69,81.5 147.31,81.89 147.31,82.1 147.26,82.15 147.26,82.15 147.19,82.25 147.1,82.32 147.1,82.49 147.18,82.57 147.63,82.57 147.64,82.59 148.07,82.59
+1.8V_PRIM on IN4 (solid shape): 206.32,36.19 206.32,35.3 206.25,35.24 205.53,35.24 204.29,36.48 204.29,37.27 204.33,37.32 205.2,37.32
+1.8V_PRIM on IN4 (solid shape): 294.14,20 294.14,19.23 293.95,19.04 291.92,19.04 291.73,19.23 291.73,20.19 291.79,20.25 293.88,20.25
+1.8V_PRIM on IN3: 30.8,31.36 30.87,31.3 30.87,30.41 30.17,29.71 28.96,29.71 28.66,30.01 28.66,31.05 28.98,31.36
+1.8V_PRIM on IN3: 203.52,37.71 205.68,37.71 205.81,37.59 205.81,36.63 205.62,36.44 203.4,36.44 203.27,36.57 203.27,37.46
+1.8V_PRIM on IN3: 171.27,95.12 173.49,95.12 176.92,91.69 176.92,84.26 175.65,82.99 174,82.99 173.3,83.69 173.3,90.8 170.95,93.15 170.95,94.8
+1.8V_PRIM on VCC: outline of 84 points within 278.39,18.92 297.19,82.54
+1.8V_PRIM on VCC: 147.33,78.8 147.33,82.18 147.56,82.42 160.51,82.42 162.54,84.45 166.23,84.45 168.79,87.01 168.79,94.23 170.42,94.23 171.56,95.37 177.95,95.37 179.46,93.87 179.46,91.18 175.29,91.18 174.5,90.4 174.5,87.35 172.24,85.08 171.48,85.08 167.92,81.53 163.6,81.53 160.87,78.8
+1.8V_PRIM on IN4: 278.33,27.81 278.64,28.12 278.64,29.71 278.26,30.09 273.56,30.09 273.06,29.58 255.59,29.58 255.15,29.14 255.15,28.57 255.91,27.81
+1.8V_PRIM on IN4: 176.28,83.05 176.28,80.89 175.9,80.51 174.95,80.51 174.95,80.7 173.93,81.72 171.65,81.72 171.2,81.27 171.2,80.13 170.76,79.69 147.64,79.69 147.26,80.07 147.26,82.23 148.28,83.24 149.1,83.24 151.45,85.59 173.04,85.59 173.3,85.34 174,85.34 ; 3 cut-outs
+1.8V_PRIM_VTR3 on TOP (solid shape): 285.47,81.55 285.47,81.07 286.01,81.07 286.01,80.85 285.47,80.85 285.47,80.45 285.43,80.41 285.18,80.41 285,80.58 284.84,80.59 284.78,80.58 284.2,80.58 284.12,80.66 284.12,81.06 284.77,81.71 285.31,81.71
+1.8V_RUN on TOP (solid shape): 283.53,33.59 283.53,32.12 282.26,30.85 282.26,30.35 282.04,30.12 280.9,30.12 280.55,30.47 280.55,30.92 280.87,31.24 280.87,32.63 280.99,32.76 282.2,32.76 282.39,32.95 282.39,33.65 282.49,33.75 283.37,33.75
+1.8V_RUN on TOP (solid shape): 291.36,24.47 291.36,22.21 291.12,21.98 289.49,21.98 289.12,22.35 289.12,22.75 289.43,22.75 289.43,22.7 289.43,22.65 289.45,22.6 289.47,22.55 289.5,22.51 289.54,22.47 289.58,22.44 289.63,22.42 289.68,22.4 289.73,22.4 289.78,22.4 289.83,22.4 289.88,22.42 289.93,22.44 289.97,22.47 290.01,22.51 290.04,22.55 290.06,22.6 290.08,22.65 290.09,22.7 290.09,22.75 290.08,22.8 290.06,22.85 290.04,22.9 290.01,22.94 289.97,22.98 289.93,23.01 289.88,23.03 289.83,23.05 289.78,23.06 289.73,23.06 289.68,23.05 289.63,23.03 289.58,23.01 289.54,22.98 289.5,22.94 289.47,22.9 289.45,22.85 289.43,22.8 289.43,22.75 289.12,22.75 289.12,24.44 289.36,24.68 291.15,24.68
+1.8V_RUN on IN3 (solid shape): 282.39,29.97 282.39,29.2 282.2,29.01 281.5,29.01 280.49,30.03 280.49,30.92 280.68,31.11 281.25,31.11
+1.8V_RUN on IN3 (solid shape): 291.44,23.46 291.44,22.12 291.25,21.93 290.32,21.93 290.14,22.11 290.14,22.98 290.01,23.11 290.01,23.74 290.2,23.93 290.96,23.93
+1.8V_RUN_AUDIO on TOP (solid shape): 282.11,36.52 282.11,36.48 282.17,36.42 282.17,36.37 282.2,36.34 282.2,36.07 282.43,35.84 282.77,35.84 282.88,35.74 282.88,35.37 283.1,35.15 284.15,35.15 284.39,34.91 284.41,34.88 284.4,34.84 284.42,34.51 284.74,34.48 284.82,34.48 285,34.3 285.55,34.3 285.71,34.13 287.22,34.13 287.36,34 287.36,33.01 287.16,32.81 284.2,32.81 283.77,33.24 283.77,33.79 283.41,34.14 283.41,34.41 282.52,34.41 282.28,34.17 281.59,34.17 281.51,34.25 281.51,35.13 281.75,35.37 281.75,36.1 281.75,36.11 281.77,36.21 281.75,36.32 281.75,36.33 281.75,36.51 281.84,36.61 282.03,36.61
+1.8V_RUN_CARD on TOP (solid shape): 311.36,67.67 311.36,66.74 311.29,66.67 310.59,66.67 310.44,66.82 310.44,67.77 310.54,67.87 311.17,67.87
+1.8V_RUN_CARD on TOP (solid shape): 292.68,64.88 292.68,63.79 293.19,63.28 293.19,62.87 293.34,62.72 293.34,62.39 293.27,62.31 292.81,62.31 292.68,62.44 292.68,63.46 292.48,63.66 292.48,64.88 292.53,64.93 292.63,64.93
+1.8V_RUN_CARD on BOTTOM (solid shape): 309.06,68.49 309.51,68.04 310.77,68.04 311.16,67.65 311.16,66.91 310.82,66.57 310.5,66.57 310.13,66.94 309.11,66.94 308.36,67.69 308.36,68.44 308.42,68.51 309.04,68.51
+1.8V_RUN_CARD on IN2 (solid shape): 293.14,63.35 293.14,63.28 293.62,62.8 293.9,62.8 294.11,62.59 294.11,61.98 293.85,61.73 293.19,61.73 292.68,62.24 292.68,63.3 292.89,63.51 292.99,63.51
+1.8V_RUN_CARD on IN2 (solid shape): 312.02,67.84 312.02,66.11 311.73,65.82 311.66,65.81 311.6,65.79 310.76,65.79 310.6,65.95 310.6,67.88 310.71,68 311.86,68
+1.8V_RUN_UZ8 on TOP (solid shape): 292.99,24.16 293.84,24.16 294.02,23.98 294.02,22.33 293.93,22.24 291.96,22.24 291.53,22.67 291.53,23.66 292.02,23.66 292.02,24.04 291.53,24.04 291.53,24.5 291.64,24.61 292.54,24.61
+1.8VALWP on TOP (solid shape): 176.22,103.88 176.22,103.5 175.2,102.48 174.19,102.48 173.93,102.74 173.93,103.5 174.19,103.75 174.95,103.75 175.2,104.01 176.09,104.01
+1.8VALWP on BOTTOM (solid shape): 173.68,104.64 173.68,104.13 174,103.82 174.95,103.82 175.45,104.31 177.5,104.31 178.28,103.54 178.28,102.25 177.81,101.78 173.23,101.78 172.45,102.57 172.45,103.63 172.96,103.63 172.96,104.02 172.45,104.02 172.45,104.36 172.79,104.71 173.62,104.71
+1VS_VCCIOP on TOP (solid shape): 79.67,27.71 79.67,25.24 79.57,25.14 79,25.14 78.68,24.82 77.16,24.82 77.15,24.82 75.1,24.82 74.59,24.31 73.09,24.31 72.9,24.5 72.9,25.97 73.92,26.98 77.86,26.98 78.05,27.17 78.05,27.55 78.24,27.74 79.64,27.74
+2.5V_MEM on TOP (solid shape): 116.85,28.82 116.85,27.55 116.59,27.3 115.32,27.3 115,27.62 115,28.76 115.26,29.01 116.66,29.01
+2.5V_MEM on TOP (solid shape): 126.84,40.75 126.84,39.1 126.58,38.84 123.41,38.84 123.28,38.97 123.28,40.75 123.51,40.98 126.61,40.98
+2.5V_MEM on TOP (solid shape): 202.59,40.94 202.59,39.29 202.44,39.15 202.36,39.15 202.18,38.98 202.18,37.91 201.87,37.59 201.87,37.01 201.51,36.65 200.92,36.65 200.65,36.65 200.63,36.67 200.63,40.4 200.77,40.54 200.77,40.95 200.88,41.06 202.47,41.06
+2.5V_MEM on BOTTOM (solid shape): 124.75,40 124.75,38.48 124.62,38.35 123.42,38.35 123.29,38.48 123.29,40.06 123.35,40.13 124.62,40.13
+2.5V_MEM on BOTTOM (solid shape): 202.24,40.86 202.24,38.58 201.95,38.29 200.63,38.29 200.47,38.45 200.47,40.7 200.89,41.12 201.98,41.12
+2.5V_MEM on IN4 (solid shape): 116.81,28.92 116.81,27.65 116.56,27.39 115.29,27.39 114.97,27.71 114.97,28.85 115.23,29.11 116.62,29.11
+2.5V_MEM on IN4 (solid shape): 202,40.32 202,38.73 201.75,38.47 200.98,38.47 200.76,38.7 200.76,40.67 200.92,40.82 201.49,40.82
+2.5V_MEM on IN4 (solid shape): 125.82,39.79 125.82,38.59 125.69,38.46 124.3,38.46 124.04,38.72 124.04,39.79 124.19,39.94 125.67,39.94
+2.7V_ANT on BOTTOM (solid shape): 306.28,107.27 306.28,107.22 306.2,107.14 305.85,107.14 305.23,106.52 304.56,106.52 304.41,106.67 304.41,106.86 304.79,107.23 304.82,107.26 305.66,107.26 305.73,107.33 306.22,107.33
+2.7V_ANT on BOTTOM (solid shape): 306.27,97.69 306.27,97.62 306.21,97.56 305.87,97.56 305.45,97.14 304.04,97.14 303.93,97.25 303.93,97.48 304.08,97.63 304.23,97.63 304.28,97.58 304.52,97.58 304.58,97.58 305.46,97.58 305.62,97.73 306.22,97.73
+2.7V_ANT_R on TOP (solid shape): 301.39,94.29 301.39,93.07 301.06,92.74 299.11,92.74 299.05,92.8 299.05,93.15 299.2,93.3 300.46,93.3 300.63,93.48 300.63,94.19 300.63,94.27 300.71,94.35 301.33,94.35
+2.7V_ANT_R on IN3 (solid shape): 300.26,93.17 300.26,92.83 300.07,92.65 299.35,92.65 298.92,92.22 298.79,92.22 298.67,92.34 298.67,92.95 299.06,93.34 300.08,93.34
+3.3V_5V_RUN_QV8 on TOP (solid shape): 81.25,110.85 81.25,109.65 81.05,109.65 81.05,108.74 80.8,108.74 80.79,108.75 80.5,108.67 80.39,108.39 80.39,108.36 79.16,107.13 78.5,107.13 78.38,107.26 78.38,108.21 79.89,109.72 79.89,110.68 80.12,110.92 81.19,110.92
+3.3V_ALW on TOP (solid shape): 126.5,29.2 126.5,27.81 126.18,27.49 124.72,27.49 124.36,27.85 124.36,28.24 124.87,28.24 124.87,28.62 124.36,28.62 124.36,29.04 124.76,29.43 126.27,29.43
+3.3V_ALW on TOP (solid shape): 175.85,28.71 175.85,28.12 175.29,28.12 175.29,27.62 175.85,27.62 175.85,27.27 175.46,26.87 175.46,25.33 175.33,25.2 173.81,25.2 173.49,25.52 173.49,28.11 174.17,28.79 175.77,28.79
+3.3V_ALW on TOP (solid shape): 27.89,92.54 27.89,90.91 27.41,90.42 27.37,90.43 27.25,90.45 27.13,90.43 26.79,90.43 26.59,90.63 26.59,92.02 27.19,92.62 27.81,92.62
+3.3V_ALW on TOP (solid shape): 268.36,32.34 268.36,31.91 268.3,31.85 267.74,31.85 267.57,31.68 267.57,31.29 267.47,31.18 266.69,31.18 266.46,31.42 266.46,32.32 266.59,32.45 268.25,32.45
+3.3V_ALW on TOP (solid shape): 184.09,98.16 184.09,95.78 183.77,95.46 183.05,95.46 182.62,95.03 181.92,95.03 181.85,95.09 181.85,95.66 181.79,95.73 181.79,95.74 181.64,95.89 181.64,98.17 182.17,98.7 183.54,98.7
+3.3V_ALW on TOP (solid shape): 184.73,92.83 184.73,92.77 185.05,92.45 187.78,92.45 188.28,91.94 188.28,86.35 188.14,86.21 186.7,86.21 186.63,86.28 186.63,88.64 186.32,88.96 182.89,88.96 181.82,90.03 181.82,93.55 181.92,93.66 183.9,93.66
+3.3V_ALW on TOP (solid shape): 29.79,34.09 29.79,32.06 29.41,31.68 28.01,31.68 27.8,31.47 27.8,30.98 27.68,30.87 26.6,30.87 26.44,31.03 26.44,32.99 26.51,33.07 27.43,33.07 28.58,34.22 29.66,34.22
+3.3V_ALW on TOP (solid shape): 171.27,66.1 171.27,65.56 171.91,64.91 171.91,63.06 171.76,62.92 169.94,62.92 168.85,64 168.22,64 168.15,64.07 168.15,64.76 168.47,65.08 169.49,65.08 169.74,65.34 169.74,66.22 169.93,66.41 170.95,66.41
+3.3V_ALW on TOP (solid shape): 262.15,54.35 262.33,54.33 262.5,54.35 262.58,54.35 262.71,54.22 262.71,52 262.32,51.62 260.81,51.62 260.03,52.41 260.03,53.55 260.17,53.7 260.79,53.7 260.93,53.84 260.93,54.29 260.99,54.35 262.15,54.35
+3.3V_ALW on TOP (solid shape): 265.7,48.5 265.7,47 265.6,46.9 265.6,45.23 265.8,45.03 265.82,44.9 265.89,44.79 265.89,44 265.79,43.9 264.45,43.9 264.45,43.9 263.07,43.9 262.87,44.11 262.84,44.17 262.81,44.22 262.81,44.93 262.69,45.06 262.69,47.92 263.35,48.58 265.62,48.58
+3.3V_ALW on TOP (solid shape): 276.25,71.72 276.73,71.72 276.73,72.26 277.12,72.26 277.27,72.1 277.27,71.6 276.43,70.76 276.32,70.58 276.3,70.38 276.3,70.37 276.3,69.41 276.15,69.26 274.48,69.26 274.35,69.13 273.39,69.13 273.31,69.21 273.31,70.54 273.37,70.61 274.24,70.61 274.54,70.91 275.15,70.91 275.53,71.29 275.53,72.13 275.66,72.26 276.25,72.26
+3.3V_ALW on BOTTOM (solid shape): 44.52,103.56 44.52,103.3 44.98,102.85 44.98,101.85 44.71,101.59 44.28,101.59 43.92,101.94 43.92,102.23 43.76,102.4 43.76,103.5 43.95,103.69 44.39,103.69
+3.3V_ALW on BOTTOM (solid shape): 267.66,33.25 267.66,31.68 267.6,31.49 267.66,31.3 267.66,30.98 267.63,30.97 267.48,30.84 267.43,30.66 267.43,30.64 267.29,30.5 266.36,30.5 266.26,30.6 266.26,33.18 266.42,33.35 267.57,33.35
+3.3V_ALW on BOTTOM (solid shape): 101.61,99.56 101.92,99.56 101.93,99.56 102.08,99.53 102.23,99.56 102.24,99.56 102.99,99.56 102.99,99.56 103.11,99.54 103.23,99.56 103.26,99.56 103.34,99.48 103.34,99.01 103.13,98.8 101.48,98.8 101.23,98.55 100.65,98.55 100.46,98.74 100.46,99.24 101.03,99.82 101.35,99.82
+3.3V_ALW on BOTTOM (solid shape): outline of 391 points within 181.36,85.27 187.39,104.2
+3.3V_ALW on IN1 (solid shape): 28.72,92.54 28.72,91.77 28.62,91.67 27.01,91.67 26.93,91.75 26.93,92.32 27.23,92.62 28.64,92.62
+3.3V_ALW on IN1 (solid shape): outline of 694 points within 181.17,88.96 187.27,104.13
+3.3V_ALW on IN2 (solid shape): 126.56,29.27 126.56,28.25 126.43,28.12 124.72,28.12 124.4,28.44 124.4,29.14 124.66,29.39 126.43,29.39
+3.3V_ALW on IN3 (solid shape): 45.15,102.37 45.15,100.39 44.14,99.37 41.43,99.37 41.31,99.61 41.15,99.81 41.15,100.49 41.42,100.77 43.63,100.77 43.95,101.09 43.95,102.1 44.37,102.52 45,102.52
+3.3V_ALW on IN1: outline of 84 points within 266.33,91.12 296.41,98.04
+3.3V_ALW on IN2: 172.98,26.41 173.74,25.65 175.39,25.65 192.28,42.54 192.28,44.82 191.14,45.97 189.81,45.97 183.65,39.81 173.87,39.81 172.98,38.92
+3.3V_ALW on IN2: 35.72,31.2 38.36,28.57 40.96,28.57 41.79,29.39 46.36,29.39 48.08,27.68 66.87,27.68 67.11,27.44 80.34,27.44 80.7,27.79 80.7,28.98 79.58,30.09 49.28,30.09 45.03,34.35 40.27,34.35 40.01,34.09 30.17,34.09 29.53,33.46 27.85,33.46 27.44,33.05 27.44,31.68 27.91,31.2
+3.3V_ALW on VCC: outline of 131 points within 23.76,29.46 287.53,108.45 ; 2 cut-outs
+3.3V_ALW_DSW on TOP (solid shape): outline of 3417 points within 141.23,60.08 168.87,78.06
+3.3V_ALW_DSW on IN3: 143.42,76.73 143.42,78.14 143.61,78.33 143.61,78.73 143.2,79.13 141.91,79.13 141.44,78.66 138.81,78.66 137.48,77.34 137.48,75.58 133.18,71.28 114.13,71.28 105.42,62.57 89.63,62.57 88.51,61.45 88.51,58.8 89.94,57.37 126.25,57.37 130.99,62.11 130.99,65.78 135.21,70 139.65,70 140.41,70.76 140.41,73.48 140.24,73.64 140.24,75.76 140.88,76.4 142.05,76.4 142.1,76.35 142.1,75.74 142.25,75.59 143.59,75.59 143.75,75.74 143.75,76.4
+3.3V_ALW_DSW_R on TOP (solid shape): 172.42,62.38 172.42,61.61 172.05,61.23 169.58,61.23 169.55,61.26 168.67,61.26 168.64,61.23 168,61.23 167.94,61.29 167.94,61.89 168.02,61.98 169.4,61.98 169.98,62.56 172.24,62.56
+3.3V_ALW_PCH on TOP (solid shape): 168.54,59.73 168.54,58.6 168.46,58.52 165.46,58.52 165.36,58.62 165.36,59.75 165.46,59.85 168.43,59.85
+3.3V_ALW_PCH on TOP (solid shape): 248.69,50.18 248.69,50.07 247.85,49.22 247.73,49.22 246.49,50.46 246.49,50.65 247.15,51.3 247.57,51.3
+3.3V_ALW_PCH on TOP (solid shape): 197.71,72.35 197.71,70.93 197.62,70.84 196.38,70.84 196.25,70.97 196.25,72.4 196.41,72.56 197.5,72.56
+3.3V_ALW_PCH on TOP (solid shape): 169.04,80.38 169.04,79.75 168.98,79.69 168.54,79.69 168.34,79.5 168.34,79.24 168.28,79.18 167.27,79.18 167.12,79.32 167.12,80.05 167.25,80.18 167.25,80.42 167.4,80.57 168.86,80.57
+3.3V_ALW_PCH on TOP (solid shape): 251.61,44.18 251.61,38.25 251.19,37.83 248.86,37.83 248.7,37.99 248.7,38.1 248.72,38.12 248.8,38.34 248.7,38.57 248.7,39.41 248.96,39.67 249.88,39.67 250.2,39.98 250.2,41.34 250.21,41.37 250.25,41.39 250.58,41.72 250.25,42.05 250.21,42.06 250.2,42.1 250.2,43.87 250.7,44.38 251.4,44.38
+3.3V_ALW_PCH on TOP (solid shape): 176.28,94.16 176.28,92.26 177.79,90.75 180.47,90.75 180.69,90.53 180.69,88.4 180.7,88.39 180.7,87.92 180.47,87.69 180.47,86.76 180.25,86.53 179.1,86.53 178.71,86.14 178.71,85.55 178.66,85.5 177.65,85.5 177.54,85.76 177.28,85.85 177.12,85.78 177.01,85.64 176.94,85.58 176.85,85.61 176.37,86.09 176.37,87.2 175.36,88.21 175.06,88.21 174.91,88.36 174.91,88.94 175.66,88.94 175.66,88.98 175.8,88.98 175.88,88.9 176.18,88.9 176.38,89.11 176.38,89.4 176.1,89.69 175.66,89.69 175.66,89.73 174.89,89.73 174.89,93.85 174.63,94.1 174.63,94.61 174.76,94.74 175.71,94.74
+3.3V_ALW_PCH on BOTTOM (solid shape): 250.58,38.72 250.58,38.02 250.49,37.93 248.88,37.93 248.74,38.07 248.74,38.14 248.74,38.15 248.8,38.31 248.77,38.46 248.76,38.5 248.86,38.6 249.46,38.6 249.66,38.81 250.49,38.81
+3.3V_ALW_PCH on BOTTOM (solid shape): 299.1,31.32 299.1,25.28 298.46,24.64 295.54,24.64 295.47,24.65 295.4,24.64 293.91,24.64 293.81,24.75 293.81,26.75 294.19,27.13 295.04,27.13 297.51,29.6 298.01,29.6 298.22,29.81 298.22,31.48 298.37,31.63 298.78,31.63
+3.3V_ALW_PCH on BOTTOM (solid shape): 147.35,78.37 147.37,78.37 147.38,78.36 147.6,78.29 147.81,78.37 148.05,78.37 148.5,77.92 148.5,76.88 148.35,76.72 148.08,76.72 147.92,76.79 147.75,76.72 147.43,76.72 147.27,76.79 147.1,76.72 146.79,76.72 146.46,77.05 146.46,78.34 146.52,78.4 147.32,78.4
+3.3V_ALW_PCH on BOTTOM (solid shape): 172.15,70.12 172.15,68.36 172.06,68.26 171.32,68.26 171.22,68.36 171.22,68.83 171.11,68.95 170.98,68.95 170.97,68.95 170.87,69 170.75,69.01 170.17,69.01 169.77,68.77 169.81,68.3 169.81,67.71 169.72,67.62 168.98,67.62 168.9,67.7 168.9,69.09 168.97,69.12 169.03,69.17 169.44,69.58 170.52,69.58 170.54,69.57 170.75,69.52 170.97,69.57 170.98,69.58 171.11,69.58 171.26,69.73 171.26,70.12 171.39,70.24 172.03,70.24
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 309 points within 158.2,54.43 167.04,59.33
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 333 points within 168.28,84.83 179.46,91.44
+3.3V_ALW_PCH on IN1 (solid shape): outline of 430 points within 248.73,37.11 269.58,42.22
+3.3V_ALW_PCH on IN1 (solid shape): outline of 1321 points within 141.42,76.07 148.66,81.65
+3.3V_ALW_PCH on IN2 (solid shape): outline of 314 points within 171.87,81.97 177.87,88.89
+3.3V_ALW_PCH on IN3 (solid shape): 248.16,50.83 248.16,50.48 246.79,49.1 246.61,49.1 246.2,49.52 246.2,50.36 247.21,51.37 247.62,51.37
+3.3V_ALW_PCH on IN3 (solid shape): 197.23,71.61 197.23,70.12 197.05,69.94 196.24,69.94 196.1,70.08 196.1,71.56 196.32,71.79 197.05,71.79
+3.3V_ALW_PCH on IN4 (solid shape): 270.49,41.45 270.49,40.09 270.43,40.03 269.11,40.03 268.56,40.58 268.56,41.32 268.92,41.67 270.26,41.67
+3.3V_ALW_PCH on IN4 (solid shape): outline of 430 points within 141.49,75.87 148.49,78.06
+3.3V_ALW_PCH on IN2: 169.36,79.88 172.98,79.88 173.65,79.21 175.68,79.21 177.04,77.84 178.76,77.84 179.62,76.99 179.62,76.29 182.03,73.88 185.46,73.88 187.01,72.32 196.92,72.32 197.36,71.88 197.36,70.61 196.54,69.78 186.06,69.78 184.35,71.49 180.47,71.49 174.5,77.46 169.87,77.46 168.98,78.35 168.98,79.5
+3.3V_ALW_PCH on IN3: 163.96,82.47 171.46,82.47 172.29,83.3 172.79,83.3 173.61,82.48 174.82,82.48 175.64,83.3 176.09,83.3 176.44,82.95 176.41,82.92 176.41,80.83 175.46,79.88 175.46,78.54 176.22,77.78 178.94,77.78 179.06,77.65 179.06,77.02 178.82,76.78 178.82,76.77 178.76,76.7 176.47,76.7 176.16,76.38 176.16,72.83 175.14,71.81 172.35,71.81 171.17,70.64 171.17,68.03 170.44,67.3 170.44,65.21 167.96,62.73 167.96,59.56 166.82,58.41 165.68,58.41 164.73,59.37 164.73,63.24 167.27,65.78 167.27,70.67 164.91,73.02 164.64,73.02 162.84,74.82 162.84,81.35
+3.3V_ALW_PCH on VCC: 154.54,72.89 151.88,75.56 141.72,75.56 141.36,75.92 141.36,77.91 146.38,77.91 146.76,78.29 161.08,78.29 163.81,81.02 168.13,81.02 171.69,84.58 172.45,84.58 175.01,87.14 175.01,90.19 175.5,90.67 179.46,90.67 179.46,85.57 168.05,74.16 162.08,74.16 160.81,72.89
+3.3V_ALW_PCH_UZ3 on TOP (solid shape): 180.64,93.58 180.64,91.13 180.47,90.95 179.41,90.95 179.41,91.47 179.02,91.47 179.02,90.95 178.6,90.95 178.44,91.11 178.44,92.13 178.54,92.23 178.54,92.68 178.58,92.77 178.68,92.77 178.96,92.75 179.15,92.94 179.23,93.05 179.27,93.18 179.3,93.24 179.35,93.27 179.75,93.67 180.56,93.67
+3.3V_ALW_UE1 on TOP (solid shape): 284.85,89.97 284.85,89.01 284.82,88.97 284.05,88.97 283.79,89.23 283.79,89.66 284.17,90.04 284.78,90.04
+3.3V_ALW_UE1 on TOP (solid shape): 277.59,73.69 277.59,72.83 277.18,72.42 275.79,72.42 275.68,72.53 275.68,72.99 275.78,73.09 276.22,73.09 276.56,73.43 276.56,73.85 276.67,73.95 277.33,73.95
+3.3V_ALW_UZ12 on TOP (solid shape): 186.32,86.8 186.32,86.23 185.87,85.78 185.87,84.51 185.81,84.45 185.17,84.45 185.11,84.51 185.11,85.02 185.05,85.08 185.05,86.73 185.17,86.86 186.25,86.86
+3.3V_ALWP on TOP (solid shape): 191.23,90.2 191.23,89.1 190.95,88.82 190.95,88.13 190.76,87.94 190.13,87.94 190,87.81 190,84 190.19,83.81 190.19,82.23 190.06,82.1 189.57,82.1 189.52,82.15 189.52,83.47 189.3,83.69 188.92,83.69 188.73,83.88 188.73,90.04 189.02,90.33 191.1,90.33
+3.3V_ALWP on BOTTOM (solid shape): 194.06,92.39 194.06,90.35 192.89,89.18 191.49,89.18 191.14,88.83 191.14,88 190.95,87.81 190.19,87.81 189.93,87.56 189.93,84 189.87,83.94 188.73,83.94 188.09,84.58 187.59,84.58 186.82,85.34 186.82,86.5 186.25,86.5 186.25,86.93 186.8,86.93 186.8,87.7 186.25,87.7 186.25,88.13 186.82,88.13 186.82,89.08 187.52,89.78 187.52,91.37 188.86,92.7 189.11,92.7 190.38,93.97 192.47,93.97
+3.3V_CAM on TOP (solid shape): 61.71,111.63 61.71,110.92 61.38,110.59 61.38,110.29 61.26,110.18 60.95,110.18 60.33,110.79 58.7,110.79 58.57,110.92 58.57,111.57 58.67,111.67 61.67,111.67
+3.3V_CAM on TOP (solid shape): 54.08,111.42 54.08,110.9 54.54,110.44 54.54,110.22 54.38,110.06 54.17,110.06 53.83,110.23 53.55,109.97 53.55,109.95 53.42,109.82 53.42,108.09 52.94,107.61 51.96,107.61 51.9,107.68 51.9,109.31 51.96,109.37 52.29,109.7 52.29,109.77 52.3,109.78 52.83,110.86 52.99,112.05 53.01,112.13 53.09,112.16 53.35,112.16
+3.3V_EC_PLL on TOP (solid shape): 276.81,77.86 276.81,76.92 276.8,76.91 276.8,76.27 276.53,76 276.53,75.99 276.43,75.88 276.43,73.52 276.27,73.36 275.65,73.36 275.49,73.52 275.49,75.46 276.17,76.14 276.45,76.42 276.45,77.19 276.45,77.2 276.45,77.83 276.56,77.93 276.73,77.93
+3.3V_HDD_M2 on TOP (solid shape): outline of 1135 points within 12.54,19.49 34.33,29.84
+3.3V_MMI_AUX on TOP (solid shape): 296.68,71.3 296.68,71.18 296.3,70.8 295.18,70.8 295.02,70.64 293.48,70.64 293.19,70.35 293.19,70.33 293.14,70.28 293.14,69.83 293.33,69.64 293.33,69.36 293.12,69.15 293.12,69.08 293.09,69.05 293.1,69.05 293.1,68.2 293.04,68.14 292.95,68.14 292.88,68.21 292.88,69.19 292.66,69.41 292.66,69.68 292.46,69.88 292.46,70.5 292.15,70.81 291.64,70.81 291.5,70.96 291.5,71.67 291.59,71.76 292.33,71.76 292.47,71.62 295.54,71.62 295.85,71.94 296.04,71.94
+3.3V_MMI_IN on TOP (solid shape): 298.35,72.38 298.35,72.04 297.76,71.45 297.72,71.42 297.69,71.38 297.53,71.38 296.44,72.47 296.44,72.54 297.18,73.28 297.45,73.28
+3.3V_MMI_IN on TOP (solid shape): 291.9,64.88 291.9,64.02 291.92,64.01 291.92,62.96 291.95,62.92 291.95,62.49 292.19,62.25 292.19,59.18 291.93,58.92 290.64,58.92 290.2,58.48 289.67,58.48 289.54,58.6 289.54,59.24 290.1,59.24 290.1,59.79 289.54,59.79 289.54,60.04 290.1,60.04 290.1,60.59 289.54,60.59 289.54,60.99 289.73,61.18 291.23,61.18 291.55,61.5 291.55,63.17 291.42,63.3 291.42,63.59 291.53,63.7 291.53,63.7 291.68,63.84 291.68,64.88 291.74,64.94 291.84,64.94
+3.3V_MMI_IN on IN2 (solid shape): outline of 273 points within 289.22,62.94 298.41,72.77
+3.3V_RUN on TOP (solid shape): 181.22,60.94 181.22,60 181.03,59.81 179,59.81 178.9,59.91 178.4,59.91 178.06,60.26 178.06,60.94 178.14,61.02 181.14,61.02
+3.3V_RUN on TOP (solid shape): 103.07,107.88 103.07,106.15 102.91,105.99 99.59,105.99 99.5,106.08 99.5,106.73 99.49,106.74 99.49,108.77 99.7,108.98 99.7,109.02 101.92,109.02
+3.3V_RUN on TOP (solid shape): 265.56,30.12 265.56,29.79 265.76,29.59 266.77,29.59 266.92,29.44 266.92,28.92 266.82,28.82 264.67,28.82 264,29.49 264,30.13 264.16,30.29 265.39,30.29
+3.3V_RUN on TOP (solid shape): 289.4,60.88 289.4,60.43 289.95,60.43 289.95,60.18 289.39,60.18 289.39,59.64 289.95,59.64 289.95,59.37 289.41,59.37 289.41,58.72 289.28,58.59 288.03,58.59 287.93,58.69 287.93,60.79 288.09,60.95 289.33,60.95
+3.3V_RUN on TOP (solid shape): 299.35,51.05 299.35,50.52 298.84,50.52 298.84,50.13 299.35,50.13 299.35,49.4 299.07,49.13 295.99,49.13 295.98,49.13 295.85,49.16 295.72,49.13 295.72,49.13 295.45,49.13 295.28,49.29 295.28,50.51 295.36,50.59 295.93,50.59 296.52,51.17 299.22,51.17
+3.3V_RUN on TOP (solid shape): 21.66,94.67 21.66,93.11 21.86,92.92 21.86,92.03 21.82,91.99 21.69,91.99 21.66,92.01 21.66,92.35 21.54,92.47 20.19,92.47 20.19,92.07 20.06,91.93 19.37,91.93 19.15,92.16 19.15,93.47 18.74,93.88 18.74,94.48 18.74,94.48 18.74,94.8 18.88,94.94 21.4,94.94
+3.3V_RUN on TOP (solid shape): 173.21,60.37 173.21,59.67 173.01,59.47 172.81,59.47 172.56,59.73 172.56,59.82 172.52,59.82 172.52,59.94 172.46,60 172,60 171.82,59.82 171.79,59.82 171.79,59.79 171.72,59.72 171.72,58.72 171.53,58.52 169.91,58.52 169.72,58.72 169.72,59.7 169.87,59.85 170.25,59.85 171.18,60.78 172.8,60.78
+3.3V_RUN on TOP (solid shape): 88.8,111.13 88.8,109.35 89.46,108.69 89.46,108.68 89.48,108.68 89.6,108.55 89.92,108.55 89.96,108.52 89.96,107.97 89.66,107.67 88.49,107.67 88.49,107.66 88.16,107.66 88.15,107.67 88.15,108.18 86.79,109.54 84.72,109.54 84.21,109.02 83.57,109.02 83.48,109.11 83.48,109.7 83.3,109.89 81.69,109.89 81.51,110.06 81.51,110.77 81.73,110.99 87.26,110.99 87.67,111.41 88.53,111.41
+3.3V_RUN on TOP (solid shape): 178.85,83.24 179.52,83.24 179.65,83.12 179.65,82.73 179.56,82.64 179.53,82.64 179.22,82.48 179.23,82.13 179.24,82.06 179.2,81.99 179.13,81.92 179.08,81.83 179.07,81.8 178.08,81.8 178,81.88 178,83.45 178.03,83.48 178.61,83.48
+3.3V_RUN on TOP (solid shape): 181.86,64.51 181.86,64.25 181.71,63.98 181.86,63.7 181.86,63.37 181.77,63.28 177.24,63.28 177.11,63.41 177.14,63.44 177.23,63.73 177.06,63.96 177.03,63.98 177.03,64.47 177.2,64.64 181.73,64.64
+3.3V_RUN on TOP (solid shape): 200.4,36.99 200.4,36.56 200.18,36.34 200.18,35.91 200.49,35.6 200.49,35.6 201.02,35.07 201.57,35.07 201.64,35 201.64,34.99 201.77,34.69 202,34.46 202,33.73 201.91,33.64 201.5,33.64 201.43,33.71 201.43,34.16 201.36,34.22 199.97,34.22 199.93,34.18 199.9,34.18 199.9,34.16 199.84,34.09 199.84,33.71 199.8,33.68 198.94,33.68 198.84,33.78 198.84,36.62 199.25,37.03 200.36,37.03
+3.3V_RUN on TOP (solid shape): 22.71,31.59 22.71,31.41 22.68,31.33 22.59,31.31 22.19,30.98 22.59,30.66 22.68,30.64 22.71,30.56 22.71,30.27 22.85,30.13 22.87,30.14 23.26,29.75 23.26,28.98 23.12,28.84 20.1,28.84 19.93,29 19.93,31.08 20.59,31.74 22.56,31.74
+3.3V_RUN on TOP (solid shape): 184.85,102.93 184.85,101.91 182.39,99.45 182.37,99.45 182.28,99.36 177.78,99.36 177.78,99.86 177.13,99.86 177.13,99.36 176.58,99.36 176.58,99.86 175.93,99.86 175.93,99.36 175.34,99.36 175.32,99.42 175.3,99.47 175.27,99.51 175.24,99.55 175.19,99.58 175.15,99.61 175.1,99.63 175.05,99.64 175,99.64 174.95,99.63 174.89,99.62 174.82,99.69 174.82,100.98 180.71,100.98 180.71,100.93 180.72,100.88 180.74,100.83 180.76,100.79 180.79,100.74 180.83,100.71 180.87,100.68 180.92,100.65 180.97,100.64 181.02,100.63 181.07,100.63 181.12,100.64 181.17,100.65 181.22,100.68 181.26,100.71 181.3,100.74 181.33,100.79 181.35,100.83 181.37,100.88 181.38,100.93 181.38,100.98 181.37,101.04 181.35,101.09 181.33,101.13 181.3,101.17 181.26,101.21 181.22,101.24 181.17,101.27 181.12,101.28 181.07,101.29 181.02,101.29 180.97,101.28 180.92,101.27 180.87,101.24 180.83,101.21 180.79,101.17 180.76,101.13 180.74,101.09 180.72,101.04 180.71,100.98 174.82,100.98 174.82,101.47 176.97,103.61 184.17,103.61
+3.3V_RUN on TOP (solid shape): outline of 85 points within 245.68,33.15 247.82,37.42
+3.3V_RUN on BOTTOM (solid shape): 55.07,33.57 55.07,31.59 54.94,31.47 53.88,31.47 53.71,31.64 53.71,33.55 53.86,33.71 54.93,33.71
+3.3V_RUN on BOTTOM (solid shape): 170.37,73.09 170.37,72.44 170.19,72.26 170.19,71.69 170.11,71.61 169.1,71.61 168.98,71.73 168.98,73.14 169.11,73.27 170.19,73.27
+3.3V_RUN on BOTTOM (solid shape): 296.61,79.15 296.61,77.7 296.35,77.44 295.04,77.44 294.9,77.58 294.9,77.58 294.86,77.63 294.86,79.05 295.11,79.3 296.46,79.3
+3.3V_RUN on BOTTOM (solid shape): 265.18,33.15 265.18,33.04 265.18,32.05 265.18,32 265.18,30.83 265.19,30.82 265.19,30.56 265.67,30.08 265.67,29.31 265.55,29.19 265,29.19 264.47,29.71 264.47,30.53 264.51,30.59 264.53,30.66 264.53,30.68 264.68,30.84 264.68,31.41 264.78,31.5 264.78,33.18 264.83,33.23 265.1,33.23
+3.3V_RUN on BOTTOM (solid shape): outline of 119 points within 123.88,36.38 127.64,44.03
+3.3V_RUN on BOTTOM (solid shape): outline of 419 points within 178.89,59.37 193.39,69.46
+3.3V_RUN on IN1 (solid shape): 169.2,87.72 169.28,87.68 169.3,87.59 169.61,87.17 169.93,87.59 169.95,87.68 170.03,87.72 170.67,87.72 170.82,87.56 170.82,86.91 170.39,86.91 169.6,86.11 166.88,86.11 166.88,87.49 167.11,87.72
+3.3V_RUN on IN2 (solid shape): 200.72,35.44 200.72,34.21 200.67,34.16 199.46,34.16 199.27,34.35 199.27,35.49 199.4,35.62 200.54,35.62
+3.3V_RUN on IN4 (solid shape): 183.33,51.24 183.33,50.1 183.08,49.84 181.55,49.84 181.49,49.9 181.49,51.13 181.79,51.43 183.14,51.43
+3.3V_RUN on IN4 (solid shape): outline of 83 points within 198.59,34.47 201.56,37.96
+3.3V_RUN on IN4 (solid shape): outline of 162 points within 169.68,58.29 181.15,60.51
+3.3V_RUN on IN1: 20.28,29.2 20.05,29.43 20.05,33.71 20.24,33.9 22.72,33.9 23.2,34.38 23.2,35.49 23.71,36 26.39,36 26.82,35.56 26.82,32.99 26.35,32.52 26.35,31.27 25.05,29.97 22.36,29.97 21.59,29.2
+3.3V_RUN on IN2: 54.17,35.8 55.24,34.73 55.24,31.85 54.83,31.44 48.24,31.44 45.22,34.46 40.22,34.46 39.98,34.22 30.04,34.22 29.41,33.59 23.96,33.59 23.73,33.81 23.73,35.66 23.87,35.8 28.9,35.8 28.9,35.81 29.28,36.19 31.24,36.19 31.63,35.8
+3.3V_RUN on IN2: 181.78,63.37 179.58,63.37 179.17,63.78 177.96,63.78 176.08,65.66 174.56,65.66 173.36,66.86 170.31,66.86 170.12,66.67 169.17,66.67 168.49,67.35 168.49,72.88 168.78,73.17 170.39,73.17 170.4,73.19 173.92,73.19 174.63,72.48 174.63,72 175.99,70.64 175.99,70.22 175.52,69.75 175.52,67.89 176.09,67.33 179.31,67.33 180.73,65.91 180.73,64.78 181.87,63.63 181.87,63.46
+3.3V_RUN on IN2: 172.08,59.3 173.15,58.23 173.15,56.97 173.36,56.76 173.36,52.89 174.82,51.43 182.63,51.43 182.89,51.17 182.89,50.41 182.51,50.03 173.23,50.03 169.87,53.4 169.87,56.34 170.67,57.14 170.67,58.05 170.22,58.49 170.22,58.86 170.67,59.3
+3.3V_RUN on IN3: 169.33,72.03 169.03,72.34 169.03,74.42 169.68,75.07 170.23,74.75 169.91,75.31 171.74,77.14 174.15,77.14 174.69,76.6 174.69,75.56 174.5,75.37 174,75.37 173.87,75.5 173.81,75.5 173.62,75.69 173.51,75.69 171.44,73.62 171.44,72.5 170.98,72.03
+3.3V_RUN on VCC: outline of 146 points within 17.53,33.78 316.48,113.65
+3.3V_RUN on IN4: 29.28,92.36 28.71,91.79 27.61,91.79 27.54,91.83 27.51,91.9 27.51,91.95 27.54,92.02 27.6,92.06 27.78,92.64 27.23,92.37 27.21,92.3 27.14,92.27 26.92,92.15 26.86,91.9 26.83,91.83 26.75,91.79 24.58,91.79 23.15,90.36 20.7,90.36 20.34,90.71 20.34,92.21 18.8,93.75 18.8,94.67 19.44,95.31 33.41,95.31 34.04,94.67 34.04,92.86 33.55,92.36
+3.3V_RUN on IN4: 174.5,87.81 174.5,87.75 179.65,82.61 179.65,81.08 180.41,80.32 180.41,75.94 178.99,74.52 172.46,74.52 170.98,76 170.98,77.82 171.96,78.8 171.96,80.77 172.66,81.46 173.74,81.46 174.06,81.15 174.06,80.38 174.85,79.59 176.38,79.59 176.73,79.94 176.73,82.67 173.36,86.04 167.77,86.04 167.77,86.04 167.09,86.04 166.94,86.2 166.94,86.7 167.02,86.78 171.65,86.78 171.84,86.97 171.84,87.75 171.52,88.07 170.82,88.07 170.63,87.88 170.63,87.43 170.44,87.24 170.12,87.24 169.93,87.43 169.93,88.39 170.25,88.7 172.03,88.7 172.35,88.39 173.93,88.39
+3.3V_RUN_AUDIO on TOP (solid shape): 301.45,52.31 301.45,49.46 301.14,49.15 299.72,49.15 299.5,49.36 299.5,49.95 299.51,51.66 299.51,51.67 299.51,52.24 299.5,52.25 299.5,53.21 299.58,53.28 300.48,53.28
+3.3V_RUN_AUDIO on IN2 (solid shape): 301.06,49.78 301.06,49.27 300.93,49.14 298.96,49.14 298.84,49.27 298.84,49.84 298.96,49.97 300.87,49.97
+3.3V_RUN_AUDIO_DVDD on TOP (solid shape): 276.17,42.62 276.17,42.32 276.33,42.16 277.56,42.16 277.66,42.06 277.68,42.03 277.69,42.03 277.76,41.97 278.64,41.97 278.71,41.9 278.71,41.78 278.63,41.7 276.68,41.7 276.63,41.65 275.3,41.65 275.23,41.73 275.23,42.56 275.35,42.69 276.09,42.69
+3.3V_RUN_AUDIO_UZ5 on TOP (solid shape): 299.35,53.21 299.35,52.78 298.84,52.78 298.84,52.39 299.35,52.39 299.35,51.62 299.15,51.43 296.32,51.43 295.94,51.81 295.36,51.81 295.29,51.88 295.29,52.73 295.76,53.2 295.76,53.52 295.76,53.58 295.83,53.65 296.65,53.65 296.81,53.8 298.75,53.8
+3.3V_RUN_CARD on TOP (solid shape): 292.29,64.88 292.29,63.76 292.3,63.74 292.3,63.61 292.56,63.35 292.56,62.59 292.45,62.49 292.21,62.49 292.08,62.62 292.08,64.87 292.14,64.93 292.24,64.93
+3.3V_RUN_CARD on TOP (solid shape): 300.17,59.43 300.17,58.99 300.49,58.67 303.41,58.67 303.6,58.48 303.6,58.16 303.47,58.03 300.04,58.03 299.92,57.91 298.59,57.91 298.48,58.01 298.48,59.71 298.9,60.13 299.47,60.13
+3.3V_RUN_CARD on IN3 (solid shape): 300.04,61.33 300.04,59.3 299.6,58.86 298.96,58.86 298.71,59.11 298.71,60.26 299.03,60.57 299.03,60.89 298.77,61.14 298.77,61.21 299.28,61.72 299.66,61.72
+3.3V_RUN_CARD on IN3 (solid shape): 292.58,63.53 292.58,62.44 293.18,61.84 293.18,61.74 293.04,61.6 292.12,61.6 291.87,61.86 291.87,62.81 292.05,62.99 292.05,63.46 292.2,63.62 292.5,63.62
+3.3V_RUN_DIMM1 on TOP (solid shape): 121.83,43.58 121.83,42.58 121.87,42.54 122.21,42.54 122.42,42.33 122.42,41.6 122.6,41.42 122.6,41.03 122.79,40.84 122.94,40.84 123.15,40.63 123.15,40.22 123.04,40.11 122.6,40.11 120.96,41.75 120.96,41.95 121.03,42.02 121.03,43.62 121.1,43.69 121.72,43.69
+3.3V_RUN_DIMM2 on TOP (solid shape): 200.67,40.8 200.67,40.58 200.35,40.27 200.35,37.76 200.31,37.72 199.37,37.72 199.33,37.74 199.32,37.78 199.32,38.44 199.41,38.52 199.41,40.66 199.56,40.81 200.08,40.81 200.18,40.91 200.55,40.91
+3.3V_RUN_R on TOP (solid shape): 106.98,111.86 106.98,111.11 106.42,110.54 105.1,110.54 105.03,110.62 105.03,111.17 105.11,111.26 106.01,111.26 106.21,111.46 106.21,111.87 106.29,111.95 106.9,111.95
+3.3V_RUN_UZ3 on TOP (solid shape): outline of 110 points within 175.1,95.01 181.32,99.21
+3.3V_SPI on IN2: 144.08,77.48 151.82,77.48 154.98,74.32 163.82,74.32 164.43,74.93 164.43,75.42 165.83,76.82 167.92,76.82 168.42,76.33 173.17,76.33 173.57,75.93 173.57,75.18 173.21,74.82 166.06,74.82 165,73.77 161.87,73.77 161.26,73.16 154.3,73.16 151.9,75.57 150.35,75.57 150.26,75.66 150.26,75.66 150.09,75.83 143.98,75.83 143.63,76.18 143.63,77.04
+3.3V_SSD on TOP (solid shape): 25.06,32.97 25.06,32.4 25.18,32.27 25.91,32.27 26.04,32.14 26.04,30.55 25.89,30.4 23.06,30.4 22.87,30.59 22.87,32.92 22.99,33.04 24.98,33.04
+3.3V_TBT on TOP (solid shape): outline of 111 points within 18.38,81.53 23.68,91.66
+3.3V_TBT on TOP (solid shape): outline of 246 points within 31.01,79.22 36.8,87.65
+3.3V_TBT on BOTTOM (solid shape): 21.4,82.75 21.4,82.44 21.41,82.43 21.41,82.39 21.57,82.23 21.77,82.23 21.91,82.1 21.91,81.99 22.08,81.81 22.16,81.81 22.31,81.66 22.31,81.56 22.22,81.48 22.07,81.48 22.03,81.52 21.3,81.52 20.85,81.52 20.7,81.67 20.7,81.68 20.64,81.77 20.54,81.8 20.47,81.8 20.37,81.9 19.68,81.9 19.12,82.46 17.83,82.46 17.7,82.59 17.7,83.17 17.83,83.3 20.85,83.3
+3.3V_TBT on IN3 (solid shape): 32.35,87.67 32.35,87.19 32.19,87.04 32.09,86.97 32.03,86.87 31.8,86.65 30.27,86.65 30.11,86.81 30.11,87.64 30.31,87.84 32.18,87.84
+3.3V_TBT on IN3: 24.01,81.22 24.86,80.37 24.86,78.29 24.68,78.11 22.7,78.11 21.76,79.05 21.76,79.88 19.66,81.98 19.66,83.05 19.99,83.38 22.12,83.38 22.17,83.43 22.84,83.43 23.15,83.12 23.15,83.03 24.01,82.18
+3.3V_TBT_FLASH_R on TOP (solid shape): 32.13,93.37 32.2,93.11 32.44,93 32.44,92.92 32.44,92.92 32.44,90.38 32.42,90.36 32.44,90.34 32.44,88.64 32.21,88.41 31.69,88.41 31.46,88.64 31.16,88.64 31.02,88.78 31.02,89.42 31.46,89.85 31.46,90.78 31.46,90.79 31.46,92.32 31.44,92.32 30.8,92.96 30.11,92.96 29.8,92.66 29.8,92.15 29.66,92.01 28.78,92.01 28.65,92.13 28.65,93.62 28.82,93.78 31.71,93.78
+3.3V_TBT_LC on TOP (solid shape): 31.3,92.13 31.3,89.84 30.92,89.46 30.92,89.45 30.64,89.17 30.64,88.57 30.21,88.14 29.76,88.14 29.63,88.28 29.63,88.97 30.65,90 30.65,91.69 30.34,92.01 30.04,92.01 29.94,92.11 29.94,92.6 30.09,92.76 30.68,92.76
+3.3V_TBT_LC on TOP (solid shape): outline of 95 points within 27.37,80.44 32.26,86.46
+3.3V_TBT_S0 on TOP (solid shape): outline of 151 points within 34.3,75.39 37.98,78.8
+3.3V_TBT_S0 on IN3: 28.21,77.03 28.21,76.21 28.64,75.77 36.48,75.77 36.65,75.95 36.73,75.95 36.73,77.85 35.92,78.66 31.94,78.66 30.66,77.38 28.62,77.38 28.56,77.38
+3.3V_TBT_SX on TOP (solid shape): 24.79,92.11 26.2,92.11 26.41,91.89 26.41,90.5 26.15,90.24 24.11,90.24 23.88,90.47 23.88,91.4 23.36,91.92 23.36,92.33 23.41,92.37 24.52,92.37
+3.3V_TBT_SX on IN4 (solid shape): outline of 1321 points within 21.88,78.93 35.37,90.99
+3.3V_TBTA_FLASH on TOP (solid shape): 28.49,94.69 28.49,93.56 28.19,93.26 27.18,93.26 26.87,93.57 26.87,93.9 26.96,93.99 26.96,94.95 27.08,95.07 28.11,95.07
+3.3V_TBTA_FLASH on IN1 (solid shape): 28.06,93.82 28.06,93.28 27.89,93.12 26.48,93.12 26.22,93.39 26.22,93.88 26.26,93.91 27.97,93.91
+3.3V_TBTA_FLASH on IN2 (solid shape): outline of 250 points within 26.87,46.35 32.96,53.27
+3.3V_TP on TOP (solid shape): 252.67,33.65 252.67,32.19 252.36,31.87 252.32,31.87 252.31,31.87 252.2,31.89 252.08,31.87 252.08,31.87 251.73,31.87 251.64,31.88 251.55,31.87 251.17,31.87 251.08,31.88 250.99,31.87 250.83,31.87 250.5,31.54 250.5,30.45 250.36,30.31 249.78,30.31 249.69,30.4 249.69,31 249.81,31.21 249.75,31.45 249.75,31.77 249.97,31.98 250.34,31.98 250.47,32.11 250.47,32.72 250.39,32.79 248.32,32.79 248.09,33.03 248.09,35.03 248.34,35.28 251.04,35.28
+3.3V_VDD_DCIN on BOTTOM (solid shape): 67.43,94.84 67.43,94.25 67.97,93.71 67.97,93.04 67.59,92.66 66.07,92.66 65.84,92.9 65.84,93.79 66.44,94.39 66.44,94.94 66.49,94.99 67.28,94.99
