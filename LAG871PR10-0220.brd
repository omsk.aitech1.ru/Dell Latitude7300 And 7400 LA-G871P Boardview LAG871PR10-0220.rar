# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_RTCX1: length 23.7
  TOP w0.127: v1(144.43,59.82) 144.74,59.82 145.13,59.42 147.72,59.42 v2(147.75,59.39) 148.06,59.39 148.91,58.53 RC66.2 151.07,58.53 CC23.1 151.87,57.92 151.95,57.84 152.79,57.84 YC2.1
  IN4 w0.089: v1(144.43,59.82) 144.22,59.82 143.17,60.86 143.17,65.95 142.66,66.46 142.66,67.45 142.41,67.7 142.41,68.51 140.84,70.08 140.84,71.58 v1(141.2,71.95)
  BOTTOM w0.089: UC1.BN31 v1(141.2,71.95)
PCH_RTCX2: length 20.6
  TOP w0.127: RC532.1 151.34,59.44 RC66.1 v2(149.17,59.44) 149,59.44 148.39,60.06 145.47,60.06 145.07,60.45 v1(144.43,60.45)
  IN4 w0.089: v1(144.43,60.45) 144.35,60.37 143.92,60.37 143.35,60.94 143.35,66.02 142.84,66.53 142.84,67.52 142.59,67.78 142.59,68.58 141.01,70.15 141.01,71.13 v1(141.2,71.31)
  BOTTOM w0.089: UC1.BN32 v1(141.2,71.31)
PCH_RTCX2_R: length 4.8
  TOP w0.127: YC2.2 155.49,57.89 155.49,59.13 155.21,59.42 v2(154.5,59.42) CC26.1 152.28,59.42 RC532.2
PCH_SPI_CLK: length 49
  IN4 w0.084: v1(173.36,70.54) 173.85,70.54 173.97,70.67 177.13,70.67 177.77,70.03 v1(178.57,70.03)
  BOTTOM w0.076: 154.65,65.03 154.33,65.35 152.17,65.35 149.78,67.74 149.78,68.41 UC1.CH37
  BOTTOM w0.127: 154.65,65.03 159,65.03 159.41,64.62 159.66,64.62 159.79,64.75 159.79,65.59 159.92,65.72 160.17,65.72 160.3,65.59 160.3,64.75 160.43,64.62 170.47,64.62 172.71,66.86 172.89,66.86 173.13,66.62 173.31,66.62 173.49,66.8 173.49,66.98 173.25,67.22 173.25,67.4 173.74,67.89 173.74,70.16 v1(173.36,70.54) 172.92,70.99 172.92,71.75 172.22,72.45 171.01,72.45 170.75,72.2 RC96.1 ; v1(178.57,70.03) 179.58,70.03 181.1,71.55 JSPI1.8 181.1,74 181.07,74.03 RC27.1
PCH_SPI_CLK_0_R: length 15.5
  TOP w0.127: RC571.2 184.85,72.83 186.06,72.83 186.77,72.12 v3(186.77,67.56) 186.77,63.39 186.94,63.23 RC299.1 189.51,62.51 UC5.6
PCH_SPI_CLK_1_R: length 21.1
  IN1 w0.084: v1(192.39,73.58) 192.83,73.13 192.83,73.01 192.33,72.52 192.33,72.4 192.45,72.28 192.57,72.28 193.07,72.78 193.19,72.78 193.31,72.66 193.31,72.54 192.81,72.04 192.81,71.92 192.93,71.8 193.05,71.8 193.54,72.3 193.66,72.3 193.96,72 193.96,69.97 v1(194.55,69.39)
  BOTTOM w0.127: RC575.2 184.87,76 184.93,75.94 189.68,75.94 192.04,73.58 v1(192.39,73.58) 193.52,73.58 RC289.1 ; UC6.6 v1(194.55,69.39)
PCH_SPI_CLK_2_R: length 5
  TOP w0.127: RZ60.2 183.3,75.7 v2(183.05,75.95) 182.38,76.62 v1(182.38,77.4) 182.41,77.43 UZ12.19
  BOTTOM w0.127: RZ63.2 181.6,78 182.2,77.4 v1(182.38,77.4)
PCH_SPI_CLK_R1: length 8.5
  TOP w0.127: RZ60.1 184.03,73.81 RC571.1 182.99,73.73 v2(182.84,73.89) v1(182.12,74.6)
  BOTTOM w0.127: JSPI1.7 181.6,74.17 RC27.2 182.03,74.6 v1(182.12,74.6) 183.53,76 RC575.1
PCH_SPI_CS#0: length 43.7
  TOP w0.127: v1(175.8,69.69) v2(176.49,69.69)
  IN4 w0.084: v1(174.25,68.64) 174.62,68.64 175.67,69.69 v1(175.8,69.69)
  BOTTOM w0.076: UC1.CG36 149.25,67.59 153.47,63.37 154.65,63.37
  BOTTOM w0.127: v1(174.25,68.64) 174.25,65.51 172.1,63.37 171.37,63.37 171.1,63.1 158.54,63.1 158.27,63.37 154.65,63.37 ; RC28.1 179.93,73.78 180.1,73.6 JSPI1.10 180.1,71.38 179.27,70.54 178.52,70.54 177.67,69.69 v1(175.8,69.69)
PCH_SPI_CS#0_R1: length 5.7
  TOP w0.127: v1(180.55,75.56) 180.68,75.69 RC32.1 181.32,76.59 v2(181.57,76.83)
  BOTTOM w0.127: v1(180.55,75.56) 180.51,75.52 RC28.2 180.51,73.78 180.6,73.69 JSPI1.9
PCH_SPI_CS#0_R2: length 28
  TOP w0.127: RC32.2 181.91,75.31 v1(181.78,75.18) ; v1(188.92,72.19) 188.92,71.49 189.68,70.73 189.68,70.59 189.68,67.26 191.03,65.91 v3(194.85,65.91) 195.21,65.91 196.34,64.77 196.34,64 196.98,63.35 196.98,60.57 197.58,59.97 UC5.1
  IN4 w0.084: v1(188.92,72.19) 186.82,72.19 186.23,72.79 184.07,72.79 183.27,73.59 183.27,73.98 182.07,75.18 v1(181.78,75.18)
PCH_SPI_CS#1: length 53
  TOP w0.127: v2(174.5,65.35) 173.97,65.88 v1(173.5,65.88)
  IN4 w0.084: v1(173.5,65.88) 174.21,66.58 176.26,66.58 176.73,67.06 181.54,67.06 182.09,66.51 v1(182.09,65.14)
  BOTTOM w0.076: 154.65,63.87 153.19,63.87 149.43,67.64 149.43,68.52 149.51,68.77 149.51,68.95 149.47,69.07 149.47,69.29 UC1.CG35
  BOTTOM w0.127: 154.65,63.87 158.48,63.87 158.75,63.6 170.89,63.6 173.16,65.88 v1(173.5,65.88) ; v1(182.09,65.14) 182.09,67.53 186.32,71.75 186.32,72.68 185.94,73.06 RC24.1 184.56,73.06 184.1,72.6 JSPI1.2
PCH_SPI_CS#1_R1: length 10.7
  IN1 w0.084: v1(180.4,76.1) 180.58,76.1 181.4,75.27 181.4,74.79 182.23,73.97 182.7,73.97 184.72,71.95 v1(185.81,71.95)
  BOTTOM w0.127: JSPI1.1 184.6,72.39 184.77,72.55 185.73,72.55 RC24.2 v1(185.81,71.95) ; v1(180.4,76.1) 180.67,76.1 181.08,75.69 RC302.1
PCH_SPI_CS#1_R2: length 19
  TOP w0.127: v1(188.22,73.59) v2(188.79,73.59)
  IN4 w0.084: v1(180.92,76.57) 181.16,76.82 182.48,76.82 184.3,75 186.6,75 188,73.59 v1(188.22,73.59)
  BOTTOM w0.127: v1(180.92,76.57) 181.11,76.38 181.35,76.38 181.91,75.82 RC302.2 ; v1(188.22,73.59) 188.22,71.46 187.87,71.11 187.87,67.29 188.32,66.85 UC6.1
PCH_SPI_CS#2: length 56
  TOP w0.127: v1(187.2,64.11) 187.46,64.37 v2(187.46,70.07) 187.46,72.24 RZ61.1
  IN4 w0.084: v1(172.66,66.18) 173.53,67.05 176.07,67.05 176.54,67.52 181.74,67.52 185.15,64.11 v1(187.2,64.11)
  BOTTOM w0.076: UC1.CH34 149.64,70.22 149.64,69.09 149.68,68.98 149.68,68.74 149.6,68.53 149.6,67.69 152.77,64.52 154.65,64.52
  BOTTOM w0.127: 154.65,64.52 158.55,64.52 158.96,64.11 170.68,64.11 172.66,66.09 v1(172.66,66.18)
PCH_SPI_CS#2_R: length 5.4
  TOP w0.127: RZ61.2 185.43,75.81 v2(185.17,76.07) 184.92,76.32 183.39,76.32 182.91,76.81 UZ12.20
PCH_SPI_D0: length 65.1
  TOP w0.127: v1(170.17,68.57) 170.17,68.42 v2(169.68,67.93)
  IN4 w0.084: v1(181.17,69.59) 180.85,69.27 179.96,69.27 179.66,69.57 177.58,69.57 176.98,70.16 175.48,70.16 174.42,69.1 170.71,69.1 v1(170.17,68.57)
  BOTTOM w0.076: 154.65,61.22 154.64,61.22 154.6,61.18 154.44,61.18 153.87,61.76 153.87,62.05 148.55,67.38 148.55,68.17 148.33,68.38 148.33,68.65 148.6,69.13 UC1.CF36
  BOTTOM w0.127: v1(170.17,68.57) RC94.2 RC505.2 RC518.1 ; RC25.1 184.16,74.1 183.1,73.05 JSPI1.4 183.1,71.11 182.34,70.35 181.94,70.35 v1(181.17,69.59) 180.41,68.83 180.41,67.79 179.86,67.24 177.55,67.24 176.93,66.62 176.93,64.59 175.35,63.01 174.62,63.01 172.37,60.76 168.56,60.76 167.79,60 158.63,60 157.41,61.22 154.65,61.22
PCH_SPI_D0_0_R: length 10.4
  TOP w0.127: RC570.2 188.28,71.37 189.17,70.48 v3(189.17,70.35) 189.17,67.05 191.08,65.14 191.08,63.91 190.95,63.78 UC5.5
PCH_SPI_D0_1_R: length 19.3
  BOTTOM w0.127: RC574.2 187.36,72.06 187.36,67.08 v2(187.53,66.92) 188.17,66.27 190.26,66.27 190.82,66.84 190.82,67.73 192.41,69.32 192.41,71.37 192.54,71.49 193.75,71.49 194.59,70.66 UC6.5
PCH_SPI_D0_2_R: length 4.1
  TOP w0.127: RZ59.2 v2(184.14,76.91) 183.54,76.91 183.41,77.03 UZ12.21
PCH_SPI_D0_R1: length 10.7
  TOP w0.127: RZ59.1 186.12,74.3 186.53,73.9 v1(186.78,73.9) 186.78,73.65 v2(187.17,73.27) 187.57,72.87 RC570.1
  BOTTOM w0.127: RC574.1 187.45,72.93 186.78,73.59 v1(186.78,73.9) 185.52,73.9 185.31,74.1 RC25.2 184.96,73.96 184.58,73.59 184.37,73.59 183.6,72.82 JSPI1.3
PCH_SPI_D1: length 51
  BOTTOM w0.076: 154.65,61.78 154.37,61.78 148.72,67.43 148.72,68.41 UC1.CF37
  BOTTOM w0.127: 154.65,61.78 154.71,61.72 157.76,61.72 158.98,60.51 166.44,60.51 167.09,61.16 168.17,61.16 168.59,61.57 172.46,61.57 174.41,63.52 175.14,63.52 176.35,64.72 176.35,65.34 176.08,65.6 176.08,67.05 176.93,67.9 176.93,68.7 177.31,69.08 179.75,69.08 182.1,71.43 JSPI1.6 182.1,73.7 v2(183.17,74.77) 183.77,75.37 185.78,75.37 RC26.1
PCH_SPI_D1_0_R: length 24.1
  TOP w0.127: RC734.2 189.27,74.63 191.08,72.83 191.08,67.3 191.46,66.92 v3(197.48,66.92) 198.89,66.92 200.36,65.45 200.36,62.3 199.3,61.24 UC5.2
PCH_SPI_D1_1_R: length 10
  BOTTOM w0.127: UC6.2 190.49,68.12 191.9,69.53 191.9,72.19 v2(190.02,74.07) 189.24,74.86 RC573.2
PCH_SPI_D1_2_R: length 3.4
  TOP w0.127: UZ12.24 184.91,77.98 185.05,77.84 v2(186.87,77.84) 187.14,77.58 RZ58.2
PCH_SPI_D1_R1: length 11.8
  TOP w0.127: RZ58.1 186.63,75.48 v1(186.63,74.44) 187.26,74.44 187.54,74.72 v2(187.65,74.72) 188.54,74.72 RC734.1
  BOTTOM w0.127: JSPI1.5 182.6,73.37 184.09,74.86 185.3,74.86 185.53,74.63 RC26.2 186.13,74.44 v1(186.63,74.44) 187.63,74.44 RC573.1
PCH_SPI_D2: length 58.8
  TOP w0.127: v1(168.35,68.57) v2(168.35,67.98)
  IN4 w0.084: v1(174.99,70.2) 174.82,70.2 174.19,69.57 169.89,69.57 169.67,69.79 168.43,69.79 168.35,69.71 v1(168.35,68.57)
  BOTTOM w0.076: UC1.CF34 148.86,70.22 148.86,69.74 148.82,69.63 148.82,69.39 148.86,69.28 148.86,69.09 148.82,68.98 148.82,68.74 148.9,68.53 148.9,67.48 154.09,62.29 154.65,62.29
  BOTTOM w0.127: RC61.2 168.35,67.92 v1(168.35,68.57) 168.35,69.79 168.4,69.85 RC519.1 RC11.2 ; RC29.1 178.66,73.78 179.1,73.33 JSPI1.12 179.1,71.2 178.95,71.05 178.31,71.05 177.46,70.2 v1(174.99,70.2) 174.76,69.97 174.76,69.53 175.57,68.71 175.57,65.4 172.25,62.08 168.38,62.08 167.97,61.68 166.89,61.68 166.57,61.36 165.14,61.36 164.42,62.08 158.12,62.08 157.91,62.29 154.65,62.29
PCH_SPI_D2_0_R: length 31.8
  TOP w0.127: RC33.2 180.96,75.05 v1(181.03,75.12) ; v1(187.33,73.73) 187.7,74.1 189.09,74.1 190.57,72.62 190.57,67.09 191.25,66.41 195.42,66.41 196.75,65.08 199.27,65.08 199.85,64.5 v2(199.85,63.91) 199.85,63 199.37,62.51 UC5.3
  IN4 w0.084: v1(187.33,73.73) 186.85,73.25 184.65,73.25 182.27,75.64 181.12,75.64 181.03,75.56 v1(181.03,75.12)
PCH_SPI_D2_1_R: length 20.7
  TOP w0.127: v2(189.67,72.05) 188.98,72.74 v1(188.98,72.75)
  IN4 w0.084: v1(180.03,76.57) 181.42,77.97 182.68,77.97 182.98,77.67 182.98,76.97 184.49,75.46 186.87,75.46 188.98,73.35 v1(188.98,72.75)
  BOTTOM w0.127: v1(188.98,72.75) 189.03,72.7 190.38,72.7 191.4,71.69 191.4,70.03 190.75,69.39 UC6.3 ; RC35.2 179.88,76.42 v1(180.03,76.57)
PCH_SPI_D2_R1: length 6.7
  TOP w0.127: v1(179.37,75.05) RC33.1 179.93,74.76 180.14,74.54 v2(181.36,74.54)
  BOTTOM w0.127: JSPI1.11 179.6,73.42 179.24,73.78 RC29.2 179.37,74.3 v1(179.37,75.05) 179.37,75.98 RC35.1
PCH_SPI_D3: length 51.3
  TOP w0.127: v1(170.06,70.51) v2(170.46,70.91)
  IN4 w0.084: v1(170.06,70.51) 170.98,70.51 171.46,70.03 174,70.03 v1(174.25,70.29)
  BOTTOM w0.076: 154.65,62.8 153.81,62.8 149.07,67.53 149.07,68.52 148.98,68.77 148.98,68.95 149.03,69.07 149.03,69.3 148.98,69.42 148.98,69.6 149.03,69.72 149.03,69.94 UC1.CG34
  BOTTOM w0.127: v1(170.06,70.51) 170.23,70.51 170.51,70.79 RC515.1 RC62.2 ; 154.65,62.8 158.12,62.8 158.33,62.59 166.11,62.59 166.51,62.19 167.75,62.19 168.15,62.59 171.31,62.59 171.52,62.8 172.25,62.8 174.76,65.3 174.76,68.81 174.25,69.32 v1(174.25,70.29) 174.25,70.58 174.38,70.71 177.25,70.71 178.1,71.56 JSPI1.14 178.1,72.85 177.39,73.57 RC30.1
PCH_SPI_D3_0_R: length 19.2
  TOP w0.127: UC5.7 189.46,61.24 187.98,62.72 186.58,62.72 186.19,63.11 v2(186.19,65.06) 186.19,69.73 182.32,73.6 180.63,73.6 RC572.2
PCH_SPI_D3_1_R: length 24.7
  BOTTOM w0.127: RC576.2 179.51,76.97 181.43,76.97 181.51,76.89 182.89,76.89 183.27,76.51 v2(186.34,76.51) 189.87,76.51 191.97,74.42 193.45,74.42 196.17,71.7 197.15,71.7 197.76,71.09 197.76,68.33 197.54,68.12 UC6.7
PCH_SPI_D3_R1: length 7.9
  TOP w0.127: RC572.1 179.14,73.97 v2(178.78,74.33) v1(178.78,75.74)
  BOTTOM w0.127: RC576.1 v1(178.78,75.74) 177.97,74.93 RC30.2 177.97,73.75 178.6,73.12 JSPI1.13
PCH_SPI_DO2_XDP: length 309.1
  TOP w0.127: v2(42.25,46.3) 42.84,46.89 v1(42.84,47.01)
  IN1 w0.084: v1(42.84,47.01) 42.84,46.67 42.2,46.03 42.2,41.75 42.49,41.46 42.49,36.82 43.91,35.4 43.91,32.63 44.49,32.05 44.49,30.61 45.32,29.79 48.36,29.79 48.9,29.25 56.74,29.25 58.13,30.64 69.33,30.64 70.09,29.88 70.09,28.59 70.51,28.17 70.51,26.39 71.22,25.68 74.62,25.68 75.57,24.73 82.14,24.73 82.64,24.23 115.98,24.23 118.73,26.98 123.96,26.98 124.79,26.15 145.96,26.15 148.76,28.95 160.4,28.95 161.5,27.85 161.91,27.85 162.6,27.16 165.17,27.16 165.85,27.85 172.12,27.85 172.13,27.86 172.5,28.23 176.56,28.23 180.56,24.23 185.96,24.23 190.5,28.77 191.29,28.77 192.8,30.29 200.62,30.29 202.39,32.06 202.39,32.75 201.54,33.61 201.54,35.67 201.84,35.97 201.84,39.59 202.05,39.8 202.05,40.89 197.57,45.37 196.15,45.37 193.93,47.59 191,47.59 181.7,56.89 179.33,56.89 178.29,57.93 178.29,58.52 176.88,59.93 176.88,61.13 175.84,62.17 175.84,62.44 174.12,64.15 174.12,66.44 171.08,69.49 171.08,70.1 v1(170.01,71.17)
  IN4 w0.084: v1(42.84,47.01) 42.55,47.3 42.55,48 41.31,49.24 41.31,53.58 41.41,53.68 41.41,59.33 41.69,59.61 41.69,60.58 41.24,61.03 41.24,70.1 41.22,70.13 41.22,73.53 43.63,75.94 44.22,75.94 45.98,77.7 45.98,78.53 50.6,83.15 50.6,86.8 52.25,88.45 52.25,91.77 53.98,93.5 53.98,97.91 54.62,98.54 v1(54.86,98.54)
  BOTTOM w0.127: RC11.1 169.76,70.91 v1(170.01,71.17) ; v1(54.86,98.54) 54.86,98.78 55.07,98.99 56.05,98.99 56.18,99.12 JXDP1.60
PCH_SPI_DO_XDP: length 301.1
  TOP w0.127: v1(54.45,97.66) 54.57,97.53 55.17,97.53 55.97,98.33 55.97,98.74 55.73,98.98 RC133.1 55.78,99.14 RC128.1 ; v1(43.4,47) 43.4,46.77 v2(43.81,46.36)
  IN1 w0.084: v1(172.26,67.43) 172.26,63.3 175.46,60.11 179.14,56.43 181.5,56.43 190.81,47.12 193.73,47.12 195.95,44.91 197.38,44.91 200.78,41.51 200.78,39.17 201.07,38.88 201.07,33.41 201.93,32.56 201.93,32.25 200.42,30.75 192.61,30.75 191.09,29.24 190.31,29.24 186.85,25.77 184.41,25.77 183.33,24.7 181.14,24.7 180.02,25.83 180.02,26.74 179.88,26.87 178.97,26.87 177.15,28.69 172.3,28.69 171.92,28.31 161.69,28.31 160.59,29.41 148.57,29.41 145.77,26.61 125.15,26.61 124.21,27.55 118.64,27.55 115.79,24.7 90.38,24.7 89.37,25.71 88.73,25.71 87.72,24.7 82.83,24.7 82.3,25.23 75.74,25.23 74.81,26.16 71.4,26.16 70.98,26.58 70.98,28.4 70.55,28.82 70.55,30.07 69.53,31.1 57.78,31.1 56.39,29.71 49.41,29.71 44.54,34.59 44.54,35.42 43,36.97 43,38.35 43.38,38.73 43.38,41.89 43,42.27 43,45.31 43.4,45.72 v1(43.4,47)
  IN4 w0.084: v1(54.45,97.66) 54.45,93.3 53.09,91.95 53.09,89.73 52.74,89.38 52.74,88.27 51.07,86.6 51.07,82.96 46.44,78.33 46.44,77.51 44.41,75.48 43.93,75.48 41.68,73.23 41.68,70.32 41.71,70.3 41.71,61.22 42.15,60.77 42.15,59.42 41.87,59.14 41.87,53.49 41.77,53.39 41.77,49.44 43.02,48.19 43.02,47.66 43.4,47.28 v1(43.4,47)
  BOTTOM w0.127: RC505.1 171.98,67.43 v1(172.26,67.43)
PCH_TBT_PERST#: length 212.6
  TOP w0.127: RT493.1 22.23,44.05 22.6,43.68 25.85,43.68 26.69,44.52 30.73,44.52 31.12,44.13 v2(31.76,44.13) 32.96,44.13 38.72,38.37 45.62,38.37 47.57,40.32 47.57,41.9 49.82,44.15 v1(49.82,45.35)
  IN1 w0.102: v1(171.49,84.36) 170.69,83.56 169.52,83.56 169.39,83.43 158.53,83.43 v1(158.12,83.84)
  IN3 w0.122: v1(171.49,84.36) 171.15,84.02 166.92,84.02 166.15,83.25 164.33,83.25 162.12,81.03 162.12,77.33 161.86,77.07 161.86,75.3 161.66,75.1 161.66,73.09 160.84,72.27 160.11,72.27 159.71,71.87 159.71,70.58 159.27,70.14 154.39,70.14 150.97,66.72 150.97,62.3 150.5,61.83 150.15,61.83 146.1,57.77 144.28,57.77 141.19,60.87 141.19,62.39 140.45,63.13 139.43,63.13 139.04,62.74 139.04,59.69 133.79,54.43 90.9,54.43 86.95,50.49 73.04,50.49 72.82,50.72 72.25,50.72 70.99,49.45 61.25,49.45 60.65,48.85 58.12,48.85 57.99,48.97 v1(57.99,49.76)
  IN4 w0.084: v1(49.82,45.35) 50.45,45.35 52.2,47.1 54.06,47.1 56.1,49.14 57.91,49.14 57.99,49.22 v1(57.99,49.76)
  BOTTOM w0.076: UC1.CR14 154.04,82.93 156.79,82.93 157.22,83.36
  BOTTOM w0.102: 157.22,83.36 157.3,83.44 157.73,83.44 v1(158.12,83.84)
  BOTTOM w0.127: v1(171.49,84.36) 173.2,84.36 174.01,85.17 RC557.1 RC754.1
PCIE_PRX_C_DTX_N5: length 4.7
  BOTTOM w0.076: UT1.V22 29.38,72.71 arc(29.33,72.63) 29.31,72.55 29.31,72.16 29.46,72.01 29.46,71.78 29.62,71.62 29.62,71.6 29.63,71.59
  BOTTOM w0.104: 29.63,71.59 30.11,71.11 30.37,71.11 30.98,70.5 31.52,70.5 31.71,70.3 31.71,69.97 CT7.1
PCIE_PRX_C_DTX_N6: length 5.9
  BOTTOM w0.076: 27.93,71.72 27.92,71.74 27.9,71.74 27.8,71.84 27.8,72.01 27.93,72.14 27.93,72.5 arc(27.9,72.63) 27.83,72.74 UT1.P22
  BOTTOM w0.104: CT9.1 29.7,68.21 29.7,68.53 29.41,68.82 v4(29.41,69.44) 29.41,70.25 27.93,71.72
PCIE_PRX_C_DTX_N7: length 6.1
  BOTTOM w0.076: UT1.K22 25.99,72.74 arc(26.06,72.63) 26.09,72.5 26.09,72.14 25.95,72 25.95,71.62 25.96,71.61 25.96,71.59
  BOTTOM w0.104: 25.96,71.59 25.96,71.35 26.07,71.24 26.55,71.24 26.78,71.01 26.82,71.01 27.21,70.62 27.21,70.58 27.53,70.25 27.53,68.19 27.72,68 CT128.1
PCIE_PRX_C_DTX_N8: length 5.7
  BOTTOM w0.076: UT1.F22 23.86,72.71 arc(23.81,72.63) 23.79,72.55 23.79,72.16 23.94,72.01 23.94,71.62 23.93,71.61 23.93,71.59
  BOTTOM w0.104: CT130.1 25.41,68.2 25.41,68.57 25.3,68.68 25.28,68.68 24.92,69.05 24.92,69.06 24.13,69.85 v4(24.13,70.49) 24.13,71.02 23.93,71.23 23.93,71.59
PCIE_PRX_C_DTX_N9: length 2.3
  TOP w0.104: CR14.2 288.85,65.14 288.95,65.23 289.77,65.23 289.86,65.14 UR1.8
PCIE_PRX_C_DTX_P5: length 4.7
  BOTTOM w0.076: UT1.V23 29.54,72.51 arc(29.57,72.59) 29.65,72.62 arc(29.73,72.58) 29.77,72.49 29.77,72.14 29.63,71.99 29.63,71.85 29.74,71.74 29.76,71.74 29.77,71.72
  BOTTOM w0.104: CT6.1 31.9,70 31.9,70.38 31.58,70.7 v4(31.3,70.7) 31.05,70.7 30.45,71.3 30.19,71.3 29.77,71.72
PCIE_PRX_C_DTX_P6: length 5.9
  BOTTOM w0.076: UT1.P23 27.7,72.51 arc(27.66,72.59) 27.59,72.62 arc(27.5,72.59) 27.47,72.5 27.47,72.2 27.63,72.03 27.63,71.77 27.78,71.62 27.78,71.6 27.8,71.59
  BOTTOM w0.104: CT8.1 29.51,68.19 29.51,68.45 29.21,68.74 29.21,69.17 29.2,69.18 29.2,69.7 29.21,69.71 29.21,70.17 27.8,71.59
PCIE_PRX_C_DTX_P7: length 6.1
  BOTTOM w0.076: 25.77,71.59 25.77,71.61 25.78,71.62 25.78,72.04 25.63,72.2 25.63,72.5 arc(25.66,72.59) 25.75,72.62 arc(25.82,72.59) 25.86,72.51 UT1.K23
  BOTTOM w0.104: CT127.1 27.15,68 27.34,68.19 27.34,70.17 v4(26.83,70.68) 26.47,71.05 25.99,71.05 25.77,71.27 25.77,71.59
PCIE_PRX_C_DTX_P8: length 5.7
  BOTTOM w0.076: UT1.F23 24.02,72.51 arc(24.05,72.59) 24.13,72.62 arc(24.21,72.58) 24.25,72.49 24.25,72.14 24.11,71.99 24.11,71.62 24.12,71.61 24.12,71.59
  BOTTOM w0.104: CT129.1 25.6,68.17 25.6,68.65 v4(25.24,69.01) 24.33,69.93 24.33,70.22 24.34,70.23 24.34,70.75 24.33,70.76 24.33,71.1 24.12,71.31 24.12,71.59
PCIE_PRX_C_DTX_P9: length 2.3
  TOP w0.104: UR1.7 289.88,65.54 289.78,65.43 v4(289.22,65.43) 288.84,65.43 288.45,65.05 CR13.2
PCIE_PRX_DTX_N5: length 174.7
  IN1 w0.084: v1(145.01,86.02) 145.23,86.24 145.37,86.24 145.56,86.43 145.56,89.14 144.71,89.98 144.71,90.21 144.72,90.22 144.72,90.24
  IN1 w0.094: v1(31.54,68.64) 31.54,70.2 33.44,72.1 33.44,76.67 33.88,77.11 33.88,79.15 33.8,79.23 33.8,83.7 35.06,84.96 35.06,85.53 35.77,86.25 35.77,89.93 36.49,90.65 36.49,92.57 37.14,93.22 37.14,95.72 37.67,96.24 37.67,97.33 38.37,98.02 38.37,99 40.58,101.21 42.21,101.21 45.24,104.23 46.33,104.23 47.08,104.98 48.58,104.98 52.14,108.54 52.14,108.96 54.16,110.98 77.36,110.98 78.78,109.57 87,109.57 88.59,111.16 88.59,111.31 88.84,111.57 102.11,111.57 102.21,111.47 105.65,111.47 106.3,110.82 110.4,110.82 111.14,111.57 136.72,111.57 136.93,111.36 138.03,111.36 138.58,110.81 142.5,110.81 147.2,106.1 147.2,97.78 145.23,95.81 145.23,94.23 144.72,93.72 144.72,90.24
  BOTTOM w0.076: UC1.BW9 v1(145.01,86.02)
  BOTTOM w0.104: CT7.2 31.72,69.02 31.72,68.82 v1(31.54,68.64)
PCIE_PRX_DTX_N6: length 166.6
  IN1 w0.084: 143.96,90.24 143.96,90.22 143.96,90.22 143.96,90.17 143.97,90.16 143.97,90.06 144.19,89.83 144.19,89.5 143.88,89.18 143.88,88.38 143.74,88.24 143.74,87.89 144.1,87.53 v1(144.1,87.4)
  IN1 w0.094: v1(30.11,65.69) 30.11,66.13 30.2,66.22 35.5,66.22 38.36,69.08 38.36,70.94 37.7,71.61 37.7,76.73 38.33,77.36 38.33,78.63 39.07,79.37 39.07,80.38 40.33,81.64 40.33,83.22 42.47,85.35 42.47,87.75 43.25,88.53 43.25,91.75 43.86,92.36 43.86,95.78 46.76,98.68 47.61,98.68 50.63,101.7 50.63,102 53.08,104.44 53.08,104.49 54.26,105.67 54.26,106.2 55.04,106.97 63.66,106.97 64.09,106.55 65.18,106.55 65.38,106.34 79.33,106.34 79.56,106.12 82.93,106.12 83.28,106.47 90.42,106.47 92.06,108.11 102.77,108.11 103.15,107.73 111.73,107.73 112.48,108.47 123.29,108.47 123.98,107.78 136.01,107.78 136.41,107.39 138.41,107.39 142.77,103.02 142.77,96.06 143.26,95.57 143.26,91.47 143.96,90.78 143.96,90.24
  BOTTOM w0.089: v1(144.1,87.4) UC1.BU6
  BOTTOM w0.104: v1(30.11,65.69) 29.91,65.88 29.91,66.41 29.7,66.63 29.7,67.23 CT9.2
PCIE_PRX_DTX_N7: length 168
  IN1 w0.084: 142.82,90.24 142.82,90.22 142.81,90.21 142.81,89.85 143.7,88.96 143.7,88.45 143.54,88.28 143.54,87.76 v1(143.18,87.4)
  IN1 w0.094: 142.82,90.24 142.82,95.45 142.38,95.89 142.38,102.83 138.22,106.99 123.71,106.99 122.62,108.08 112.65,108.08 111.9,107.33 101.65,107.33 101.27,107.71 93.37,107.71 92.14,106.48 90.99,106.48 89.97,105.46 81.09,105.46 80.83,105.72 79.39,105.72 79.16,105.94 65.22,105.94 65.02,106.15 63.86,106.15 63.67,105.95 61.77,105.95 61.15,106.58 55.44,106.58 55.06,106.2 55.06,105.85 53.91,104.71 53.91,104.22 53.53,103.84 53.04,103.84 51.03,101.83 51.03,101.54 47.76,98.27 46.95,98.27 44.34,95.67 44.34,91.66 44.49,91.52 44.49,89.16 42.87,87.54 42.87,85.19 40.73,83.05 40.73,81.48 39.47,80.22 39.47,79.21 38.73,78.46 38.73,72.88 39.12,72.49 39.12,72.18 38.8,71.86 38.8,68.32 36.28,65.79 32.41,65.79 31.81,65.2 29.23,65.2 27.87,66.55 v1(27.76,66.55)
  BOTTOM w0.089: UC1.BT7 v1(143.18,87.4)
  BOTTOM w0.104: CT128.2 27.72,66.58 v1(27.76,66.55)
PCIE_PRX_DTX_N8: length 171.9
  IN1 w0.084: v1(144.1,85.57) 143.95,85.73 143.2,85.73 142.61,86.31 142.61,88.98 142.06,89.54 142.06,90.21 142.05,90.22 142.05,90.24
  IN1 w0.094: v1(27.76,64.81) 27.96,65.02 28.13,65.02 28.87,64.28 31.13,64.28 31.45,63.96 32.99,63.96 33.62,64.59 36.16,64.59 39.57,68 39.57,68.73 39.93,69.09 39.93,70.5 39.88,70.54 39.88,72.81 39.49,73.2 39.49,78.15 40.24,78.89 40.24,79.9 41.5,81.16 41.5,82.74 43.63,84.87 43.63,87.22 45.25,88.84 45.25,91.97 45.15,92.07 45.15,94.58 51.8,101.22 51.8,101.51 53.32,103.04 53.85,103.04 55.9,105.09 61.42,105.09 61.52,105.19 63.97,105.19 64.21,104.95 66.36,104.95 66.59,105.18 78.84,105.18 79.07,104.96 80.51,104.96 80.77,104.7 91.49,104.7 93.74,106.95 100.69,106.95 101.08,106.56 112.22,106.56 112.96,107.31 114.11,107.31 114.55,106.88 117.04,106.88 117.47,107.31 122.3,107.31 123.39,106.22 137.87,106.22 141.61,102.48 141.61,95.58 142.05,95.14 142.05,90.24
  BOTTOM w0.089: v1(144.1,85.57) 143.72,85.88 UC1.BU9
  BOTTOM w0.104: v1(27.76,64.81) 27.64,64.93 26.3,64.93 25.21,66.02 CT130.2
PCIE_PRX_DTX_N9: length 205.2
  TOP w0.104: v1(286.72,63.38) 286.9,63.38 286.91,63.39 287.34,63.39 287.34,63.39 287.52,63.39 287.89,63.76 CR14.1
  IN4 w0.084: v1(142.25,88.77) 142.25,88.47 142.34,88.38 142.56,88.38 142.64,88.47 142.64,89.53 143.28,90.17 143.28,92.38 143.27,92.39 143.27,92.41
  IN4 w0.094: 143.27,92.41 143.27,92.65 143.57,92.95 144.74,92.95 150.14,98.34 154.75,98.34 155.12,97.97 155.29,97.97 155.72,97.54 162.33,97.54 162.74,97.14 166.3,97.14 167.55,95.89 168.53,95.89 169.25,95.17 175.25,95.17 175.84,94.58 175.84,92.51 177.09,91.26 177.09,88.35 179.03,86.41 179.03,85.4 181.2,83.23 181.2,82.21 184.93,78.47 185.2,78.47 186.36,77.31 187.64,77.31 190.83,74.12 190.83,70.57 192.09,69.31 192.09,67.98 193.31,66.77 193.31,61.84 197.43,57.72 199.69,57.72 213.78,43.62 215.54,43.62 218.38,40.78 221.65,40.78 222.26,40.18 225.65,40.18 226.76,39.07 228.3,39.07 228.69,39.46 239.68,39.46 240.43,40.22 243.87,40.22 244.68,41.03 244.68,41.59 245.64,42.55 256.26,42.55 257.05,43.34 257.05,46.75 260.8,50.51 260.8,50.94 261.32,51.45 263.29,51.45 264.8,52.97 264.8,54.14 267.04,56.37 275.99,56.37 276.41,56.79 281.53,56.79 282.19,57.45 285.06,57.45 285.38,57.77 285.38,58.74 286.46,59.82 286.46,60.39 287.79,61.72 287.79,63.41 287.54,63.65 287.22,63.65 286.95,63.38 v1(286.72,63.38)
  BOTTOM w0.076: UC1.BP5 141.95,88.47 v1(142.25,88.77)
PCIE_PRX_DTX_N10: length 163.5
  IN4 w0.084: 142.68,92.41 142.68,92.39 142.68,92.38 142.68,90.15 141.89,89.37 141.89,88.41 141.69,88.21 141.51,88.21 v1(141.33,88.04)
  IN4 w0.094: 142.68,92.41 142.68,92.63 143.4,93.35 144.58,93.35 149.23,98 149.23,101.6 149.98,102.34 151.79,102.34 153.23,100.9 153.93,100.9 156.84,97.98 162.46,97.98 162.9,97.54 166.46,97.54 167.72,96.28 168.7,96.28 169.42,95.57 175.42,95.57 176.24,94.75 176.24,92.7 177.49,91.45 177.49,88.63 179.78,86.33 179.78,85.23 182.54,82.46 182.54,82.03 186.87,77.71 187.8,77.71 191.22,74.29 191.22,70.74 194.29,67.68 194.29,63.68 213.92,44.05 215.67,44.05 218.54,41.18 221.81,41.18 222.42,40.57 225.86,40.57 226.97,39.47 227.96,39.47 228.35,39.86 239.51,39.86 240.82,41.16 242.85,41.16 243.79,42.1 244.55,42.1 245.4,42.95 254.97,42.95 255.17,43.15 255.17,43.35 v1(255.37,43.55)
  BOTTOM w0.089: v1(141.33,88.04) UC1.BN6
  BOTTOM w0.104: v1(255.37,43.55) 255.33,43.55 255.03,43.85 255.03,44.01 255.21,44.19 255.85,44.19 256.15,43.88 JNGFF1.43
PCIE_PRX_DTX_N11: length 161.1
  TOP w0.104: v1(241.41,44.76) 241.67,44.51 241.88,44.51 242.04,44.67 UZ29.14
  IN4 w0.084: 139.85,92.41 139.85,92.39 139.85,92.38 139.85,86.54 140.26,86.13 v1(141.33,86.13)
  IN4 w0.094: v1(241.41,44.76) 240.29,44.76 239.63,45.42 224.17,45.42 223.75,45.84 220.48,45.84 217.61,48.71 215.85,48.71 204.45,60.11 204.45,60.68 200.94,64.19 199.94,65.19 199.94,73.84 190.8,82.98 190.8,83.65 189.72,84.72 189.3,84.72 186.5,87.52 185.59,87.52 183,90.11 183,93.88 182.39,94.49 182.39,95.55 181.17,96.77 181.17,97.4 175.33,103.24 174.69,103.24 173.75,104.19 171.32,104.19 164.97,110.54 158.31,110.54 156.93,109.17 155.62,109.17 155.35,108.89 154.97,108.89 153.84,107.76 149.4,107.76 148.69,107.05 144.08,107.05 139.59,102.56 139.59,95.87 139.85,95.61 139.85,92.41
  BOTTOM w0.089: v1(141.33,86.13) UC1.BN10
PCIE_PRX_DTX_N12: length 198.3
  IN4 w0.084: v1(140.41,88.04) 140.64,88.27 140.66,88.27 140.75,88.27 140.95,88.47 140.95,92.38 140.95,92.39 140.95,92.41
  IN4 w0.094: 140.95,92.41 140.95,92.97 142.93,94.95 145.35,94.95 147.66,97.25 147.66,102.18 148.4,102.92 151.83,102.92 152.21,103.31 155.77,103.31 157.34,104.88 161.79,104.88 166.13,100.54 166.13,98.88 168.14,96.87 168.94,96.87 169.11,96.69 170.36,96.69 170.66,96.99 171.02,96.99 171.86,96.15 175.91,96.15 177.48,94.58 177.48,92.31 178.09,91.71 178.09,88.85 180.36,86.58 180.36,85.47 183.13,82.7 183.13,82.27 187.11,78.29 188.05,78.29 191.83,74.51 191.83,71 194.13,68.7 194.78,68.7 194.87,68.61 194.87,63.92 214.16,44.63 215.92,44.63 218.78,41.76 222.05,41.76 222.47,41.34 229.1,41.34 230.01,40.44 239.27,40.44 240.57,41.74 242.61,41.74 243.6,42.74 244.3,42.74 245.67,44.1 247.54,44.1 247.92,43.72 254.03,43.72 255.78,45.47 255.78,47.14 256.97,48.33 258.05,48.33 259.21,49.48 259.21,50.34 260.73,51.86 262.52,51.86 264.1,53.45 264.1,54 266.87,56.77 275.83,56.77 277.06,58 v1(277.85,58)
  BOTTOM w0.089: v1(140.41,88.04) UC1.BL6
  BOTTOM w0.104: JNGFF2.43 277.68,57.47 277.37,57.78 277.37,57.97 277.51,58.11 277.74,58.11 v1(277.85,58)
PCIE_PRX_DTX_N13: length 193.9
  IN1 w0.084: 139.31,89.84 139.31,89.82 139.31,89.82 139.31,89.38 138.94,89.01 138.94,88.68 139.48,88.15 v1(139.48,88.04)
  IN1 w0.094: v1(33.85,28.76) 33.59,29.02 33.59,29.59 33.4,29.78 33.4,31.67 33.89,32.16 33.89,48.08 36.57,50.76 36.57,54.21 37.15,54.79 37.15,60.19 40.04,63.08 40.04,66.01 41.11,67.08 41.11,67.08 41.31,67.28 41.31,68.01 41.68,68.38 41.68,71.22 41.63,71.27 41.63,73.53 41.24,73.92 41.24,77.42 41.98,78.17 41.98,79.18 44.79,81.98 45.48,81.98 47.16,83.65 47.16,87.66 47.5,88.01 47.5,92.89 48.24,93.63 48.24,95.19 53.54,100.49 53.54,100.79 54.05,101.29 54.57,101.29 56.62,103.34 60.83,103.34 61.2,102.98 70.23,102.98 70.69,103.43 77.98,103.43 78.23,103.19 79.81,103.19 80.51,102.49 88.6,102.49 89,102.89 92.16,102.89 93.28,104.01 93.93,104.01 94.74,104.82 110.25,104.82 110.66,104.41 113.82,104.41 114.54,105.13 119.81,105.13 120.46,104.48 135.78,104.48 136.13,104.12 137.42,104.12 139.12,102.42 139.12,100.61 140.03,99.7 140.03,91.42 139.31,90.69 139.31,89.84
  BOTTOM w0.089: v1(139.48,88.04) 139.2,87.9 UC1.BK6
  BOTTOM w0.104: JNGFF3.5 32.88,23.3 32.77,23.41 32.77,23.58 33.66,24.47 33.66,28.57 v1(33.85,28.76)
PCIE_PRX_DTX_N14: length 197.5
  IN1 w0.076: 138.01,89.84 138.01,89.83 138.02,89.82 138.02,88.68 138.56,88.14 v1(138.56,88.04)
  IN1 w0.094: v1(30.8,27.62) 30.56,27.86 30.56,28.03 30.66,28.12 34.03,28.12 34.99,29.09 34.99,33.84 34.47,34.36 34.47,47.83 37.22,50.58 37.22,52.13 38.87,53.78 38.87,55.24 38.55,55.56 38.55,57.78 38.06,58.26 38.06,58.82 38.8,59.56 38.8,60.38 39.62,61.19 39.62,61.83 40.63,62.84 40.63,65.77 41.69,66.83 41.69,66.84 41.89,67.04 41.89,67.77 42.26,68.13 42.26,71.46 42.23,71.48 42.23,75.82 42.37,75.96 42.37,76.88 42.23,77.03 42.23,77.59 42.56,77.93 42.56,78.93 44.74,81.11 45.5,81.11 47.74,83.35 47.74,87.41 48.12,87.79 48.12,92.69 48.82,93.39 48.82,94.69 50.24,96.11 50.73,96.11 52.28,97.66 52.28,98.15 54.12,99.99 54.12,100.55 54.29,100.71 54.81,100.71 56,101.9 59.16,101.9 59.65,102.4 70.47,102.4 70.93,102.85 72.78,102.85 73.28,102.35 75.29,102.35 76.94,100.7 80.02,100.7 81.23,101.91 92,101.91 93.52,103.43 94.17,103.43 94.98,104.24 110.01,104.24 110.42,103.83 114.13,103.83 114.82,104.52 119.59,104.52 120.22,103.9 135.54,103.9 135.89,103.54 137.16,103.54 138.54,102.16 138.54,100.37 139.45,99.46 139.45,91.66 139.1,91.31 138.71,91.31 138.01,90.61 138.01,89.84
  BOTTOM w0.089: v1(138.56,88.04) UC1.BJ6
  BOTTOM w0.104: JNGFF3.17 29.88,23.46 29.73,23.61 29.73,24.79 30.57,25.63 30.57,27.38 v1(30.8,27.62)
PCIE_PRX_DTX_N15: length 193.2
  IN1 w0.076: v1(137.63,88.67) 137.63,88.46 137.55,88.38 137.32,88.38 137.24,88.46 137.24,89.84 137.25,89.84
  IN1 w0.094: v1(27.25,26.71) 26.85,26.31 26.85,25.73 27.42,25.16 34.31,25.16 37.41,28.25 37.41,41.52 37.69,41.81 37.69,45.94 42.36,50.61 42.36,54.03 42.14,54.26 42.14,56.33 41.92,56.54 41.92,57.92 42.92,58.92 42.92,64.18 44.63,65.89 44.63,68.56 45.24,69.17 45.24,75.91 45.4,76.07 45.4,77.46 50.12,82.18 50.12,86.36 50.41,86.66 50.41,90.1 53.67,93.35 53.67,95.26 55.69,97.28 56.28,97.28 56.59,97.59 56.59,98.49 57.28,99.18 59.68,99.18 60.32,99.81 70.52,99.81 70.76,100.05 74.34,100.05 75.99,98.4 80.97,98.4 81.53,98.96 82.95,98.96 83.6,99.62 93.61,99.62 95.91,101.93 99.5,101.93 99.89,101.53 113.3,101.53 113.59,101.24 121.39,101.24 121.67,101.53 122.8,101.53 123.8,100.53 127.16,100.53 128.2,101.57 129.5,101.57 130.68,100.39 134.11,100.39 134.78,99.72 134.78,96.04 134.7,95.96 134.7,94.32 134.96,94.07 134.96,93.05 135.21,92.8 135.21,91.87 136.61,90.47 136.92,90.47 137.25,90.14 137.25,89.84
  BOTTOM w0.089: v1(137.63,88.67) UC1.BG5
  BOTTOM w0.104: JNGFF3.29 26.88,23.37 26.73,23.53 26.73,24.29 27.03,24.6 27.03,26.5 v1(27.25,26.71)
PCIE_PRX_DTX_N16: length 196.1
  IN1 w0.084: v1(136.71,88.67) 136.42,88.67 136.34,88.75 136.34,89.34 136.12,89.56 136.12,89.77 136.13,89.77 136.13,89.82 136.13,89.83 136.13,89.84
  IN1 w0.094: v1(23.23,26.73) 23.35,26.85 23.35,27.22 23.56,27.42 24.11,27.42 24.45,27.07 24.45,26.22 26.11,24.57 34.55,24.57 37.99,28.01 37.99,39.82 38.81,40.64 38.81,42.49 38.43,42.88 38.43,45.85 43.41,50.83 43.41,55.17 42.94,55.64 42.94,57.51 43.07,57.63 43.07,58.24 43.5,58.67 43.5,63.94 45.21,65.64 45.21,68.26 45.82,68.87 45.82,75.67 45.98,75.83 45.98,77.21 50.75,81.98 50.75,86.11 51.01,86.37 51.01,87.65 53.28,89.92 53.28,92.13 54.81,93.66 54.81,95.43 55.95,96.58 56.51,96.58 57.28,97.35 57.28,98.04 57.84,98.6 59.93,98.6 60.56,99.23 70.76,99.23 71,99.47 74.08,99.47 75.73,97.82 81.21,97.82 81.77,98.38 83.48,98.38 83.7,98.6 90.9,98.6 91.33,99.03 93.85,99.03 94.47,99.66 97.91,99.66 99.21,100.95 113.06,100.95 113.35,100.66 120.96,100.66 122.63,98.99 124.97,98.99 125.44,98.52 126.89,98.52 129,100.63 129.62,100.63 130.44,99.81 133.87,99.81 134.2,99.48 134.2,96.28 134.12,96.2 134.12,94.08 134.38,93.83 134.38,92.81 134.63,92.56 134.63,91.62 136.13,90.12 136.13,89.84
  BOTTOM w0.089: v1(136.71,88.67) UC1.BE5
  BOTTOM w0.104: v1(23.23,26.73) 23.5,26.46 23.5,23.46 23.38,23.34 JNGFF3.43
PCIE_PRX_DTX_P5: length 174.7
  IN1 w0.084: 144.54,90.24 144.54,90.22 144.54,90.21 144.54,89.91 145.38,89.07 145.38,86.5 145.3,86.42 144.9,86.42 144.81,86.5 144.81,86.64 v1(145.01,86.84)
  IN1 w0.094: v1(32.12,68.64) 32.12,68.89 32,69.02 31.82,69.02 31.72,69.11 31.72,70.12 33.62,72.02 33.62,76.6 34.06,77.03 34.06,79.22 33.98,79.31 33.98,83.62 35.24,84.89 35.24,85.46 35.95,86.17 35.95,89.85 36.68,90.58 36.68,92.49 37.33,93.14 37.33,95.64 37.85,96.17 37.85,97.25 38.55,97.95 38.55,98.92 40.65,101.02 42.29,101.02 45.31,104.05 46.4,104.05 47.16,104.8 48.66,104.8 52.32,108.47 52.32,108.89 54.23,110.8 77.29,110.8 78.7,109.38 87.07,109.38 88.77,111.08 88.77,111.24 88.92,111.38 102.04,111.38 102.14,111.28 105.58,111.28 106.22,110.64 110.47,110.64 111.22,111.38 136.64,111.38 136.85,111.18 137.95,111.18 138.5,110.63 142.42,110.63 147.02,106.03 147.02,97.86 145.05,95.89 145.05,94.3 144.54,93.79 144.54,90.24
  BOTTOM w0.076: UC1.BW8 v1(145.01,86.84)
  BOTTOM w0.104: v1(32.12,68.64) 31.92,68.85 31.92,69.02 CT6.2
PCIE_PRX_DTX_P6: length 166.5
  IN1 w0.084: 144.14,90.24 144.14,90.13 144.37,89.9 144.37,89.43 144.05,89.11 144.05,88.09 v1(144.1,88.04)
  IN1 w0.094: 144.14,90.24 144.14,90.85 143.44,91.55 143.44,95.65 142.96,96.14 142.96,103.1 138.49,107.57 136.48,107.57 136.09,107.96 124.06,107.96 123.36,108.66 112.4,108.66 111.66,107.91 103.23,107.91 102.85,108.29 91.98,108.29 90.34,106.66 83.21,106.66 82.85,106.3 79.63,106.3 79.41,106.53 65.46,106.53 65.26,106.73 64.16,106.73 63.73,107.16 54.96,107.16 54.08,106.28 54.08,105.75 52.9,104.57 52.9,104.52 50.45,102.07 50.45,101.78 47.53,98.86 46.69,98.86 43.68,95.85 43.68,92.44 43.07,91.83 43.07,88.61 42.29,87.83 42.29,85.43 40.15,83.29 40.15,81.72 38.89,80.46 38.89,79.45 38.15,78.71 38.15,77.44 37.52,76.81 37.52,71.53 38.18,70.87 38.18,69.16 35.43,66.41 30.12,66.41 29.92,66.21 29.92,66.09 v1(29.52,65.69)
  BOTTOM w0.089: v1(144.1,88.04) UC1.BU5
  BOTTOM w0.104: CT8.2 29.51,67.25 29.51,66.55 29.72,66.33 29.72,65.89 v1(29.52,65.69)
PCIE_PRX_DTX_P7: length 167.9
  IN1 w0.084: 142.63,90.24 142.63,90.22 142.64,90.21 142.64,89.78 143.53,88.89 143.53,88.52 143.18,88.16 v1(143.18,88.04)
  IN1 w0.094: v1(27.21,66.83) 27.21,66.51 27.54,66.17 27.99,66.17 29.15,65.01 31.89,65.01 32.48,65.61 36.35,65.61 38.98,68.24 38.98,71.78 39.3,72.1 39.3,72.57 38.91,72.96 38.91,78.39 39.66,79.13 39.66,80.14 40.92,81.4 40.92,82.98 43.05,85.11 43.05,87.46 44.67,89.08 44.67,91.59 44.52,91.74 44.52,95.59 47.02,98.09 47.84,98.09 51.21,101.46 51.21,101.76 53.12,103.66 53.61,103.66 54.1,104.15 54.1,104.63 55.24,105.78 55.24,106.12 55.52,106.39 61.07,106.39 61.7,105.77 63.75,105.77 63.94,105.96 64.94,105.96 65.14,105.76 79.09,105.76 79.31,105.54 80.75,105.54 81.01,105.28 90.04,105.28 91.07,106.3 92.22,106.3 93.45,107.53 101.19,107.53 101.57,107.15 111.98,107.15 112.72,107.89 122.54,107.89 123.63,106.8 138.14,106.8 142.19,102.75 142.19,95.82 142.63,95.38 142.63,90.24
  BOTTOM w0.076: UC1.BT6 143.1,87.82 143.18,87.89 v1(143.18,88.04)
  BOTTOM w0.104: CT127.2 27.4,67.17 27.4,67.02 v1(27.21,66.83)
PCIE_PRX_DTX_P8: length 172
  IN1 w0.084: v1(144.1,86.13) 143.87,85.9 143.27,85.9 142.79,86.39 142.79,89.05 142.23,89.61 142.23,90.21 142.23,90.22 142.23,90.24
  IN1 w0.094: v1(27.76,65.4) 27.95,65.2 28.21,65.2 28.94,64.46 31.21,64.46 31.53,64.15 32.91,64.15 33.54,64.78 36.08,64.78 39.38,68.08 39.38,68.81 39.74,69.17 39.74,70.42 39.7,70.47 39.7,72.73 39.31,73.12 39.31,78.22 40.05,78.97 40.05,79.98 41.32,81.24 41.32,82.81 43.45,84.95 43.45,87.3 45.07,88.92 45.07,91.89 44.97,91.99 44.97,94.66 51.61,101.3 51.61,101.59 53.25,103.22 53.77,103.22 55.82,105.27 61.34,105.27 61.45,105.37 64.05,105.37 64.28,105.14 66.28,105.14 66.51,105.36 78.92,105.36 79.14,105.14 80.59,105.14 80.85,104.88 91.41,104.88 93.66,107.13 100.77,107.13 101.15,106.75 112.14,106.75 112.89,107.49 114.19,107.49 114.62,107.06 116.96,107.06 117.39,107.49 122.38,107.49 123.47,106.4 137.95,106.4 141.79,102.56 141.79,95.65 142.23,95.21 142.23,90.24
  BOTTOM w0.089: v1(144.1,86.13) UC1.BU8
  BOTTOM w0.104: CT129.2 25.78,67.11 25.68,67 25.49,67 25.4,66.92 25.4,66.1 26.38,65.12 27.48,65.12 v1(27.76,65.4)
PCIE_PRX_DTX_P9: length 205.2
  TOP w0.104: CR13.1 287.57,63.72 287.44,63.59 287.34,63.59 287.06,63.59 286.93,63.72 v1(286.93,63.9)
  IN4 w0.084: 143.45,92.41 143.45,92.39 143.45,92.38 143.45,90.1 142.81,89.46 142.81,88.4 142.61,88.2 142.41,88.19 v1(142.25,88.04)
  IN4 w0.094: v1(286.93,63.9) 287,63.83 287.62,63.83 287.97,63.48 287.97,61.64 286.65,60.32 286.65,59.74 285.57,58.66 285.57,57.7 285.14,57.27 282.26,57.27 281.6,56.61 276.49,56.61 276.07,56.19 267.11,56.19 264.98,54.06 264.98,52.89 263.37,51.27 261.39,51.27 260.98,50.86 260.98,50.43 257.23,46.68 257.23,43.27 256.34,42.37 245.72,42.37 244.86,41.52 244.86,40.95 243.94,40.03 240.51,40.03 239.75,39.28 228.76,39.28 228.37,38.88 226.68,38.88 225.57,39.99 222.18,39.99 221.57,40.6 218.3,40.6 215.47,43.44 213.71,43.44 199.61,57.53 197.35,57.53 193.12,61.76 193.12,66.69 191.91,67.9 191.91,69.23 190.64,70.5 190.64,74.04 187.56,77.12 186.29,77.12 185.12,78.29 184.86,78.29 181.01,82.13 181.01,83.16 178.84,85.33 178.84,86.33 176.9,88.27 176.9,91.19 175.66,92.44 175.66,94.51 175.18,94.99 169.17,94.99 168.46,95.7 167.48,95.7 166.22,96.95 162.66,96.95 162.26,97.36 155.65,97.36 155.22,97.79 155.04,97.79 154.67,98.16 150.21,98.16 144.82,92.77 143.64,92.77 143.45,92.58 143.45,92.41
  BOTTOM w0.089: v1(142.25,88.04) UC1.BP6
PCIE_PRX_DTX_P10: length 163.4
  IN4 w0.084: 142.5,92.41 142.5,92.39 142.5,92.38 142.5,90.22 141.72,89.44 141.72,88.48 141.62,88.38 141.42,88.38 141.33,88.47 v1(141.33,88.67)
  IN4 w0.094: v1(254.78,43.55) 254.99,43.35 254.99,43.23 254.89,43.14 245.33,43.14 244.48,42.28 243.71,42.28 242.77,41.34 240.74,41.34 239.43,40.04 228.27,40.04 227.88,39.65 227.04,39.65 225.94,40.76 222.5,40.76 221.89,41.36 218.62,41.36 215.75,44.23 213.99,44.23 194.47,63.75 194.47,67.75 191.41,70.81 191.41,74.36 187.88,77.89 186.94,77.89 182.73,82.11 182.73,82.54 179.96,85.3 179.96,86.41 177.67,88.71 177.67,91.53 176.42,92.77 176.42,94.82 175.49,95.75 169.49,95.75 168.77,96.47 167.79,96.47 166.54,97.72 162.98,97.72 162.53,98.16 156.91,98.16 154,101.08 153.31,101.08 151.86,102.52 149.9,102.52 149.05,101.67 149.05,98.08 144.5,93.53 143.33,93.53 142.5,92.7 142.5,92.41
  BOTTOM w0.089: v1(141.33,88.67) UC1.BN5
  BOTTOM w0.104: v1(254.78,43.55) 254.78,44.03 255.13,44.38 JNGFF1.41
PCIE_PRX_DTX_P11: length 161.1
  TOP w0.104: UZ29.15 242.02,44.17 241.88,44.32 241.65,44.32 v1(241.41,44.08)
  IN4 w0.084: 140.03,92.41 140.03,92.39 140.02,92.38 140.02,86.61 140.33,86.3 140.93,86.3 141.01,86.39 141.01,86.64 141.14,86.77 v1(141.33,86.77)
  IN4 w0.094: v1(241.41,44.08) 241.41,44.23 241.06,44.58 240.21,44.58 239.55,45.24 224.09,45.24 223.67,45.66 220.4,45.66 217.53,48.53 215.77,48.53 204.27,60.03 204.27,60.6 200.86,64.01 199.76,65.12 199.76,73.77 190.62,82.91 190.62,83.57 189.65,84.54 189.23,84.54 186.42,87.34 185.51,87.34 182.82,90.04 182.82,93.8 182.21,94.41 182.21,95.47 180.99,96.69 180.99,97.33 175.26,103.06 174.62,103.06 173.67,104.01 171.25,104.01 164.89,110.36 158.38,110.36 157.01,108.99 155.7,108.99 155.42,108.71 155.04,108.71 153.91,107.58 149.48,107.58 148.76,106.87 144.15,106.87 139.77,102.48 139.77,95.95 140.03,95.69 140.03,92.41
  BOTTOM w0.076: v1(141.33,86.77) 141.33,86.59 141.25,86.52 UC1.BN8
PCIE_PRX_DTX_P12: length 198.4
  IN4 w0.084: v1(140.4,88.67) 140.64,88.44 140.67,88.44 140.77,88.54 140.77,92.38 140.77,92.39 140.77,92.41
  IN4 w0.094: 140.77,92.41 140.77,93.05 142.85,95.13 145.28,95.13 147.48,97.33 147.48,102.26 148.33,103.11 151.75,103.11 152.14,103.49 155.69,103.49 157.27,105.06 161.86,105.06 166.31,100.61 166.31,98.95 168.22,97.05 169.02,97.05 169.19,96.87 170.29,96.87 170.59,97.17 171.09,97.17 171.93,96.33 175.99,96.33 177.67,94.65 177.67,92.39 178.28,91.78 178.28,88.92 180.55,86.65 180.55,85.54 183.31,82.78 183.31,82.35 187.18,78.47 188.12,78.47 192.01,74.58 192.01,71.08 194.2,68.88 194.85,68.88 195.05,68.68 195.05,64 214.23,44.81 215.99,44.81 218.86,41.95 222.13,41.95 222.55,41.53 229.18,41.53 230.08,40.62 239.19,40.62 240.5,41.93 242.53,41.93 243.52,42.92 244.23,42.92 245.59,44.29 247.62,44.29 248,43.9 253.96,43.9 255.6,45.55 255.6,47.22 256.89,48.51 257.98,48.51 259.03,49.56 259.03,50.41 260.66,52.04 262.44,52.04 263.92,53.52 263.92,54.08 266.79,56.96 275.75,56.96 276.98,58.18 277.32,58.18 v1(277.68,58.55)
  BOTTOM w0.089: v1(140.4,88.67) UC1.BL5
  BOTTOM w0.104: JNGFF2.41 277.18,58.05 v1(277.68,58.55)
PCIE_PRX_DTX_P13: length 193.9
  IN1 w0.084: v1(139.48,88.67) 139.2,88.67 139.12,88.75 139.12,88.94 139.48,89.31 139.48,89.82 139.49,89.82 139.49,89.84
  IN1 w0.094: v1(33.27,28.76) 33.41,28.9 33.41,29.52 33.22,29.71 33.22,31.74 33.71,32.24 33.71,48.15 36.39,50.83 36.39,54.29 36.97,54.87 36.97,60.27 39.86,63.16 39.86,66.08 40.93,67.15 40.93,67.15 41.13,67.35 41.13,68.09 41.49,68.45 41.49,71.14 41.47,71.16 41.47,71.17 41.45,71.2 41.45,73.45 41.06,73.85 41.06,77.5 41.8,78.24 41.8,79.25 44.71,82.16 45.41,82.16 46.97,83.73 46.97,87.73 47.32,88.08 47.32,92.97 48.06,93.71 48.06,95.26 53.36,100.56 53.36,100.87 53.97,101.48 54.5,101.48 56.55,103.53 60.91,103.53 61.27,103.16 70.16,103.16 70.61,103.62 78.06,103.62 78.3,103.37 79.89,103.37 80.58,102.68 88.52,102.68 88.92,103.08 92.08,103.08 93.2,104.2 93.86,104.2 94.66,105 110.33,105 110.73,104.6 113.75,104.6 114.47,105.31 119.89,105.31 120.54,104.66 135.85,104.66 136.21,104.3 137.5,104.3 139.3,102.5 139.3,100.69 140.22,99.78 140.22,91.34 139.49,90.61 139.49,89.84
  BOTTOM w0.089: v1(139.48,88.67) UC1.BK5
  BOTTOM w0.104: JNGFF3.7 32.38,23.3 32.58,23.5 32.58,23.66 33.47,24.55 33.47,28.56 v1(33.27,28.76)
PCIE_PRX_DTX_P14: length 197.5
  IN1 w0.076: 138.19,89.84 138.19,89.83 138.18,89.82 138.18,88.75 138.26,88.67 v1(138.56,88.67)
  IN1 w0.094: v1(30.22,27.62) 30.38,27.78 30.38,28.11 30.58,28.31 33.96,28.31 34.81,29.16 34.81,33.76 34.29,34.28 34.29,47.91 37.03,50.65 37.03,52.2 38.69,53.85 38.69,55.17 38.37,55.49 38.37,57.7 37.88,58.19 37.88,58.89 38.62,59.63 38.62,60.45 39.43,61.27 39.43,61.91 40.44,62.91 40.44,65.84 41.51,66.91 41.51,66.91 41.71,67.11 41.71,67.84 42.08,68.21 42.08,71.38 42.05,71.41 42.05,71.41 42.05,71.41 42.05,75.9 42.19,76.04 42.19,76.8 42.04,76.95 42.04,77.66 42.38,78 42.38,79.01 44.67,81.3 45.43,81.3 47.55,83.43 47.55,87.49 47.94,87.87 47.94,92.76 48.64,93.47 48.64,94.77 50.17,96.29 50.66,96.29 52.1,97.73 52.1,98.22 53.94,100.06 53.94,100.62 54.21,100.9 54.74,100.9 55.93,102.08 59.08,102.08 59.58,102.58 70.4,102.58 70.86,103.04 72.85,103.04 73.36,102.53 75.37,102.53 77.02,100.88 79.94,100.88 81.16,102.1 91.92,102.1 93.44,103.61 94.1,103.61 94.9,104.42 110.09,104.42 110.49,104.01 114.06,104.01 114.75,104.71 119.67,104.71 120.3,104.08 135.61,104.08 135.97,103.72 137.23,103.72 138.72,102.23 138.72,100.45 139.63,99.53 139.63,91.58 139.18,91.12 138.78,91.12 138.19,90.53 138.19,89.84
  BOTTOM w0.089: v1(138.56,88.67) UC1.BJ5
  BOTTOM w0.104: v1(30.22,27.62) 30.37,27.46 30.37,25.71 29.53,24.87 29.53,23.62 29.38,23.46 JNGFF3.19
PCIE_PRX_DTX_P15: length 193.1
  IN1 w0.076: 137.07,89.66 137.06,89.65 137.06,88.4 137.25,88.22 137.45,88.22 v1(137.63,88.04)
  IN1 w0.094: v1(26.66,26.71) 26.66,25.66 27.34,24.97 34.39,24.97 37.59,28.17 37.59,41.44 37.88,41.73 37.88,45.86 42.54,50.53 42.54,54.11 42.32,54.33 42.32,56.4 42.11,56.61 42.11,57.84 43.1,58.84 43.1,64.11 44.81,65.81 44.81,68.48 45.42,69.09 45.42,75.83 45.58,76 45.58,77.38 50.3,82.1 50.3,86.29 50.6,86.59 50.6,90.02 53.85,93.28 53.85,95.19 55.76,97.09 56.36,97.09 56.78,97.51 56.78,98.41 57.36,99 59.76,99 60.39,99.63 70.6,99.63 70.83,99.87 74.26,99.87 75.91,98.22 81.05,98.22 81.61,98.78 83.03,98.78 83.68,99.43 93.68,99.43 95.99,101.74 99.42,101.74 99.81,101.35 113.22,101.35 113.51,101.06 121.46,101.06 121.75,101.35 122.73,101.35 123.72,100.35 127.24,100.35 128.28,101.39 129.42,101.39 130.61,100.21 134.03,100.21 134.6,99.64 134.6,96.11 134.52,96.04 134.52,94.25 134.78,93.99 134.78,92.98 135.03,92.72 135.03,91.79 136.53,90.29 136.84,90.29 137.07,90.07 137.07,89.66
  BOTTOM w0.089: v1(137.63,88.04) UC1.BG6
  BOTTOM w0.104: JNGFF3.31 26.38,23.37 26.53,23.52 26.53,24.37 26.84,24.68 26.84,26.54 v1(26.66,26.71)
PCIE_PRX_DTX_P16: length 196.1
  IN1 w0.084: 135.95,89.84 135.95,89.49 136.17,89.27 136.17,88.68 136.71,88.14 v1(136.71,88.04)
  IN1 w0.094: 135.95,89.84 135.95,90.05 134.45,91.55 134.45,92.48 134.19,92.74 134.19,93.75 133.94,94.01 133.94,96.28 134.02,96.35 134.02,99.4 133.79,99.63 130.37,99.63 129.55,100.45 129.07,100.45 126.96,98.34 125.37,98.34 124.9,98.81 122.55,98.81 120.88,100.48 113.27,100.48 112.98,100.77 99.28,100.77 97.99,99.47 94.54,99.47 93.92,98.85 91.41,98.85 90.98,98.42 83.77,98.42 83.55,98.2 81.85,98.2 81.29,97.64 75.65,97.64 74,99.29 71.08,99.29 70.84,99.05 60.64,99.05 60,98.42 57.92,98.42 57.47,97.96 57.47,97.28 56.58,96.39 56.03,96.39 54.99,95.36 54.99,93.59 53.46,92.06 53.46,89.84 51.19,87.57 51.19,86.29 50.93,86.03 50.93,81.91 46.16,77.14 46.16,75.75 46,75.59 46,68.8 45.39,68.19 45.39,65.57 43.69,63.86 43.69,58.6 43.25,58.16 43.25,57.56 43.12,57.43 43.12,55.71 43.59,55.24 43.59,50.76 38.61,45.77 38.61,42.95 39,42.57 39,40.57 38.17,39.74 38.17,27.93 34.62,24.39 26.03,24.39 24.27,26.15 24.27,27 24.03,27.24 23.63,27.24 23.54,27.14 23.54,27.01 v1(23.82,26.73)
  BOTTOM w0.089: v1(136.71,88.04) UC1.BE6
  BOTTOM w0.104: JNGFF3.41 23.88,23.35 23.69,23.54 23.69,26.6 v1(23.82,26.73)
PCIE_PRX_L_DTX_N11: length 2.9
  TOP w0.104: LI16.2 273.71,54.83 273.56,54.99 273.56,55.56 273.78,55.77 v1(273.97,55.77)
  BOTTOM w0.104: v1(273.97,55.77) 274.18,55.99 JNGFF2.29
PCIE_PRX_L_DTX_P11: length 2.9
  TOP w0.104: v1(273.95,55.19) 273.96,55.19 274.21,54.94 LI16.3
  BOTTOM w0.104: v1(273.95,55.19) 274.67,55.92 274.67,56.82 JNGFF2.31
PCIE_PRX_SW_DTX_N11: length 37.4
  TOP w0.104: v1(273.8,51.73) 273.77,51.73 273.37,52.13 273.37,52.44 273.71,52.79 LI16.1 ; UZ29.4 245.51,43.17 245.64,43.04 245.94,43.04 246.59,42.4 246.59,41.91 v1(246.66,41.84)
  IN1 w0.094: v1(246.66,41.84) 246.66,42.27 247.08,42.69 250.73,42.69 251.69,43.65 254.18,43.65 254.65,44.12 256.3,44.12 256.71,43.71 260.55,43.71 262.44,45.6 266.61,45.6 267.45,46.44 267.45,46.94 268.48,47.98 271.52,47.98 272.47,48.93 272.47,50.91 273.29,51.73 v1(273.8,51.73)
PCIE_PRX_SW_DTX_P11: length 37.3
  TOP w0.104: LI16.4 274.21,52.7 v1(273.8,52.29) ; UZ29.3 245.49,42.67 245.67,42.85 245.86,42.85 246.4,42.32 246.4,42.16 v1(246.08,41.84)
  IN1 w0.094: v1(273.8,52.29) 273.61,52.29 273.51,52.18 273.51,51.99 273.43,51.91 273.22,51.91 272.29,50.99 272.29,49.01 271.44,48.17 268.41,48.17 267.26,47.02 267.26,46.51 266.53,45.78 262.36,45.78 260.47,43.89 256.79,43.89 256.38,44.3 254.57,44.3 254.11,43.83 251.61,43.83 250.65,42.87 247.01,42.87 246.48,42.34 246.48,42.24 246.41,42.18 246.17,42.18 246.08,42.08 v1(246.08,41.84)
PCIE_PTX_C_DRX_N5: length 5.3
  BOTTOM w0.076: 30.88,71.72 30.87,71.74 30.85,71.74 30.59,72 30.59,72.1 30.69,72.2 30.69,72.5 arc(30.66,72.63) 30.59,72.74 UT1.Y22
  BOTTOM w0.104: 30.88,71.72 31.3,71.3 32.64,71.3 v4(33.26,70.69) 33.66,70.29 33.66,69.95 CT3.2
PCIE_PTX_C_DRX_N6: length 4.3
  BOTTOM w0.076: 28.81,71.7 28.79,71.71 28.78,71.71 28.68,71.81 28.68,71.97 28.85,72.14 28.85,72.5 arc(28.82,72.63) 28.75,72.74 UT1.T22
  BOTTOM w0.104: CT5.2 30.61,69.99 30.61,70.28 30.19,70.7 29.82,70.7 29.46,71.07 29.44,71.07 28.81,71.7
PCIE_PTX_C_DRX_N7: length 4
  BOTTOM w0.076: 26.85,71.59 26.84,71.59 26.84,71.61 26.84,71.61 26.8,71.65 26.8,71.67 26.7,71.77 26.7,72.01 26.55,72.16 26.55,72.55 arc(26.57,72.63) 26.62,72.71 UT1.M22
  BOTTOM w0.104: CT124.2 28.21,69.96 28.21,70.31 27.79,70.73 27.79,70.74 27.51,71.02 27.41,71.02 26.85,71.59
PCIE_PTX_C_DRX_N8: length 4.6
  BOTTOM w0.076: 24.97,71.59 24.97,71.61 24.96,71.62 24.96,71.93 25.17,72.14 25.17,72.5 arc(25.14,72.63) 25.07,72.74 UT1.H22
  BOTTOM w0.104: CT126.2 26.68,69.93 26.68,70.26 26.31,70.63 25.83,70.63 25.81,70.64 25.3,70.64 24.97,70.97 24.97,71.59
PCIE_PTX_C_DRX_N9: length 6.7
  TOP w0.104: CR12.2 286.51,64.35 286.76,64.35 287.08,64.66 287.08,65.22 286.91,65.39 286.91,66.6 287.15,66.84 v4(287.92,66.84) 288.91,66.84 288.93,66.83 289.75,66.83 289.84,66.74 UR1.4
PCIE_PTX_C_DRX_N10: length 3
  BOTTOM w0.104: JNGFF1.37 256.15,45.38 256,45.53 255.85,45.53 255.27,44.95 254.94,44.95 CZ13.2
PCIE_PTX_C_DRX_N11: length 2
  TOP w0.104: CZ153.2 241.24,45.8 241.47,45.8 241.74,45.53 241.89,45.53 242.03,45.67 UZ29.12
PCIE_PTX_C_DRX_N12: length 3
  TOP w0.104: v1(278.45,55.26) 278.77,54.95 278.77,54.58 CZ210.2
  BOTTOM w0.104: v1(278.45,55.26) 278.77,55.58 278.77,55.84 278.68,55.93 JNGFF2.47
PCIE_PTX_C_DRX_N13: length 3.8
  BOTTOM w0.104: JNGFF3.11 31.38,23.48 31.23,23.64 31.23,23.98 31.88,24.64 31.88,25.54 CN65.1
PCIE_PTX_C_DRX_N14: length 3.8
  BOTTOM w0.104: CN67.1 28.82,25.59 28.82,24.93 28.27,24.38 28.27,23.61 28.38,23.5 JNGFF3.23
PCIE_PTX_C_DRX_N15: length 2.7
  BOTTOM w0.104: JNGFF3.35 25.38,23.35 25.29,23.44 25.29,24.69 CN69.1
PCIE_PTX_C_DRX_N16: length 2.9
  BOTTOM w0.104: JNGFF3.47 22.38,23.34 22.21,23.51 22.21,24.37 21.88,24.69 21.88,24.75 CN71.1
PCIE_PTX_C_DRX_P5: length 5.4
  BOTTOM w0.076: 30.74,71.59 30.73,71.6 30.73,71.62 30.42,71.93 30.42,72.06 30.23,72.26 30.23,72.5 arc(30.26,72.59) 30.35,72.62 arc(30.42,72.59) 30.46,72.51 UT1.Y23
  BOTTOM w0.104: CT2.2 33.46,70.02 33.46,70.22 33.34,70.34 33.32,70.34 32.93,70.73 32.93,70.74 32.56,71.11 31.22,71.11 30.74,71.59
PCIE_PTX_C_DRX_P6: length 4.3
  BOTTOM w0.076: 28.65,71.59 28.51,71.72 28.51,72.07 28.39,72.2 28.39,72.5 arc(28.42,72.59) 28.51,72.62 arc(28.58,72.59) 28.62,72.51 UT1.T23
  BOTTOM w0.104: CT4.2 30.42,69.98 30.42,70.2 30.11,70.51 29.73,70.51 29.51,70.72 v4(29.51,70.73) 29.51,70.73 29.06,71.18 28.65,71.59
PCIE_PTX_C_DRX_P7: length 4
  BOTTOM w0.076: UT1.M23 26.78,72.51 arc(26.81,72.59) 26.89,72.62 arc(26.97,72.58) 27.01,72.49 27.01,72.14 26.87,71.99 26.87,71.84 26.98,71.72
  BOTTOM w0.104: CT123.2 28.4,69.96 28.4,70.4 v4(28.12,70.69) 27.59,71.22 27.49,71.22 26.98,71.72
PCIE_PTX_C_DRX_P8: length 4.6
  BOTTOM w0.076: UT1.H23 24.94,72.51 arc(24.9,72.59) 24.83,72.62 arc(24.74,72.59) 24.71,72.5 24.71,72.15 24.79,72.06 24.79,71.62 24.78,71.61 24.78,71.59
  BOTTOM w0.104: CT125.2 26.48,70 26.48,70.18 26.23,70.43 v4(25.53,70.43) 25.23,70.43 24.78,70.89 24.78,71.59
PCIE_PTX_C_DRX_P9: length 6.8
  TOP w0.104: UR1.3 289.85,67.14 289.74,67.04 v4(289.19,67.04) 288.19,67.04 288.17,67.05 287.66,67.05 287.64,67.04 287.07,67.04 286.72,66.68 286.72,65.31 286.88,65.14 286.88,64.74 286.68,64.54 286.53,64.54 CR11.2
PCIE_PTX_C_DRX_P10: length 3
  BOTTOM w0.104: JNGFF1.35 256.15,45.88 256,45.73 255.77,45.73 255.19,45.14 254.98,45.14 CZ12.2
PCIE_PTX_C_DRX_P11: length 2
  TOP w0.104: CZ152.2 241.25,45.61 241.39,45.61 241.66,45.34 241.93,45.34 242.1,45.17 UZ29.13
PCIE_PTX_C_DRX_P12: length 2.9
  TOP w0.104: v1(279.08,55.22) 278.96,55.11 278.96,54.81 CZ211.2
  BOTTOM w0.104: JNGFF2.49 279.18,56.03 278.96,55.81 278.96,55.34 v1(279.08,55.22)
