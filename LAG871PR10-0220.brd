# Allegro board LAG871PR10-0220.brd (continued)
## Nets (continued)
GND: CA5.2 CA6.2 CA7.2 CA10.2 CA12.2 CA13.1 CA19.2 CA22.2 CA23.2 CA24.2 CA31.2 CA33.2 CA45.2 CA46.2 CA47.2 CA48.2 CA49.2 CA53.2 CA54.2 CA55.2 CA56.2 CA59.2 CA60.2 CA61.2 CA62.2 CA63.2 CA64.2 CA65.2 CA66.2 CA67.2 CA68.2 CA69.2 CA72.2 CA77.2 CC9.2 CC10.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC45.2 CC46.2 CC51.2 CC52.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC73.2 CC75.2 CC76.2 CC77.2 CC78.2 CC80.2 CC83.2 CC84.2 CC85.2 CC86.2 CC93.1 CC95.1 CC96.2 CC98.2 CC100.2 CC102.2 CC103.2 CC104.2 CC195.2 CC196.2 CC234.2 CC235.2 CC236.2 CC237.2 CC266.2 CC269.2 CC279.2 CC280.2 CC288.2 CC299.2 CC300.2 CC301.2 CC302.2 CC303.2 CC304.2 CC305.2 CC306.2 CC307.2 CC316.2 CC318.2 CC319.2 CC320.2 CC326.2 CC331.2 CC332.2 CC333.2 CC334.2 CC340.2 CC430.2 CC1452.2 CC1453.2 CC1454.2 CC1455.2 CC1456.2 CC1457.2 CC1458.2 CC1459.2 CC1460.2 CC1461.2 CC1462.2 CC1463.2 CC1464.2 CC1465.2 CC1466.2 CC1467.2 CC1468.2 CC1469.2 CC1470.2 CC1471.2 CC1476.2 CC1477.2 CC1478.2 CC1479.2 CC1480.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD63.2 CD66.2 CD69.2 CD70.2 CD71.2 CD72.2 CE3.2 CE4.2 CE8.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE19.2 CE20.2 CE21.2 CE22.2 CE23.2 CE25.2 CE28.2 CE29.2 CE30.2 CE31.2 CE32.2 CE36.2 CE38.2 CE40.2 CE47.2 CE52.2 CE53.2 CE54.2 CE57.2 CE59.2 CE60.2 CE61.2 CE62.2 CE63.2 CE64.2 CE65.2 CE66.2 CE67.2 CE68.2 CI1.2 CI3.2 CI6.2 CI7.2 CI14.2 CI17.2 CI19.2 CI31.2 CI32.2 CI33.2 CI34.2 CI43.2 CI44.2 CI45.2 CI46.2 CI103.2 CLIP1.1(P1) CLIP2.1(P1) CLIP3.1(P1) CLIP4.1(P1) CLIP5.1(P1) CLIP6.1(P1) CLIP7.1(P1) CLIP8.1(P1) CLIP9.1(P1) CLIP10.1(P1) CLIP11.1(P1) CLIP12.1(P1) CLIP13.1(P1) CLIP14.1(P1) CLIP15.1(P1) CLIP16.1(P1) CMOS1.2 CN60.2 CN61.2 CN62.2 CN63.2 CN64.2 CN77.2 CN78.2 CN79.2 CN80.2 CN81.2 CN82.2 CN84.2 CN86.2 CN87.2 CR1.2 CR2.2 CR3.2 CR4.2 CR5.2 CR6.2 CR7.2 CR15.2 CR17.1 CR18.2 CR19.1 CR20.2 CR21.2 CR22.2 CR25.2 CR26.2 CR27.2 CR28.2 CT1.2 CT20.2 CT21.2 CT22.2 CT25.2 CT26.2 CT27.2 CT28.2 CT29.2 CT30.2 CT31.2 CT32.2 CT33.2 CT34.2 CT35.2 CT36.2 CT37.2 CT38.2 CT39.2 CT40.2 CT41.2 CT42.2 CT43.2 CT44.2 CT45.2 CT46.2 CT47.2 CT48.2 CT49.2 CT50.2 CT51.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT59.2 CT60.2 CT61.2 CT62.2 CT63.2 CT64.2 CT67.2 CT68.2 CT69.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT76.2 CT77.2 CT78.2 CT82.2 CT83.2 CT84.2 CT85.2 CT86.2 CT87.2 CT88.2 CT89.2 CT90.2 CT91.2 CT92.2 CT94.2 CT99.2 CT100.1 CT101.2 CT102.1 CT189.2 CT190.2 CT193.2 CT237.2 CT359.2 CT360.2 CV11.2 CV12.2 CV14.2 CV15.2 CV16.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV24.2 CV25.2 CV39.2 CV40.2 CV41.2 CV54.2 CV55.2 CV632.2 CV633.2 CV634.2 CV635.2 CV651.2 CV652.2 CV750.2 CV751.2 CV752.2 CV753.2 CV754.2 CV755.2 CV756.2 CV757.2 CV758.2 CZ2.2 CZ3.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ21.2 CZ23.2 CZ24.2 CZ25.2 CZ26.2 CZ27.2 CZ28.2 CZ29.2 CZ30.2 CZ31.2 CZ32.2 CZ33.2 CZ34.2 CZ35.2 CZ36.2 CZ37.2 CZ39.2 CZ40.2 CZ41.2 CZ50.2 CZ51.2 CZ52.2 CZ53.2 CZ54.2 CZ55.2 CZ56.2 CZ57.2 CZ58.2 CZ62.2 CZ63.2 CZ64.2 CZ66.2 CZ67.2 CZ68.2 CZ69.2 CZ71.2 CZ72.2 CZ73.2 CZ75.2 CZ80.2 CZ81.2 CZ82.2 CZ83.2 CZ84.2 CZ85.2 CZ86.2 CZ87.2 CZ88.2 CZ89.2 CZ90.2 CZ91.2 CZ92.2 CZ93.2 CZ94.2 CZ100.2 CZ101.2 CZ102.2 CZ105.2 CZ106.2 CZ109.2 CZ112.2 CZ113.2 CZ114.2 CZ115.2 CZ116.2 CZ117.2 CZ118.2 CZ119.2 CZ120.2 CZ121.2 CZ122.2 CZ124.2 CZ125.2 CZ126.2 CZ127.2 CZ128.2 CZ154.2 CZ155.2 CZ156.2 CZ197.2 CZ198.2 CZ200.2 CZ202.2 CZ204.2 CZ205.2 CZ206.2 CZ207.2 CZ218.2 CZ220.2 CZ227.2 CZ228.2 CZ229.2 CZ230.2 CZ233.2 CZ234.2 CZ303.1 CZ305.2 CZ306.2 CZ307.2 CZ308.2 CZ309.2 CZ311.2 CZ312.2 DA1.1 DA2.1 DA3.1 DA6.1 DA7.1 DD1.1 DE1.2 DI1.3 DI2.1 DI4.3 DI5.1 DT4.2(OUT) DT5.2 DT6.2 DT9.2 DT10.2 DT13.2 DT14.2 DT17.2 DT18.2 DT39.3 DT40.3 DV13.1 DV14.1 DZ10.1 DZ11.1 DZ13.3 DZ14.3 DZ15.3 DZ21.1 H1.1 H2.1 H3.1 H4.1 H5.1 H8.1 H11.1 H12.1 H13.1 H14.1 H15.1 H16.1 H17.1 H18.1 H20.1 H21.1 H27.1 H28.1 H29.1 H30.1 H31.1 JANT1.6(GND1) JANT1.7(GND2) JANT1.8(GND3) JANT1.9(GND4) JANT1.10(GND5) JANT1.11(GND6) JANT1.12(GND7) JANT1.13(GND8) JANT2.6(GND1) JANT2.7(GND2) JANT2.8(GND3) JANT2.9(GND4) JANT2.10(GND5) JANT2.11(GND6) JANT2.12(GND7) JANT2.13(GND8) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19(GND1) JAPS1.20(GND2) JASA1.1 JASA1.5(G1) JASA1.6(G2) JDEG1.10 JDEG1.11(GND1) JDEG1.12(GND2) JDIMM1.1(VSS1) JDIMM1.2(VSS2) JDIMM1.5(VSS3) JDIMM1.6(VSS4) JDIMM1.9(VSS5) JDIMM1.10(VSS6) JDIMM1.14(VSS7) JDIMM1.15(VSS8) JDIMM1.18(VSS9) JDIMM1.19(VSS10) JDIMM1.22(VSS11) JDIMM1.23(VSS12) JDIMM1.26(VSS13) JDIMM1.27(VSS14) JDIMM1.30(VSS15) JDIMM1.31(VSS16) JDIMM1.35(VSS17) JDIMM1.36(VSS18) JDIMM1.39(VSS19) JDIMM1.40(VSS20) JDIMM1.43(VSS21) JDIMM1.44(VSS22) JDIMM1.47(VSS23) JDIMM1.48(VSS24) JDIMM1.51(VSS25) JDIMM1.52(VSS26) JDIMM1.56(VSS27) JDIMM1.57(VSS28) JDIMM1.60(VSS29) JDIMM1.61(VSS30) JDIMM1.64(VSS31) JDIMM1.65(VSS32) JDIMM1.68(VSS33) JDIMM1.69(VSS34) JDIMM1.72(VSS35) JDIMM1.73(VSS36) JDIMM1.77(VSS37) JDIMM1.78(VSS38) JDIMM1.81(VSS39) JDIMM1.82(VSS40) JDIMM1.85(VSS41) JDIMM1.86(VSS42) JDIMM1.89(VSS43) JDIMM1.90(VSS44) JDIMM1.93(VSS45) JDIMM1.94(VSS46) JDIMM1.98(VSS47) JDIMM1.99(VSS48) JDIMM1.102(VSS49) JDIMM1.103(VSS50) JDIMM1.106(VSS51) JDIMM1.107(VSS52) JDIMM1.167(VSS53) JDIMM1.168(VSS54) JDIMM1.171(VSS55) JDIMM1.172(VSS56) JDIMM1.175(VSS57) JDIMM1.176(VSS58) JDIMM1.180(VSS59) JDIMM1.181(VSS60) JDIMM1.184(VSS61) JDIMM1.185(VSS62) JDIMM1.188(VSS63) JDIMM1.189(VSS64) JDIMM1.192(VSS65) JDIMM1.193(VSS66) JDIMM1.196(VSS67) JDIMM1.197(VSS68) JDIMM1.201(VSS69) JDIMM1.202(VSS70) JDIMM1.205(VSS71) JDIMM1.206(VSS72) JDIMM1.209(VSS73) JDIMM1.210(VSS74) JDIMM1.213(VSS75) JDIMM1.214(VSS76) JDIMM1.217(VSS77) JDIMM1.218(VSS78) JDIMM1.222(VSS79) JDIMM1.223(VSS80) JDIMM1.226(VSS81) JDIMM1.227(VSS82) JDIMM1.230(VSS83) JDIMM1.231(VSS84) JDIMM1.234(VSS85) JDIMM1.235(VSS86) JDIMM1.238(VSS87) JDIMM1.239(VSS88) JDIMM1.243(VSS89) JDIMM1.244(VSS90) JDIMM1.247(VSS91) JDIMM1.248(VSS92) JDIMM1.251(VSS93) JDIMM1.252(VSS94) JDIMM1.261(GND2) JDIMM1.262(GND1) JDIMM2.1(VSS1) JDIMM2.2(VSS2) JDIMM2.5(VSS3) JDIMM2.6(VSS4) JDIMM2.9(VSS5) JDIMM2.10(VSS6) JDIMM2.14(VSS7) JDIMM2.15(VSS8) JDIMM2.18(VSS9) JDIMM2.19(VSS10) JDIMM2.22(VSS11) JDIMM2.23(VSS12) JDIMM2.26(VSS13) JDIMM2.27(VSS14) JDIMM2.30(VSS15) JDIMM2.31(VSS16) JDIMM2.35(VSS17) JDIMM2.36(VSS18) JDIMM2.39(VSS19) JDIMM2.40(VSS20) JDIMM2.43(VSS21) JDIMM2.44(VSS22) JDIMM2.47(VSS23) JDIMM2.48(VSS24) JDIMM2.51(VSS25) JDIMM2.52(VSS26) JDIMM2.56(VSS27) JDIMM2.57(VSS28) JDIMM2.60(VSS29) JDIMM2.61(VSS30) JDIMM2.64(VSS31) JDIMM2.65(VSS32) JDIMM2.68(VSS33) JDIMM2.69(VSS34) JDIMM2.72(VSS35) JDIMM2.73(VSS36) JDIMM2.77(VSS37) JDIMM2.78(VSS38) JDIMM2.81(VSS39) JDIMM2.82(VSS40) JDIMM2.85(VSS41) JDIMM2.86(VSS42) JDIMM2.89(VSS43) JDIMM2.90(VSS44) JDIMM2.93(VSS45) JDIMM2.94(VSS46) JDIMM2.98(VSS47) JDIMM2.99(VSS48) JDIMM2.102(VSS49) JDIMM2.103(VSS50) JDIMM2.106(VSS51) JDIMM2.107(VSS52) JDIMM2.167(VSS53) JDIMM2.168(VSS54) JDIMM2.171(VSS55) JDIMM2.172(VSS56) JDIMM2.175(VSS57) JDIMM2.176(VSS58) JDIMM2.180(VSS59) JDIMM2.181(VSS60) JDIMM2.184(VSS61) JDIMM2.185(VSS62) JDIMM2.188(VSS63) JDIMM2.189(VSS64) JDIMM2.192(VSS65) JDIMM2.193(VSS66) JDIMM2.196(VSS67) JDIMM2.197(VSS68) JDIMM2.201(VSS69) JDIMM2.202(VSS70) JDIMM2.205(VSS71) JDIMM2.206(VSS72) JDIMM2.209(VSS73) JDIMM2.210(VSS74) JDIMM2.213(VSS75) JDIMM2.214(VSS76) JDIMM2.217(VSS77) JDIMM2.218(VSS78) JDIMM2.222(VSS79) JDIMM2.223(VSS80) JDIMM2.226(VSS81) JDIMM2.227(VSS82) JDIMM2.230(VSS83) JDIMM2.231(VSS84) JDIMM2.234(VSS85) JDIMM2.235(VSS86) JDIMM2.238(VSS87) JDIMM2.239(VSS88) JDIMM2.243(VSS89) JDIMM2.244(VSS90) JDIMM2.247(VSS91) JDIMM2.248(VSS92) JDIMM2.251(VSS93) JDIMM2.252(VSS94) JDIMM2.261(GND2) JDIMM2.262(GND1) JEDP1.4 JEDP1.6 JEDP1.8 JEDP1.15 JEDP1.23 JEDP1.24 JEDP1.25 JEDP1.27 JEDP1.28 JEDP1.39 JEDP1.41(GND_1) JEDP1.42(GND_2) JEDP1.43(GND_3) JEDP1.44(GND_4) JEDP1.45(GND_5) JEDP1.46(GND_6) JEDP1.47(GND_7) JEDP1.48(GND_8) JEDP1.49(GND_9) JEDP1.50(GND_10) JEDP1.51(GND_11) JEDP1.52(GND_12) JEDP1.53(GND_13) JEDP1.54(GND_14) JEDP1.55(GND_15) JEDP1.56(GND_16) JEDP1.57(GND_17) JEDP1.58(GND_18) JEDP1.59(GND_19) JEDP1.60(GND_20) JEDP1.61(GND_21) JEDP1.62(GND_22) JEDP1.63(GND_23) JEDP1.64(GND_24) JEDP1.65(GND_25) JEDP1.66(GND_26) JEDP1.67(GND_27) JEDP1.68(GND_28) JEDP1.69(GND_29) JEDP1.70(GND_30) JEDP1.71(GND_31) JEDP1.72(GND_32) JEDP1.73(GND_33) JEDP1.74(GND_34) JESPI.9 JESPI.11(GND1) JESPI.12(GND2) JFAN1.1 JFAN1.5(GND1) JFAN1.6(GND2) JFPBTN1.2 JFPBTN1.8 JHDMI1.2(D2_SHIELD) JHDMI1.5(D1_SHIELD) JHDMI1.8(D0_SHIELD) JHDMI1.11(CK_SHIELD) JHDMI1.17(DDC/CEC_GND) JHDMI1.20(GND4) JHDMI1.21(GND3) JHDMI1.22(GND2) JHDMI1.23(GND1) JIRTS1.6 JIRTS1.7 JIRTS1.19(G1) JIRTS1.20(G2) JKBTP1.2 JKBTP1.3 JKBTP1.9 JKBTP1.15 JKBTP1.17 JKBTP1.20 JKBTP1.21(GND1) JKBTP1.22(GND2) JLED1.1 JLED1.5(GND1) JLED1.6(GND2) JNGFF1.1(GND_1) JNGFF1.7(GND_2) JNGFF1.13(SDO_DAT0) JNGFF1.18(GND_3) JNGFF1.19(SDO_DAT3) JNGFF1.33(GND_4) JNGFF1.39(GND_5) JNGFF1.45(GND_6) JNGFF1.51(GND_7) JNGFF1.57(GND_8) JNGFF1.63(GND_9) JNGFF1.69(GND_10) JNGFF1.75(GND_11) JNGFF1.76(GND_12) JNGFF1.77(GND_13) JNGFF2.3(GND_1) JNGFF2.5(GND_2) JNGFF2.11(GND_3) JNGFF2.27(GND_4) JNGFF2.33(GND_5) JNGFF2.39(GND_6) JNGFF2.45(GND_7) JNGFF2.51(GND_8) JNGFF2.57(GND_9) JNGFF2.71(GND_10) JNGFF2.73(GND_11) JNGFF2.76(GND_12) JNGFF2.77(GND_13) JNGFF3.1(GND_1) JNGFF3.3(GND_2) JNGFF3.9(GND_3) JNGFF3.15(GND_4) JNGFF3.21(GND5) JNGFF3.27(GND6) JNGFF3.33(GND7) JNGFF3.39(GND8) JNGFF3.45(GND9) JNGFF3.51(GND10) JNGFF3.57(GND11) JNGFF3.71(GND_12) JNGFF3.73(GND_13) JNGFF3.75(GND_14) JNGFF3.76(GND_15) JNGFF3.77(GND_16) JRTC1.2 JRTC1.3(G1) JRTC1.4(G2) JSD1.6(VSS1) JSD1.10(GND1) JSD1.11(GND2) JSD1.12(GND3) JSD1.13(GND4) JSD1.14(GND5) JSD1.17(VSS2) JSD1.20(VSS3) JSD1.23(VSS4) JSIM1.3(GND1) JSIM1.4(GND2) JSIM1.5(GND3) JSIM1.6(GND4) JSIM1.7(GND5) JSIM1.8(GND6) JSIM1.9(GND7) JSIM1.C5(GND) JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21(GND1) JSPI1.22(GND2) JSPK1.1 JSPK1.9(GND1) JSPK1.10(GND2) JTAG1.2 JUSB1.4(GND5) JUSB1.7(GND6) JUSB1.10(GND1) JUSB1.11(GND2) JUSB1.12(GND3) JUSB1.13(GND4) JUSB2.4(GND5) JUSB2.7(GND6) JUSB2.10(GND1) JUSB2.11(GND2) JUSB2.12(GND3) JUSB2.13(GND4) JUSBC1.1(GND_5) JUSBC1.2(GND_6) JUSBC1.3(GND_7) JUSBC1.4(GND_8) JUSBC1.5(GND_9) JUSBC1.6(GND_10) JUSBC1.A1(GND_1) JUSBC1.A12(GND_2) JUSBC1.B1(GND_3) JUSBC1.B12(GND_4) JUSH1.3 JUSH1.17 JUSH1.20 JUSH1.21 JUSH1.27(GND1) JUSH1.28(GND2) JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP1.61 JXDP1.62(GND#62) JXDP1.63(GND#63) PBATT1.7 PBATT1.8 PBATT1.9 PBATT1.10 PC1.2 PC2.2 PC3.2 PC5.2 PC7.2 PC8.2 PC10.2 PC11.2 PC12.2 PC13.1 PC100.2 PC101.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.1 PC112.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC128.2 PC129.2 PC130.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PC141.2 PC142.2 PC161.2 PC162.2 PC163.2 PC164.2 PC200.2 PC201.2 PC202.2 PC203.2 PC204.2 PC206.2 PC207.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC216.2 PC217.2 PC218.2 PC219.2 PC221.2 PC222.2 PC223.2 PC224.2 PC225.2 PC226.2 PC227.2 PC228.2 PC230.2 PC231.2 PC301.2 PC302.2 PC303.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.1 PC313.2 PC314.1 PC315.2 PC316.2 PC317.2 PC318.2 PC350.2 PC360.2 PC401.2 PC402.2 PC403.2 PC404.2 PC405.2 PC406.2 PC407.2 PC408.2 PC409.2 PC411.2 PC412.2 PC413.2 PC414.2 PC415.2 PC416.2 PC417.2 PC418.2 PC419.2 PC424.2 PC425.2 PC426.2 PC427.2 PC428.2 PC501.2 PC504.2 PC505.2 PC506.2 PC513.2 PC514.2 PC516.2 PC517.2 PC530.1 PC601.2 PC602.2 PC603.2 PC604.2 PC605.1 PC606.2(G) PC607.2(G) PC608.2 PC609.2 PC610.2 PC612.2 PC613.1 PC614.1 PC616.1 PC618.1 PC619.1 PC621.1 PC622.2 PC625.1 PC628.2 PC629.1 PC631.2 PC636.1 PC641.2 PC643.2 PC644.2 PC645.2 PC647.2 PC649.2 PC651.1 PC652.2 PC654.1 PC656.2 PC657.2 PC658.2 PC659.2 PC660.2 PC661.2 PC662.2 PC664.2 PC665.2 PC666.2 PC667.2 PC668.2 PC669.2 PC670.2 PC672.2 PC673.2 PC674.2 PC675.2 PC676.2 PC677.2 PC678.2 PC682.2 PC683.2 PC684.2 PC685.2 PC686.2 PC687.2 PC688.2 PC689.2 PC690.2 PC691.2 PC692.2 PC697.2 PC700.2 PC701.2 PC702.2 PC703.2 PC704.2 PC705.2 PC706.2(G) PC707.2 PC708.2 PC709.2 PC710.2 PC715.2(G) PC720.2 PC721.2 PC722.2 PC723.2 PC725.2 PC726.2 PC728.2 PC729.2 PC730.2 PC731.2 PC732.2 PC733.2 PC734.2 PC735.2 PC736.2 PC737.1 PC738.2 PC739.1 PC741.2 PC742.2 PC743.2 PC744.2 PC745.2 PC746.2 PC747.2 PC748.2 PC749.2 PC750.2 PC751.2 PC753.2 PC754.1 PC755.2 PC756.2 PC757.2 PC758.2 PC759.2 PC760.2 PC761.2 PC800.2 PC801.1 PC804.2 PC805.2 PC806.2 PC807.2 PC808.2 PC809.2 PC810.2 PC811.2 PC812.2 PC813.2 PC814.1 PC865.2 PC906.2 PC1000.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2(G) PC1092.2(G) PC1093.2(G) PC1094.2(G) PC1095.2(G) PC1096.2 PC1097.2 PC1098.2 PC1099.2 PC1101.2 PC1102.2 PC1103.2 PC1104.2 PC1105.2 PC1106.2 PC1107.2 PC1108.2 PC1109.2 PC1110.2 PC1111.2 PC1112.2 PC1113.2 PC1114.2 PC1115.2 PC1116.2 PC1117.2 PC1118.2 PC1119.2 PC1120.2 PC1121.2 PC1122.2 PC1123.2 PC1131.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2(G) PC1143.2(G) PC1146.2 PC1147.2 PC1148.2 PC1149.2 PC1151.2 PC1152.2 PC1153.2 PC1154.2 PC1155.2 PC1156.2 PC1157.2 PC1158.2 PC1159.2 PC1160.2 PC1161.2 PC1166.2 PC1167.2 PC1168.2 PC1169.2 PC1180.2 PC1181.2 PC3001.1 PC3002.2 PC3003.1 PC3004.1 PC3005.2 PC3008.2 PC3009.2 PC3010.2 PC3011.2 PD1.1 PD2.1 PD4.1 PD701.2 PD901.1 PD902.1 PH601.1 PH603.1 PJP19.2 PJPDC1.4 PJPDC1.5 PJPDC1.6(GND1) PJPDC1.7(GND2) PQ1.1(S1) PQ1.4(S2) PQ3.3(EMITTER) PQ6.3(S) PQ7.3(S) PQ10.1(S1) PQ10.4(S2) PQ12.3(S) PQ13.3(S) PQ614.5(S2_1) PQ614.6(S2_2) PQ614.7(S2_3) PQ700.10(S2) PQ701.10(S2) PQ703.3(S) PQ802.1(S1) PQ802.4(S2) PQ804.1(S1) PQ804.4(S2) PQ806.1(S1) PQ806.4(S2) PQ808.1(S) PQ808.4(S) PQ809.1(S) PQ809.4(S) PQ811.1(S) PQ811.4(S) PQ812.3(S) PQ813.1(S1) PQ813.4(S2) PQ814.3(S) PQ3000.1(S1) PQ3000.4(S2) PR8.2 PR9.2 PR13.2 PR14.2 PR24.2 PR45.2 PR103.2 PR116.2 PR206.2 PR207.2 PR209.2 PR212.2 PR302.2 PR310.2 PR311.2 PR403.2 PR407.2 PR412.1 PR415.2 PR416.2 PR419.2 PR420.2 PR424.2 PR427.2 PR428.2 PR505.2 PR506.2 PR514.2 PR516.2 PR608.2 PR611.2 PR613.1 PR629.1 PR631.1 PR647.1 PR651.2 PR653.1 PR658.1 PR693.1 PR706.2 PR709.1 PR716.2 PR720.2 PR723.2 PR725.2 PR739.2 PR744.2 PR815.2 PR817.2 PR819.2 PR823.2 PR842.2 PR843.2 PR846.2 PR855.2 PR862.2 PR3003.1 PR3005.1 PR3008.1 PR3011.2 PU2.2(GND) PU3.3(G) PU100.7(GND1) PU100.8(GND2) PU100.18(GND4) PU100.21(GND3) PU102.7(GND1) PU102.8(GND2) PU102.18(GND4) PU102.21(GND3) PU200.4(VTTGND) PU200.9(PGND) PU200.15(SGND) PU301.7(GND1) PU301.8(GND2) PU301.18(GND3) PU301.21(PAD) PU401.6(AGND) PU401.15(PGND1) PU401.16(PGND2) PU401.17(TP) PU402.6(AGND) PU402.15(PGND1) PU402.16(PGND2) PU402.17(TP) PU501.2(GND) PU503.4(GND1) PU503.9(GND2) PU602.41(AGND) PU610.4(AGND1) PU610.10(PGND1) PU610.14(PGND2) PU610.18(AGND2) PU612.4(AGND1) PU612.10(PGND1) PU612.14(PGND2) PU612.18(AGND2) PU613.4(AGND1) PU613.10(PGND1) PU613.14(PGND2) PU613.18(AGND2) PU614.4(GND) PU614.9(TP) PU700.33(PAD) PU701.3(G) PU800.4(G) PU801.3(G) PU3000.4(VEE) QC4.1(S1) QC4.4(S2) QC6.3(S) QE2.1(S1) QE2.4(S2) QE12.3(S) QE17.3(S) QR1.3(S) QV2.3(S) QV4.3(S) QV7.3(S) QV19.3(EMITTER) QV21.3(EMITTER) QZ17.3(S) RA35.2 RA36.2 RA37.2 RA45.2 RA51.2 RA52.1 RC2.1 RC5.2 RC7.2 RC10.2 RC47.2 RC48.2 RC49.2 RC53.2 RC63.2 RC65.2 RC75.2 RC86.2 RC96.2 RC106.2 RC107.2 RC108.2 RC109.2 RC116.2 RC120.1 RC122.2 RC136.2 RC139.2 RC151.2 RC161.2 RC164.2 RC165.2 RC220.2 RC229.2 RC230.2 RC231.2 RC232.2 RC233.2 RC234.2 RC236.2 RC237.2 RC337.2 RC397.2 RC401.2 RC402.2 RC405.1 RC406.1 RC407.1 RC409.1 RC410.1 RC411.1 RC412.1 RC413.1 RC414.1 RC415.1 RC416.1 RC417.1 RC418.1 RC419.1 RC420.1 RC444.1 RC446.1 RC448.1 RC452.1 RC454.1 RC504.2 RC515.2 RC518.2 RC519.2 RC520.2 RC521.2 RC536.2 RC565.2 RC624.2 RC640.1 RC723.1 RC730.2 RC745.2 RC751.1 RC752.1 RC754.2 RC757.2 RC758.2 RC759.2 RC760.2 RC761.2 RC832.2 RC833.2 RC844.2 RC848.1 RC868.1 RD5.2 RD7.2 RD9.2 RD16.2 RD18.2 RD21.2 RD23.2 RD25.2 RD29.2 RD31.2 RE20.2 RE55.2 RE56.2 RE58.2 RE65.2 RE77.2 RE85.2 RE86.2 RE93.2 RE95.1 RE313.2 RE342.2 RE541.1 RE550.2 RE802.2 RE810.1 RE811.1 RE812.1 RI14.1 RR4.2 RT21.2 RT22.2 RT23.2 RT24.2 RT25.2 RT26.2 RT27.2 RT28.2 RT29.2 RT31.2 RT32.2 RT33.2 RT34.2 RT35.1 RT36.2 RT37.2 RT38.2 RT41.2 RT42.1 RT63.2 RT64.2 RT65.2 RT71.1 RT81.2 RT82.2 RT86.2 RT96.2 RT99.1 RT100.2 RT101.2 RT103.1 RT128.2 RT129.2 RT219.2 RT220.2 RT221.2 RT222.2 RT377.2 RT393.2 RT440.1 RT447.1 RT488.2 RT489.2 RT490.2 RT491.2 RT494.1 RT497.2 RV1.2 RV2.2 RV3.2 RV21.2 RV102.2 RV319.1 RV624.2 RV626.2 RV629.2 RZ10.1 RZ25.2 RZ38.1 RZ40.1 RZ334.2 RZ752.2 RZ1450.2 RZ1460.1 RZ1461.1 RZ1472.1 SHDCAN.1(P1) SW1.4(G1) SW1.5(G2) SW3.1 SW3.2(3) UA1.49(G) UC1.A3(VSS_32) UC1.A4(VSS_13) UC1.A32(VSS_30) UC1.A36(VSS_35) UC1.AB3(VSS_41) UC1.AB4(VSS_52) UC1.AB7(VSS_55) UC1.AB27(VSS_38) UC1.AB30(VSS_43) UC1.AB33(VSS_46) UC1.AB36(VSS_49) UC1.AC5(VSS_431) UC1.AC10(VSS_58) UC1.AC27(VSS_61) UC1.AC30(VSS_64) UC1.AD33(VSS_69) UC1.AD35(VSS_72) UC1.AE7(VSS_83) UC1.AE24(VSS_14) UC1.AE25(VSS_74) UC1.AE26(VSS_15) UC1.AE27(VSS_77) UC1.AE30(VSS_80) UC1.AF3(VSS_89) UC1.AF4(VSS_97) UC1.AF7(VSS_99) UC1.AF25(VSS_16) UC1.AF27(VSS_86) UC1.AF30(VSS_92) UC1.AF33(VSS_94) UC1.AF36(VSS_96) UC1.AG5(VSS_432) UC1.AG10(VSS_102) UC1.AG24(VSS_17) UC1.AG26(VSS_18) UC1.AH24(VSS_19) UC1.AH25(VSS_20) UC1.AH27(VSS_107) UC1.AH28(VSS_110) UC1.AH29(VSS_113) UC1.AH30(VSS_116) UC1.AH31(VSS_118) UC1.AH33(VSS_121) UC1.AH35(VSS_123) UC1.AJ7(VSS_130) UC1.AJ25(VSS_125) UC1.AJ28(VSS_127) UC1.AK3(VSS_132) UC1.AK4(VSS_139) UC1.AK33(VSS_134) UC1.AK36(VSS_136) UC1.AL7(VSS_150) UC1.AL28(VSS_141) UC1.AL29(VSS_144) UC1.AL32(VSS_147) UC1.AM5(VSS_429) UC1.AM10(VSS_152) UC1.AM28(VSS_155) UC1.AM33(VSS_157) UC1.AM35(VSS_160) UC1.AN7(VSS_178) UC1.AN8(VSS_181) UC1.AN25(VSS_165) UC1.AN28(VSS_168) UC1.AN29(VSS_171) UC1.AN30(VSS_173) UC1.AN31(VSS_175) UC1.AP3(VSS_186) UC1.AP4(VSS_194) UC1.AP33(VSS_189) UC1.AP36(VSS_192) UC1.AR4(VSS_417) UC1.AR28(VSS_196) UC1.AT4(VSS_207) UC1.AT33(VSS_199) UC1.AT35(VSS_202) UC1.AT36(VSS_204) UC1.AU4(VSS_418) UC1.AU10(VSS_209) UC1.AU28(VSS_212) UC1.AU29(VSS_215) UC1.AU32(VSS_219) UC1.AV3(VSS_228) UC1.AV4(VSS_236) UC1.AV6(VSS_239) UC1.AV8(VSS_242) UC1.AV25(VSS_222) UC1.AV28(VSS_225) UC1.AV33(VSS_231) UC1.AV36(VSS_233) UC1.AW1(VSS_7) UC1.AW3(VSS_251) UC1.AW4(VSS_419) UC1.AW28(VSS_245) UC1.AW29(VSS_248) UC1.AW30(VSS_254) UC1.AW31(VSS_257) UC1.AY4(VSS_10) UC1.AY33(VSS_260) UC1.AY35(VSS_263) UC1.B2(VSS_21) UC1.B5(VSS_294) UC1.B7(VSS_297) UC1.B9(VSS_300) UC1.B12(VSS_265) UC1.B15(VSS_267) UC1.B18(VSS_270) UC1.B21(VSS_273) UC1.B23(VSS_275) UC1.B25(VSS_277) UC1.B27(VSS_280) UC1.B29(VSS_283) UC1.B31(VSS_286) UC1.B34(VSS_11) UC1.B36(VSS_22) UC1.B37(VSS_291) UC1.BA3(VSS_308) UC1.BA4(VSS_424) UC1.BA6(VSS_420) UC1.BA10(VSS_303) UC1.BA28(VSS_306) UC1.BB3(VSS_311) UC1.BB4(VSS_320) UC1.BB33(VSS_314) UC1.BB36(VSS_317) UC1.BC4(VSS_421) UC1.BC8(VSS_337) UC1.BC25(VSS_323) UC1.BC29(VSS_328) UC1.BC32(VSS_332) UC1.BD4(VSS_425) UC1.BD6(VSS_9) UC1.BD7(VSS_416) UC1.BD28(VSS_340) UC1.BD33(VSS_343) UC1.BD35(VSS_346) UC1.BD36(VSS_349) UC1.BE3(VSS_361) UC1.BE4(VSS_422) UC1.BE8(VSS_423) UC1.BE10(VSS_352) UC1.BE28(VSS_355) UC1.BE29(VSS_358) UC1.BE30(VSS_364) UC1.BE31(VSS_367) UC1.BF3(VSS_372) UC1.BF4(VSS_379) UC1.BF33(VSS_375) UC1.BF36(VSS_377) UC1.BG4(VSS_426) UC1.BG25(VSS_382) UC1.BG28(VSS_384) UC1.BH28(VSS_389) UC1.BH29(VSS_392) UC1.BH32(VSS_394) UC1.BH33(VSS_396) UC1.BH35(VSS_398) UC1.BJ7(VSS_33) UC1.BK2(VSS_39) UC1.BK3(VSS_44) UC1.BK4(VSS_50) UC1.BK7(VSS_53) UC1.BK10(VSS_36) UC1.BK28(VSS_42) UC1.BK33(VSS_47) UC1.BL7(VSS_73) UC1.BL25(VSS_56) UC1.BL28(VSS_59) UC1.BL29(VSS_62) UC1.BL30(VSS_65) UC1.BL31(VSS_67) UC1.BL32(VSS_70) UC1.BM9(VSS_84) UC1.BM33(VSS_75) UC1.BM35(VSS_78) UC1.BM36(VSS_81) UC1.BN7(VSS_90) UC1.BN30(VSS_87) UC1.BP3(VSS_103) UC1.BP4(VSS_111) UC1.BP7(VSS_114) UC1.BP12(VSS_411) UC1.BP15(VSS_95) UC1.BP19(VSS_400) UC1.BP25(VSS_100) UC1.BP32(VSS_105) UC1.BP33(VSS_108) UC1.BR16(VSS_401) UC1.BR19(VSS_119) UC1.BR22(VSS_407) UC1.BR25(VSS_122) UC1.BT5(VSS_2) UC1.BT14(VSS_410) UC1.BT15(VSS_126) UC1.BT16(VSS_128) UC1.BT25(VSS_137) UC1.BT28(VSS_140) UC1.BT33(VSS_142) UC1.BT35(VSS_145) UC1.BT36(VSS_148) UC1.BU7(VSS_166) UC1.BU11(VSS_153) UC1.BU16(VSS_405) UC1.BU20(VSS_408) UC1.BU23(VSS_158) UC1.BU24(VSS_161) UC1.BU25(VSS_163) UC1.BV3(VSS_176) UC1.BV4(VSS_184) UC1.BV11(VSS_169) UC1.BV31(VSS_179) UC1.BV33(VSS_182) UC1.BW7(VSS_205) UC1.BW11(VSS_187) UC1.BW15(VSS_190) UC1.BW24(VSS_200) UC1.BY5(VSS_3) UC1.BY11(VSS_208) UC1.BY15(VSS_210) UC1.BY18(VSS_402) UC1.BY19(VSS_403) UC1.BY22(VSS_213) UC1.BY25(VSS_217) UC1.BY28(VSS_220) UC1.BY33(VSS_223) UC1.BY35(VSS_226) UC1.BY36(VSS_229) UC1.C1(VSS_234) UC1.C4(VSS_249) UC1.C9(VSS_252) UC1.C21(VSS_237) UC1.C25(VSS_240) UC1.C29(VSS_243) UC1.C33(VSS_246) UC1.C36(VSS_23) UC1.C37(VSS_24) UC1.CA11(VSS_255) UC1.CA15(VSS_258) UC1.CA22(VSS_261) UC1.CA25(VSS_268) UC1.CB2(VSS_284) UC1.CB3(VSS_292) UC1.CB4(VSS_298) UC1.CB7(VSS_301) UC1.CB11(VSS_271) UC1.CB18(VSS_278) UC1.CB19(VSS_281) UC1.CB20(VSS_287) UC1.CB24(VSS_412) UC1.CB25(VSS_289) UC1.CB33(VSS_295) UC1.CC7(VSS_321) UC1.CC11(VSS_304) UC1.CC14(VSS_406) UC1.CC16(VSS_404) UC1.CC20(VSS_309) UC1.CC24(VSS_413) UC1.CC25(VSS_312) UC1.CC28(VSS_315) UC1.CC31(VSS_318) UC1.CD11(VSS_324) UC1.CD12(VSS_326) UC1.CD14(VSS_329) UC1.CD20(VSS_409) UC1.CD24(VSS_333) UC1.CD25(VSS_335) UC1.CE7(VSS_347) UC1.CE33(VSS_338) UC1.CE35(VSS_341) UC1.CE36(VSS_344) UC1.CF2(VSS_359) UC1.CF3(VSS_368) UC1.CF4(VSS_370) UC1.CF11(VSS_350) UC1.CF14(VSS_353) UC1.CF19(VSS_356) UC1.CF23(VSS_362) UC1.CF28(VSS_365) UC1.CG7(VSS_376) UC1.CG33(VSS_373) UC1.CH31(VSS_380) UC1.CJ2(VSS_427) UC1.CJ3(VSS_428) UC1.CJ4(VSS_37) UC1.CJ11(VSS_385) UC1.CJ14(VSS_387) UC1.CJ19(VSS_390) UC1.CJ23(VSS_393) UC1.CJ28(VSS_395) UC1.CJ33(VSS_397) UC1.CJ35(VSS_399) UC1.CJ36(VSS_34) UC1.CK1(VSS_40) UC1.CK4(VSS_45) UC1.CK7(VSS_48) UC1.CK37(VSS_6) UC1.CL2(VSS_51) UC1.CM1(VSS_8) UC1.CM4(VSS_430) UC1.CM5(VSS_76) UC1.CM9(VSS_79) UC1.CM13(VSS_54) UC1.CM17(VSS_57) UC1.CM21(VSS_60) UC1.CM25(VSS_63) UC1.CM29(VSS_66) UC1.CM31(VSS_68) UC1.CM33(VSS_71) UC1.CM37(VSS_5) UC1.CN1(VSS_25) UC1.CN2(VSS_26) UC1.CN5(VSS_98) UC1.CN9(VSS_101) UC1.CN13(VSS_82) UC1.CN17(VSS_85) UC1.CN21(VSS_88) UC1.CN25(VSS_91) UC1.CN29(VSS_93) UC1.CN37(VSS_27) UC1.CP1(VSS_104) UC1.CP2(VSS_28) UC1.CP9(VSS_129) UC1.CP11(VSS_106) UC1.CP13(VSS_109) UC1.CP15(VSS_112) UC1.CP19(VSS_115) UC1.CP21(VSS_117) UC1.CP27(VSS_120) UC1.CP35(VSS_4) UC1.CP37(VSS_124) UC1.CR2(VSS_131) UC1.CR6(VSS_433) UC1.CR34(VSS_1) UC1.CR36(VSS_133) UC1.D1(VSS_29) UC1.D5(VSS_143) UC1.D6(VSS_146) UC1.D8(VSS_149) UC1.D9(VSS_151) UC1.D21(VSS_135) UC1.D25(VSS_138) UC1.E9(VSS_167) UC1.E23(VSS_154) UC1.E27(VSS_156) UC1.E29(VSS_159) UC1.E31(VSS_162) UC1.E33(VSS_164) UC1.E35(VSS_12) UC1.F2(VSS_177) UC1.F3(VSS_185) UC1.F4(VSS_188) UC1.F12(VSS_170) UC1.F15(VSS_172) UC1.F18(VSS_174) UC1.F21(VSS_180) UC1.F24(VSS_183) UC1.F33(VSS_31) UC1.G9(VSS_201) UC1.G21(VSS_191) UC1.G27(VSS_193) UC1.G33(VSS_195) UC1.G35(VSS_197) UC1.G36(VSS_198) UC1.H9(VSS_211) UC1.H21(VSS_203) UC1.H27(VSS_206) UC1.J5(VSS_414) UC1.J6(VSS_232) UC1.J12(VSS_214) UC1.J15(VSS_216) UC1.J18(VSS_218) UC1.J21(VSS_221) UC1.J24(VSS_224) UC1.J33(VSS_227) UC1.J36(VSS_230) UC1.K3(VSS_256) UC1.K4(VSS_266) UC1.K9(VSS_269) UC1.K21(VSS_235) UC1.K22(VSS_238) UC1.K24(VSS_241) UC1.K25(VSS_244) UC1.K27(VSS_247) UC1.K28(VSS_250) UC1.K29(VSS_253) UC1.K30(VSS_259) UC1.K31(VSS_262) UC1.K32(VSS_264) UC1.L6(VSS_282) UC1.L27(VSS_272) UC1.L33(VSS_274) UC1.L35(VSS_276) UC1.L36(VSS_279) UC1.N6(VSS_290) UC1.N25(VSS_285) UC1.N27(VSS_288) UC1.P3(VSS_296) UC1.P4(VSS_305) UC1.P7(VSS_307) UC1.P10(VSS_293) UC1.P33(VSS_299) UC1.P36(VSS_302) UC1.R27(VSS_310) UC1.R28(VSS_313) UC1.R29(VSS_316) UC1.R30(VSS_319) UC1.R31(VSS_322) UC1.T7(VSS_336) UC1.T27(VSS_325) UC1.T30(VSS_327) UC1.T33(VSS_330) UC1.T35(VSS_331) UC1.T36(VSS_334) UC1.U7(VSS_342) UC1.U24(VSS_415) UC1.U26(VSS_339) UC1.V3(VSS_351) UC1.V4(VSS_363) UC1.V26(VSS_345) UC1.V27(VSS_348) UC1.V30(VSS_354) UC1.V33(VSS_357) UC1.V36(VSS_360) UC1.W7(VSS_374) UC1.W10(VSS_366) UC1.W27(VSS_369) UC1.W30(VSS_371) UC1.Y7(VSS_391) UC1.Y26(VSS_378) UC1.Y27(VSS_381) UC1.Y30(VSS_383) UC1.Y33(VSS_386) UC1.Y35(VSS_388) UC5.4(VSS) UC5.9(THEMALPAD) UC6.4(GND) UC7.3(G) UC9.3(G) UD1.3(GND) UE1.A6(VSS1) UE1.A13(VSS2) UE1.C4(VSS_ANALOG) UE1.E6(VSS3) UE1.H4(VSS_ADC) UE3.3(G) UE4.3(GND) UE5.3(G) UI1.2(GND) UI3.14(GND) UI3.17(THERMAL PAD) UR1.33(E-PAD) UT1.A1(SVR_VSS_0) UT1.A6(VSS_ANA_0) UT1.A8(VSS_ANA_1) UT1.A10(VSS_ANA_2) UT1.A12(VSS_ANA_3) UT1.A14(VSS_ANA_4) UT1.A16(VSS_ANA_5) UT1.A18(VSS_ANA_6) UT1.A20(VSS_ANA_7) UT1.A22(VSS_ANA_8) UT1.AA22(VSS_ANA_97) UT1.AA23(VSS_ANA_98) UT1.AB1(VSS_27) UT1.AB2(MONDC_DPSRC) UT1.AB6(VSS_ANA_99) UT1.AB8(VSS_ANA_100) UT1.AB10(VSS_ANA_101) UT1.AB12(VSS_ANA_102) UT1.AB14(VSS_ANA_103) UT1.AB16(VSS_ANA_104) UT1.AB18(VSS_ANA_105) UT1.AB20(VSS_ANA_106) UT1.AB22(VSS_ANA_107) UT1.AC1(TEST_EDM) UT1.AC2(VSS_28) UT1.AC6(VSS_ANA_108) UT1.AC8(VSS_ANA_109) UT1.AC10(VSS_ANA_110) UT1.AC12(VSS_ANA_111) UT1.AC14(VSS_ANA_112) UT1.AC16(VSS_ANA_113) UT1.AC18(VSS_ANA_114) UT1.AC20(VSS_ANA_115) UT1.AC22(VSS_ANA_116) UT1.B1(SVR_VSS_1) UT1.B2(SVR_VSS_2) UT1.B6(VSS_ANA_9) UT1.B8(VSS_ANA_10) UT1.B10(VSS_ANA_11) UT1.B12(VSS_ANA_12) UT1.B14(VSS_ANA_13) UT1.B16(VSS_ANA_14) UT1.B18(VSS_ANA_15) UT1.B20(VSS_ANA_16) UT1.B22(VSS_ANA_17) UT1.C22(MONDC_CIO_1) UT1.C23(MONDC_CIO_0) UT1.D5(VSS_0) UT1.D6(MONDC_SVR) UT1.D8(VSS_ANA_18) UT1.D9(VSS_ANA_19) UT1.D11(VSS_ANA_20) UT1.D12(VSS_ANA_21) UT1.D13(VSS_ANA_22) UT1.D15(VSS_ANA_23) UT1.D16(VSS_ANA_24) UT1.D18(VSS_ANA_25) UT1.E4(VSS_1) UT1.E5(VSS_2) UT1.E6(VSS_3) UT1.E8(VSS_ANA_26) UT1.E9(VSS_ANA_27) UT1.E11(VSS_ANA_28) UT1.E15(VSS_ANA_29) UT1.E16(VSS_ANA_30) UT1.E22(VSS_ANA_31) UT1.E23(VSS_ANA_32) UT1.F5(VSS_4) UT1.F6(VSS_5) UT1.F9(VSS_ANA_33) UT1.F16(VSS_ANA_34) UT1.F20(VSS_ANA_35) UT1.G22(VSS_ANA_36) UT1.G23(VSS_ANA_37) UT1.H1(VSS_ANA_38) UT1.H2(VSS_ANA_39) UT1.H5(VSS_6) UT1.H8(VSS_7) UT1.H12(VSS_ANA_40) UT1.H13(VSS_ANA_41) UT1.H15(VSS_ANA_42) UT1.H16(VSS_ANA_43) UT1.H20(VSS_ANA_44) UT1.J5(VSS_ANA_45) UT1.J8(VSS_8) UT1.J12(VSS_9) UT1.J13(VSS_10) UT1.J15(VSS_11) UT1.J18(VSS_ANA_46) UT1.J19(VSS_ANA_47) UT1.J20(VSS_ANA_48) UT1.J22(VSS_ANA_49) UT1.J23(VSS_ANA_50) UT1.K1(VSS_ANA_51) UT1.K2(VSS_ANA_52) UT1.L5(VSS_ANA_53) UT1.L13(VSS_12) UT1.L15(FUSE_VQPS_64) UT1.L20(VSS_ANA_54) UT1.L22(VSS_ANA_55) UT1.L23(VSS_ANA_56) UT1.M1(VSS_ANA_57) UT1.M2(VSS_ANA_58) UT1.M5(VSS_ANA_59) UT1.M11(VSS_13) UT1.M12(VSS_14) UT1.M19(VSS_ANA_60) UT1.M20(VSS_ANA_61) UT1.N5(VSS_ANA_62) UT1.N8(VSS_15) UT1.N9(VSS_16) UT1.N11(VSS_17) UT1.N12(VSS_18) UT1.N13(VSS_19) UT1.N15(FUSE_VQPS_128) UT1.N20(VSS_ANA_63) UT1.N22(VSS_ANA_64) UT1.N23(VSS_ANA_65) UT1.P1(VSS_ANA_66) UT1.P2(VSS_ANA_67) UT1.R5(VSS_ANA_68) UT1.R18(VSS_ANA_69) UT1.R19(VSS_ANA_70) UT1.R20(VSS_ANA_71) UT1.R22(VSS_ANA_72) UT1.R23(VSS_ANA_73) UT1.T1(VSS_ANA_74) UT1.T2(VSS_ANA_75) UT1.T5(VSS_ANA_76) UT1.T6(VSS_20) UT1.T8(VSS_21) UT1.T9(VSS_22) UT1.T13(VSS_23) UT1.T15(VSS_24) UT1.T16(VSS_25) UT1.T18(VSS_26) UT1.T20(VSS_ANA_77) UT1.U22(VSS_ANA_78) UT1.U23(VSS_ANA_79) UT1.V5(VSS_ANA_80) UT1.V6(VSS_ANA_81) UT1.V8(VSS_ANA_82) UT1.V9(VSS_ANA_83) UT1.V15(VSS_ANA_84) UT1.V16(VSS_ANA_85) UT1.V20(VSS_ANA_86) UT1.W5(VSS_ANA_87) UT1.W6(VSS_ANA_88) UT1.W8(VSS_ANA_89) UT1.W9(VSS_ANA_90) UT1.W13(MONDC_DPSNK_0) UT1.W18(MONDC_DPSNK_1) UT1.W20(VSS_ANA_91) UT1.W22(VSS_ANA_92) UT1.W23(VSS_ANA_93) UT1.Y9(VSS_ANA_94) UT1.Y13(VSS_ANA_95) UT1.Y20(VSS_ANA_96) UT2.4(GND) UT5.A1(GND_5) UT5.A6(GND_1) UT5.A7(GND_2) UT5.A8(GND_3) UT5.B7(GND_4) UT5.B8(GND_13) UT5.D8(GND_14) UT5.E5(GND_6) UT5.E6(GND_7) UT5.E7(GND_8) UT5.E8(GND_15) UT5.F5(GND_9) UT5.F6(GND_16) UT5.F7(GND_17) UT5.F8(GND_18) UT5.G5(GND_10) UT5.G6(GND_19) UT5.G7(GND_20) UT5.G8(GND_21) UT5.H4(GND_11) UT5.H5(GND_12) UT5.H8(GND_22) UT5.L1(GND_23) UT6.4(GND) UT7.2(GND) UT8.2(GND) UT32.2(GND) UT34.3(G) UV2.2(GND) UV24.2(GND) UZ1.1(GND) UZ3.11(GND) UZ3.15(GPAD) UZ5.11(GND) UZ5.15(GPAD) UZ6.3(G) UZ8.5(GND1) UZ8.9(GND2) UZ10.3(G) UZ12.2(GND0) UZ12.9(NC_6) UZ12.16(NIC_13) UZ12.23(NIC_14) UZ12.32(NIC_22) UZ12.33(THPAD) UZ19.5(GND) UZ21.5(GND) UZ27.5(GND) UZ29.2(OEN) UZ29.5(GND1) UZ29.11(GND2) UZ29.20(GND3) UZ29.21(PGND) UZ35.3(G) UZ43.11(GND) UZ43.15(GPAD) UZ47.11(GND) UZ47.15(GPAD) UZ53.5(GND1) UZ53.9(GND2) UZ54.3(G) WC1.9 WC1.10 YC1.2(GND2) YC1.4(GND4) YT1.2(GND1) YT1.4(GND2)
GNDA: CA1.1 CA2.1 CA3.1 CA4.2 CA8.2 CA9.2 CA25.2 CA35.2 CA41.2 CA51.2 CA52.2 CA57.2 CA58.2 CA73.2 CA74.2 DA2.3 JHP1.5(#5) JHP1.7(GND) PJP19.1 RA35.1 RA36.1 RA37.1 RA44.2 UA1.22(AVSS2) UA1.37(AVSS1)
VBAT1_CHG: PC755.1 PR738.1 PU700.31(VBAT)
VBUS1_ECOK: RE602.2 UE1.N3(GPIO021/LPCPD#)
VBUS1_ECOK_R: PR20.2 PR24.1 PR826.1 PR861.2 RE602.1
VBUS2_ECOK: RE603.1 UE1.M6(GPIO016/GPTP-IN7/SHD_IO3/ICT3)
VBUS2_ECOK_R: PR49.2 PR816.1 PR819.1 PR827.1 RE603.2
VBUSSENSE: RC49.1 UC1.CC6(USB2_VBUSSENSE)
VCC1_IA: PC676.1 PR688.2 PU610.3(VCC)
VCC2_IA: PC677.1 PR691.2 PU613.3(VCC)
VCC_1.05VALWP: PC313.1 PU301.16(NC3) PU301.17(VCC)
VCC_CPU_CORE: PC603.1 PR602.1 PU602.34(VCC)
VCC_DDR: PC207.1 PU200.14(VCC)
VCC_GT: PC669.1 PR680.2 PU612.3(VCC)
VCC_SENSE_GT: PC639.1 PC651.2 PC653.1 PR648.1 RC160.2 RC632.2
VCC_SENSE_IA: PC617.1 PC618.2 PC620.1 PR622.1 RC150.2 RC430.2
VCC_SENSE_SA: PC640.2 PC650.2 PC652.1 PR649.2 RC166.2 RC426.2
VCCDSW_EN: CE66.1 RC445.1 UE1.M7(GPIO012/SMB07_DATA/TOUT3)
VCCDSW_EN_GPIO: DC1.2 QC6.2(G) RC431.1 RC445.2
VCCDSW_EN_Q: DC1.1 DC2.2 RC442.1
VCCEOPIO_SENSE: T368.1 UC1.V25(RSVD46)
VCCGT_SENSE_R: RC632.1 UC1.E3(VCCGT_SENSE)
VCCHDA: CC95.2 LC4.2 UC1.BT20(VCCHDA)
VCCIO_SENSE: PR422.2 RC163.2 UC1.BP28(VCCIO_SENSE)
VCCPLL_EN: RZ120.2 RZ1418.2 RZ1419.2 UZ27.4(ON)
VCCSENSE_R: RC430.1 UC1.AN6(VCC_SENSE)
VCCST_EN: RZ1416.2 RZ1417.2 RZ1423.2 UZ21.4(ON)
VCCST_PWRGD: CC301.1 RC71.1 RC78.1 RC123.1 UE4.4(Y)
VCCST_PWRGD_CPU: RC78.2 UC1.BJ2(VCCST_PWRGOOD)
VCCSTG_EN: RZ120.1 RZ320.2 UZ19.4(ON) UZ35.4(O)
VDD_CHG: PC739.2 PR707.2 PR710.2 PR712.1 PU700.18(VDD)
VDDP_CHG: PC738.1 PR707.1 PU700.8(VDDP)
VIN_1.8VALW: PC530.2 PJP501.2 PL502.2 PU501.4(IN)
VIN_1V_PRIM_CORE: PC412.1 PC413.1 PC414.1 PC416.1 PC417.1 PC418.1 PJP404.2 PL406.2 PU402.10(AVIN) PU402.11(PVIN1) PU402.12(PVIN2)
VIN_1VS_VCCIO: PC403.1 PC404.1 PC405.1 PC408.1 PC409.1 PJP403.2 PL405.2 PU401.10(AVIN) PU401.11(PVIN1) PU401.12(PVIN2)
VIN_2.5V_MEM: PC514.1 PC517.1 PJP505.2 PU503.8(IN)
VIN_CPU_CORE: PC604.1 PR603.1 PU602.33(VIN)
VSS_SENSE_GT: PC653.2 PC654.2 PU602.18(RTN_A) RC161.1 RC631.2
VSS_SENSE_IA: PC619.2 PC620.2 PU602.6(RTN_B) RC151.1 RC429.2
VSS_SENSE_SA: PC649.1 PC650.1 PU602.26(RTN_C) RC164.1 RC425.2
VSSEOPIO_SENSE: T369.1 UC1.T25(RSVD47)
VSSGT_SENSE_R: RC631.1 UC1.D2(VSSGT_SENSE)
VSSIO_SENSE: PR412.2 RC165.1 UC1.BP29(VSSIO_SENSE)
VSSSENSE_R: RC429.1 UC1.AN5(VSS_SENSE)
2.7MM_CAM_DET#: JEDP1.5 RV734.1 UC1.BY31(GPP_A16/SD_1P8_SEL)
3MM_CAM_DET#: JIRTS1.8 RV325.1 UC1.CR12(GPP_C20/UART2_RXD)
32KHZ_OUT: CE54.1 UE1.F3(GPIO221/GPTP-IN3/32KHZ_OUT)
+BL_PWR_SRC: CV11.1 CV24.1 CV25.1 CV634.1 CV753.1 CV758.1 DV11.2 FV1.2 JEDP1.17 JEDP1.18 JEDP1.19
+BL_PWR_SRC_P: CV15.1 FV1.1 QV1.1(D1) QV1.2(D2) QV1.5(D3) QV1.6(D4)
+COINCELL: JRTC1.1 PR2.1
+DDR_VREF_A_CA: CD25.1 CD26.1 JDIMM1.164(VREFCA) RD15.2 RD16.1 RD17.1
+DDR_VREF_B_CA: CD57.1 CD58.1 JDIMM2.164(VREFCA) RD28.2 RD29.1 RD30.1
+DDR_VREF_B_DQ: CD62.1 RD30.2 UC1.E36(DDR1_VREF_DQ)
+DDR_VREF_CA: CD31.1 RD17.2 UC1.F36(DDR_VREF_CA)
+EC_DEBUG_VCC: JDEG1.1 RE71.2
+EDP_VDD: PJP12.2 RV101.2 UV24.1(OUT)
+LCDVDD: CV12.1 CV16.1 CV20.1 CV21.1 CV652.1 CV751.1 CV752.1 CV757.1 DV12.2 JEDP1.30 JEDP1.31 PJP12.1 RV7.2 RV101.1 RV623.1
+MIC2-VREFO-L: RA5.1 UA1.28(MIC2-VREFO-L)
+MIC2-VREFO-R: RA6.1 UA1.29(MIC2-VREFO-R)
+PECI_VREF: CE25.1 RE59.2 UE1.J11(GPIO044/VREF_VTT)
+RREF: RR4.1 UR1.9(RREF)
+RTC_CELL: PC3.1 PD3.1 QE15.3(S) RA54.2 RE31.1 RE32.1 RE507.2 RE508.2 RE551.2 RE822.2
+RTC_CELL_PCH: CC72.1 CC73.1 CE63.1 QE15.1(D) RC56.2 RC57.2 RC69.2 RE546.1 RE551.1 UC1.BR23(VCCRTC)
+RTC_CELL_VBAT: CE11.1 RE32.2 UE1.A2(VBAT)
+SDREG2: CR15.1 UR1.24(SDREG2)
+SIM_PWR: CZ37.1 CZ41.1 JNGFF2.36(UIM-PWR) JSIM1.C1(VCC) RZ335.1
+TBT_SVR_IND: LT1.1 UT1.C1(SVR_IND_0) UT1.C2(SVR_IND_1) UT1.D1(SVR_IND_2)
+TBTA_LDO_BMC: CT71.1 UT5.E1(LDO_BMC)
+TS_PWR: CV18.1 CV19.1 CV754.1 CZ2.1 FV2.1 JEDP1.1
+TS_PWR_QV8: FV2.2 QV8.1(D)
+USB_EX2_PWR: CI1.1 CI3.1 CI45.1 CI46.1 CI103.1 JUSB2.1(VBUS) UI1.1(OUT)
+UZ12_TPM: CZ50.1 CZ75.1 RZ89.2 UZ12.8(NIC_5)
+VHDMI_VCC: CV40.1 CV41.1 JHDMI1.18(+5V) RV22.2 RV23.2 UV2.3(OUT)
+VR_CAP: CE31.1 UE1.C10(VIN) UE1.J1(VR_CAP)
+Z4012: PD3.2 PQ13.2(G) PR2.2 PR9.1
AC_DIS: PQ703.2(G) PR720.1 RE83.1 UE1.H12(GPIO134/PWM10/UART1_RTS#)
AC_DISC#: PC810.1 PQ810.3(D) PQ810.6(D) PQ811.6(D) PR828.2 PR829.1 UE1.E13(GPIO124/GPTP-OUT6/PVT_CS#)
AC_PRESENT: RC555.1 UC1.BU35(GPD1/ACPRESENT) UE1.K8(GPIO233)
ACAV_IN: CE67.1 DZ12.1 PR740.2 PR744.1 PR3010.2 UE1.C7(GPIO164/VCI_OVRD_IN)
ACAV_IN1: PQ703.1(D) PR710.1 PR716.1 PR722.1 PR741.1 PR3009.2
ACIN_CHG: PC736.1 PR705.2 PR706.1 PR3001.2 PU700.19(ACIN)
ACOK_CHG: PR722.2 PU700.24(ACOK)
ADJ_2.5V_MEM: PC515.2 PR515.2 PR516.1 PU503.3(ADJ/NC)
ADP_CHG: PR703.2 PU700.16(ADP)
ALW_PWRGD_3V_5V: DC2.1 PR119.2 PR120.2 UZ6.2(A)
ALWON: PR114.1 UE1.A5(VCI_OUT)
AMON/BMON_CHG: PC750.1 PR729.1 PR743.1 PU700.29(AMON/BMON)
AR_DP1_CTRL_CLK: QV3.1(S2) RT13.1 UT1.Y2(GPIO_7)
AR_DP1_CTRL_DATA: QV3.4(S1) RT12.1 UT1.Y1(GPIO_6)
AR_DP1_HPD: QV5.3(S) RV20.1 UT1.G1(DPSRC_HPD)
AR_DP1_N0: CT201.2 CV32.1 UT1.R1(DPSRC_ML0_N)
AR_DP1_N1: CT202.2 CV34.1 UT1.N1(DPSRC_ML1_N)
AR_DP1_N2: CT203.2 CV36.1 UT1.L1(DPSRC_ML2_N)
AR_DP1_N3: CT204.2 CV38.2 UT1.J1(DPSRC_ML3_N)
AR_DP1_P0: CT201.1 CV31.1 UT1.R2(DPSRC_ML0_P)
AR_DP1_P1: CT202.1 CV33.1 UT1.N2(DPSRC_ML1_P)
AR_DP1_P2: CT203.1 CV35.1 UT1.L2(DPSRC_ML2_P)
AR_DP1_P3: CT204.1 CV37.2 UT1.J2(DPSRC_ML3_P)
AUD_HP_NB_SENSE: DA2.2 JHP1.6(#6 AGND) RA60.2
AUD_HP_OUT_L: LA15.1 RA7.2
AUD_HP_OUT_L1: CA3.2 DA1.2 JHP1.1(#1 L/R) LA15.2
AUD_HP_OUT_R: LA16.1 RA8.2
AUD_HP_OUT_R1: CA2.2 DA1.3 JHP1.2(#2 R/L) LA16.2
AUD_PC_BEEP: CA27.2 CA28.2 UA1.34(PCBEEP)
AUD_PWR_EN: RC279.1 UC1.CK36(GPP_G6/SD_CLK) UZ5.3(ON1) UZ5.5(ON2)
AUD_SENSE_A: CA41.1 RA59.2 RA60.1 UA1.48(JD1)
AUD_SENSE_B: RA61.1 UA1.47(JD2)
AUX_EN_WOWL: DZ9.2 RZ70.1 RZ379.2 RZ1483.2 UE1.D3(GPIO210/ADC08)
BAT1_LED#: RZ28.1 UE1.D10(GPIO157/LED1)
BAT1_LED#_R: QZ3.2(B) QZ21.1(COLLECTOR)
BAT2_LED#: RZ361.1 UE1.D11(GPIO153/LED2)
BATGONE_CHG: PC744.1 PR723.1 PR724.2 PU700.25(BATGONE)
BATT_WHITE#: JLED1.2 RZ361.2
BATT_YELLOW#: JLED1.3 QZ3.3(E) RZ28.2
BC_CLK_ECE1117: CZ87.1 JKBTP1.10 UE1.D13(GPIO047/BCM1_CLK)
BC_DAT_ECE1117: CZ86.1 JKBTP1.8 RE365.1 UE1.D12(GPIO046/BCM1_DAT)
BC_INT#_ECE1117: CZ85.1 JKBTP1.7 UE1.E2(GPIO212/ADC10)
BCM5882_ALERT#: JUSH1.14 RE532.1 UE1.G10(GPIO135/UART1_CTS#)
BEEP: RA13.2 UE1.H11(GPIO035/PWM8/CTOUT1)
BEEP_R: CA28.1 CA62.1 RA13.1 RA45.1
BGATE_CHG: PC743.1 PQ702.4(G) PU700.32(BGATE)
BGPO0: T341.1 UE1.D6(BGPO0)
BIA_PWM: DV1.1 LV1.2 RV1.1
BIA_PWM_EC: DV1.2 UE1.N1(GPIO001/PWM4)
BL_PWR_MONITOR: QV19.2(BASE) RV625.2
BL_PWR_SRC_ON: CV13.1 CV14.1 QV1.3(G) RV4.1 RV5.1
BOARD_ID: CE40.1 RE79.2 UE1.J13(GPIO036/RC_ID2/SPI0_MISO)
BOOT1_CHG: PR704.2 PU700.12(BOOT1)
BOOT2_CHG: PC740.1 PU700.4(BOOT2)
BREATH_LED#: QZ7.1(S2) UE1.C11(GPIO156/LED0)
BREATH_LED#_Q: QZ7.6(D2) RZ32.1
BREATH_WHITE_LED_SNIFF#: LED3.1(CATHODE) RZ32.2
BS_DDR: PR203.1 PU200.12(BS)
BS_DDR_R: PC205.1 PR203.2
BSMB_WP_INT#: PD902.3 PR955.2 RE92.1 RE819.1
BSMB_WP_INT#_R: RE819.2 UE1.E12(GPIO126/PVT_IO3)
BST1_CHG_R: PC727.2 PR704.1
BST1_IA: PR660.2 PU610.5(BOOT)
BST1_IA_R: PC655.1 PR660.1
BST2_CHG_R: PC740.2 PR714.1
BST2_IA: PR672.2 PU613.5(BOOT)
BST2_IA_R: PC671.1 PR672.1
BST_1.05VALWP: PR304.1 PU301.1(BS)
BST_1.05VALWP_R: PC304.1 PR304.2
BST_3V: PR100.1 PU100.1(BS)
BST_3V_R: PC102.1 PR100.2
BST_5V: PR111.1 PU102.1(BS)
BST_5V_R: PC114.1 PR111.2
BST_GT: PR665.2 PU612.5(BOOT)
BST_GT_R: PC663.1 PR665.1
BST_SA: PC611.2 PU614.2(BOOT)
BST_SA_R: PC611.1 PR619.1
BT_RADIO_DIS#: DZ2.1 RE11.1 UE1.C2(GPIO166)
BT_RADIO_DIS#_R: DZ2.2 JNGFF1.54(W_DISABLE2#)
CAM_MIC_CBL_DET#: RC725.1 RZ1470.2 UC1.CH36(GPP_G0/SD_CMD)
CBN: CA29.2 CA76.2 UA1.24(CBN)
CBP: CA29.1 CA76.1 UA1.23(CBP)
CFG0: JXDP1.9 RC120.2 RC126.1 UC1.T4(CFG_0)
CFG1: JXDP1.11 RC405.2 UC1.R4(CFG_1)
CFG2: JXDP1.15 RC406.2 UC1.T3(CFG_2)
CFG3: JXDP1.17 RC121.2 RC407.2 UC1.R3(CFG_3)
CFG4: JXDP1.27 RC723.2 UC1.J4(CFG_4)
CFG5: JXDP1.29 RC409.2 UC1.M4(CFG_5)
CFG6: JXDP1.33 RC410.2 UC1.J3(CFG_6)
CFG7: JXDP1.35 RC411.2 UC1.M3(CFG_7)
CFG8: JXDP1.10 RC412.2 UC1.R2(CFG_8)
CFG9: JXDP1.12 RC413.2 UC1.N2(CFG_9)
CFG10: JXDP1.16 RC414.2 UC1.R1(CFG_10)
CFG11: JXDP1.18 RC415.2 UC1.N1(CFG_11)
CFG12: JXDP1.28 RC416.2 UC1.J2(CFG_12)
CFG13: JXDP1.30 RC417.2 UC1.L2(CFG_13)
CFG14: JXDP1.34 RC418.2 UC1.J1(CFG_14)
CFG15: JXDP1.36 RC419.2 UC1.L1(CFG_15)
CFG16: JXDP1.6 UC1.L3(CFG_16)
CFG17: JXDP1.4 UC1.L4(CFG_17)
CFG18: JXDP1.24 UC1.N3(CFG_18)
CFG19: JXDP1.22 UC1.N4(CFG_19)
CFG_RCOMP: RC624.1 UC1.AB5(CFG_RCOMP)
CLK_CNV_PRX_DTX_N: JNGFF1.21(SDIO_WAKE#) UC1.CN31(CNV_WR_CLKN)
CLK_CNV_PRX_DTX_P: JNGFF1.23(SDIO_RESET#) UC1.CP31(CNV_WR_CLKP)
CLK_CNV_PTX_DRX_N: JNGFF1.71(RSVD_7) UC1.CP34(CNV_WT_CLKN)
CLK_CNV_PTX_DRX_P: JNGFF1.73(RSVD_8) UC1.CN34(CNV_WT_CLKP)
CLK_ITPXDP_N: RC530.1 UC1.AU1(CLKOUT_ITPXDP_N)
CLK_ITPXDP_N_R: JXDP1.42 RC530.2
CLK_ITPXDP_P: RC298.1 UC1.AU2(CLKOUT_ITPXDP_P)
CLK_ITPXDP_P_R: JXDP1.40 RC298.2
CLK_PCIE_N0: JNGFF2.53(REFCLKN) UC1.AW2(CLKOUT_PCIE_N_0)
CLK_PCIE_N1: JNGFF1.49(REFCLKN0) UC1.BC1(CLKOUT_PCIE_N_1)
CLK_PCIE_N2: JNGFF3.53(REFCLKN) UC1.BD3(CLKOUT_PCIE_N_2)
CLK_PCIE_N4: UC1.BA1(CLKOUT_PCIE_N_4) UR1.6(REFCLKN)
CLK_PCIE_N5: UC1.BE1(CLKOUT_PCIE_N_5) UT1.T19(PCIE_REFCLK_100_IN_N)
CLK_PCIE_P0: JNGFF2.55(REFCLKP) UC1.AY3(CLKOUT_PCIE_P_0)
CLK_PCIE_P1: JNGFF1.47(REFCLKP0) UC1.BC2(CLKOUT_PCIE_P_1)
CLK_PCIE_P2: JNGFF3.55(REFCLKP) UC1.BC3(CLKOUT_PCIE_P_2)
CLK_PCIE_P4: UC1.BA2(CLKOUT_PCIE_P_4) UR1.5(REFCLKP)
CLK_PCIE_P5: UC1.BE2(CLKOUT_PCIE_P_5) UT1.V19(PCIE_REFCLK_100_IN_P)
CLK_TP_SIO_I2C_DAT: CZ81.1 RZ23.2 RZ346.2 UE1.E10(GPIO154/SMB02_DATA/PS2_CLK1B)
CLK_TP_SIO_R: CZ89.1 JKBTP1.14 RZ19.2 RZ23.1
CLKREQ_CNV#: RC752.2 RZ1385.1 UC1.CH29(GPP_H2/I2S2_TXD/CNV_BT_I2S_SDI/)
CLKREQ_CNV#_R: JNGFF1.14(PCM_OUT) RZ1385.2
CLKREQ_PCIE#0: JNGFF2.52(CLKREQ#) RC297.1
CLKREQ_PCIE#0_R: RC189.1 RC297.2 UC1.CF32(GPP_B5/SRCCLKREQ0#)
CLKREQ_PCIE#1: JNGFF1.53(CLKEQ0#) RC526.1
CLKREQ_PCIE#1_R: RC522.1 RC526.2 UC1.CE32(GPP_B6/SRCCLKREQ1#)
CLKREQ_PCIE#2: JNGFF3.52(CLKREQ#) RC727.1
CLKREQ_PCIE#2_R: RC525.1 RC727.2 UC1.CF30(GPP_B7/SRCCLKREQ2#)
CLKREQ_PCIE#3_R: RC523.1 UC1.CE31(GPP_B8/SRCCLKREQ3#)
CLKREQ_PCIE#4: RC528.1 UR1.2(CLK_REQ#)
CLKREQ_PCIE#4_R: RC51.1 RC528.2 UC1.CE30(GPP_B9/SRCCLKREQ4#)
CLKREQ_PCIE#5: RC529.1 UT1.AC5(PCIE_CLKREQ_N)
CLKREQ_PCIE#5_R: RC190.1 RC529.2 UC1.CF31(GPP_B10/SRCCLKREQ5#)
CMOUT: PQ811.2(G) PQ811.3(D) PQ812.2(G) PR727.1
CNV_BRI_PRX_DTX: RC724.1 RZ1381.2 UC1.CK20(GPP_F5/CNV_BRI_RSP)
CNV_BRI_PRX_DTX_R: JNGFF1.22(UART_RX) RZ1381.1
CNV_BRI_PTX_DRX: RC711.2 UC1.CJ20(GPP_F4/CNV_BRI_DT)
CNV_BRI_PTX_DRX_R: JNGFF1.36(UART_RTS) RC711.1 RZ603.1
CNV_COEX1: RZ373.2 UC1.CH17(GPP_F9/CNV_MFUART2_TXD)
CNV_COEX2: RZ372.2 UC1.CJ17(GPP_F8/CNV_MFUART2_RXD)
CNV_COEX3: RZ374.2 UC1.CP20(GPP_F0/CNV_PA_BLANKING)
CNV_DET#_EC: QZ17.1(D) RZ377.2 RZ827.2 UE1.L11(GPIO054/PWM1/GPWM1)
CNV_PRX_DTX_N0: JNGFF1.15(SDO_DAT1) UC1.CR30(CNV_WR_D0N)
CNV_PRX_DTX_N1: JNGFF1.9(SIDO_CLK) UC1.CM30(CNV_WR_D1N)
CNV_PRX_DTX_P0: JNGFF1.17(SDO_DAT2) UC1.CP30(CNV_WR_D0P)
CNV_PRX_DTX_P1: JNGFF1.11(SDIO_CMD) UC1.CN30(CNV_WR_D1P)
CNV_PTX_DRX_N0: JNGFF1.65(RSRVD_2/PERP1) UC1.CN32(CNV_WT_D0N)
CNV_PTX_DRX_N1: JNGFF1.59(RSRVD/PETP1) UC1.CP33(CNV_WT_D1N)
CNV_PTX_DRX_P0: JNGFF1.67(RSRVD_4/PERN1) UC1.CM32(CNV_WT_D0P)
CNV_PTX_DRX_P1: JNGFF1.61(RSRVD/PETN1) UC1.CN33(CNV_WT_D1P)
CNV_RF_RESET#: JNGFF1.10(PCM_SYNC) QZ17.2(G) RC640.2 UC1.CJ32(GPP_H1/I2S2_SFRM/CNV_BT_I2S_BCL)
CNV_RGI_PRX_DTX: RC733.1 RZ1383.2 UC1.CH19(GPP_F7/CNV_RGI_RSP)
CNV_RGI_PRX_DTX_R: JNGFF1.34(UART_CTS) RZ1383.1
CNV_RGI_PTX_DRX: RC710.2 UC1.CG19(GPP_F6/CNV_RGI_DT)
CNV_RGI_PTX_DRX_R: JNGFF1.32(UART_TX) RC710.1 RC832.1 RC842.1
CNV_WT_RCOMP: RC448.2 UC1.CP32(CNV_WT_RCOMP_0) UC1.CR32(CNV_WT_RCOMP_1)
CNVI_EN#: RC868.2 RZ827.1 UC1.CH30(GPP_H3/I2S2_RXD/CNV_BT_I2S_SDO)
COMP_A_GT: PC636.2 PR639.2 PU602.16(COMP_A)
COMP_B_IA: PC616.2 PR617.2 PU602.4(COMP_B)
COMP_C_SA: PC628.1 PR630.1 PU602.24(COMP_C)
COMP_CHG: PC749.1 PR728.1 PU700.28(CMOP)
CONTACTLESS_DET#: DZ8.2 RC278.1 UC1.CN35(GPP_G4/SD_DATA3)
CONTACTLESS_DET#_R: DZ8.1 JUSH1.4
CORE_VID0: PR408.1 UC1.CB36(GPP_B0/CORE_VID0)
CORE_VID1: PR411.1 UC1.CB35(GPP_B1/CORE_VID1)
CPU_C10_GATE#: PR429.1 RZ1420.1 UC1.CN27(GPP_H18/CPU_C10_GATE#)
CPU_DP1_AUXN: CT19.1 UC1.AC7(DDI1_AUX_N)
CPU_DP1_AUXN_C: CT19.2 UT1.W11(DPSNK0_AUX_N)
CPU_DP1_AUXP: CT18.1 UC1.AC6(DDI1_AUX_P)
CPU_DP1_AUXP_C: CT18.2 UT1.Y11(DPSNK0_AUX_P)
CPU_DP1_CTRL_CLK: RC503.1 UC1.CC8(GPP_E18/DPPB_CTRLCLK/CNV_BT_HOS) UT1.Y5(DPSNK0_DDC_CLK)
CPU_DP1_CTRL_DATA: RC178.1 UC1.CC9(GPP_E19/DPPB_CTRLDATA) UT1.R4(DPSNK0_DDC_DATA)
CPU_DP1_HPD: RT24.1 UC1.CN6(GPP_E13/DDPB_HPD0/DISP_MISC0) UT1.AA2(DPSNK0_HPD)
CPU_DP1_N0: CT11.1 UC1.AL5(DDI1_TXN_0)
CPU_DP1_N0_C: CT11.2 UT1.AC7(DPSNK0_ML0_N)
CPU_DP1_N1: CT13.1 UC1.AJ5(DDI1_TXN_1)
CPU_DP1_N1_C: CT13.2 UT1.AC9(DPSNK0_ML1_N)
CPU_DP1_N2: CT15.1 UC1.AF6(DDI1_TXN_2)
CPU_DP1_N2_C: CT15.2 UT1.AC11(DPSNK0_ML2_N)
CPU_DP1_N3: CT17.1 UC1.AE5(DDI1_TXN_3)
CPU_DP1_N3_C: CT17.2 UT1.AC13(DPSNK0_ML3_N)
CPU_DP1_P0: CT10.1 UC1.AL6(DDI1_TXP_0)
CPU_DP1_P0_C: CT10.2 UT1.AB7(DPSNK0_ML0_P)
CPU_DP1_P1: CT12.1 UC1.AJ6(DDI1_TXP_1)
CPU_DP1_P1_C: CT12.2 UT1.AB9(DPSNK0_ML1_P)
CPU_DP1_P2: CT14.1 UC1.AF5(DDI1_TXP_2)
CPU_DP1_P2_C: CT14.2 UT1.AB11(DPSNK0_ML2_P)
CPU_DP1_P3: CT16.1 UC1.AE6(DDI1_TXP_3)
CPU_DP1_P3_C: CT16.2 UT1.AB13(DPSNK0_ML3_P)
CPU_DP2_AUXN: CT175.1 UC1.AD4(DDI2_AUX_N)
CPU_DP2_AUXN_C: CT175.2 UT1.W12(DPSNK1_AUX_N)
CPU_DP2_AUXP: CT169.1 UC1.AD3(DDI2_AUX_P)
CPU_DP2_AUXP_C: CT169.2 UT1.Y12(DPSNK1_AUX_P)
CPU_DP2_CTRL_CLK: RC176.1 UC1.CH4(GPP_E20/DPPC_CTRLCLK)
CPU_DP2_CTRL_DATA: RC502.1 UC1.CH3(GPP_E21/DPPC_CTRLDATA)
CPU_DP2_HPD: RT29.1 UC1.CM6(GPP_E14/DDPC_HPD1/DISP_MISC1) UT1.Y6(DPSNK1_HPD)
CPU_DP2_N0: CT176.1 UC1.AC4(DDI2_TXN_0)
CPU_DP2_N0_C: CT176.2 UT1.AC15(DPSNK1_ML0_N)
CPU_DP2_N1: CT171.1 UC1.AC1(DDI2_TXN_1)
CPU_DP2_N1_C: CT171.2 UT1.AC17(DPSNK1_ML1_N)
CPU_DP2_N2: CT168.1 UC1.AE4(DDI2_TXN_2)
CPU_DP2_N2_C: CT168.2 UT1.AC19(DPSNK1_ML2_N)
CPU_DP2_N3: CT170.1 UC1.AE1(DDI2_TXN_3)
CPU_DP2_N3_C: CT170.2 UT1.AC21(DPSNK1_ML3_N)
CPU_DP2_P0: CT177.1 UC1.AC3(DDI2_TXP_0)
CPU_DP2_P0_C: CT177.2 UT1.AB15(DPSNK1_ML0_P)
CPU_DP2_P1: CT172.1 UC1.AC2(DDI2_TXP_1)
CPU_DP2_P1_C: CT172.2 UT1.AB17(DPSNK1_ML1_P)
CPU_DP2_P2: CT174.1 UC1.AE3(DDI2_TXP_2)
CPU_DP2_P2_C: CT174.2 UT1.AB19(DPSNK1_ML2_P)
CPU_DP2_P3: CT173.1 UC1.AE2(DDI2_TXP_3)
CPU_DP2_P3_C: CT173.2 UT1.AB21(DPSNK1_ML3_P)
CPU_DP3_AUXN: T1.1 UC1.AG7(DDI3_AUX_N)
CPU_DP3_AUXP: T2.1 UC1.AG6(DDI3_AUX_P)
CPU_GC6_FB_EN: T383.1 UC1.CM35(GPP_G3/SD_DATA2)
CPU_POPIRCOMP: RC106.1 UC1.BP27(PROC_POPIRCOMP)
CPU_XDP_PRDY#: JXDP1.5 UC1.W1(PROC_PRDY#)
CPU_XDP_PREQ#: JXDP1.3 RC138.2 UC1.W2(PROC_PREQ#)
CPU_XDP_TCLK: JXDP1.57 RC139.1 RC328.1 UC1.T6(PROC_TCK)
CPU_XDP_TDI: RC134.1 RC851.1 UC1.U6(PROC_TDI)
CPU_XDP_TDO: RC135.1 RC850.1 UC1.Y5(PROC_TDO)
CPU_XDP_TMS: RC131.1 RC852.1 UC1.T5(PROC_TMS)
CPU_XDP_TRST#: RC136.1 RC853.1 UC1.AB6(PROC_TRST#) UC1.Y6(PCH_TRST#)
CPVEE: CA49.1 CA77.1 UA1.25(CPVEE)
CSIN_CHG: PC719.2 PC726.1 PR702.2 PU700.14(CSIN)
CSIN_CHG_R: PR700.3 PR702.1
CSIP_CHG: PC719.1 PC725.1 PR701.2 PU700.15(CSIP)
CSIP_CHG_R: PR700.2 PR701.1
CSON_CHG: PC752.2 PC753.1 PR734.1 PU700.1(CSON)
CSON_CHG_R: PR711.3 PR734.2
CSOP_CHG: PC748.1 PC752.1 PR733.1 PU700.2(CSOP)
CSOP_CHG_R: PR711.2 PR733.2
CV2_ON: JUSH1.24 RE539.2
CV2_ON_R: RE539.1 RE810.2 UE1.H8(GPIO222/SER_IRQ)
DAT_TP_SIO_I2C_CLK: CZ80.1 RZ22.2 RZ347.2 UE1.C12(GPIO155/SMB02_CLK/PS2_DAT1B)
DAT_TP_SIO_R: CZ88.1 JKBTP1.13 RZ18.2 RZ22.1
DCIN1_EN: RE600.2 UE1.L12(GPIO107/NSMI)
DCIN1_EN_R: PQ8.3(S) PR28.1 RE600.1
DCIN2_EN: RE601.1 UE1.K4(GPIO215/ADC13)
DCIN2_EN_R: PQ807.3(S) PR821.1 RE601.2
DCIN_CHG: PC737.2 PR708.1 PU700.17(DCIN)
DCPRTC: CC76.1 UC1.BP24(DCPRTC)
DDR_A_ACT#: JDIMM1.114(ACT#) UC1.V35(DDR0_CAA_8/DDR0_ACT#)
DDR_A_ALERT#: JDIMM1.116(ALERT#) UC1.W37(NC/DDR0_ALERT#)
DDR_A_BA0: JDIMM1.150(BA0) UC1.W32(DDR0_CAB_4/DDR0_BA_0)
DDR_A_BA1: JDIMM1.145(BA1) UC1.AB31(DDR0_CAB_6/DDR0_BA_1)
DDR_A_BG0: JDIMM1.115(BG0) UC1.V34(DDR0_CAA_5/DDR0_BG_0)
DDR_A_BG1: JDIMM1.113(BG1) UC1.W35(DDR0_CAA_9/DDR0_BG_1)
DDR_A_CKE0: JDIMM1.109(CKE0) UC1.U36(DDR0_CKE_0/DDR0_CKE_0)
DDR_A_CKE1: JDIMM1.110(CKE1) UC1.U37(DDR0_CKE_1/DDR0_CKE_1)
DDR_A_CKE2: T351.1 UC1.U34(DDR0_CKE_2/NC)
DDR_A_CKE3: T350.1 UC1.U35(DDR0_CKE_3/NC)
DDR_A_CLK0: JDIMM1.137(CK0(T)) UC1.V31(DDR0_CKP_0/DDR0_CKP_0)
DDR_A_CLK1: JDIMM1.138(CK1(T)) UC1.T31(DDR0_CKP_1/DDR0_CKP_1)
DDR_A_CLK#0: JDIMM1.139(CK0#(C)) UC1.V32(DDR0_CKN_0/DDR0_CKN_0)
DDR_A_CLK#1: JDIMM1.140(CK1#(C)) UC1.T32(DDR0_CKN_1/DDR0_CKN_1)
DDR_A_CS#0: JDIMM1.149(S0#) UC1.AE32(DDR0_CS#_0/DDR0_CS#_0)
DDR_A_CS#1: JDIMM1.157(S1#) UC1.AF32(DDR0_CS#_1/DDR0_CS#_1)
DDR_A_D0: JDIMM1.4(DQ4) UC1.A26(DDR0_DQ_0/DDR0_DQ_0)
DDR_A_D1: JDIMM1.20(DQ2) UC1.D26(DDR0_DQ_1/DDR0_DQ_1)
DDR_A_D2: JDIMM1.8(DQ0) UC1.D28(DDR0_DQ_2/DDR0_DQ_2)
DDR_A_D3: JDIMM1.17(DQ7) UC1.C28(DDR0_DQ_3/DDR0_DQ_3)
DDR_A_D4: JDIMM1.3(DQ5) UC1.B26(DDR0_DQ_4/DDR0_DQ_4)
DDR_A_D5: JDIMM1.7(DQ1) UC1.C26(DDR0_DQ_5/DDR0_DQ_5)
DDR_A_D6: JDIMM1.16(DQ6) UC1.B28(DDR0_DQ_6/DDR0_DQ_6)
DDR_A_D7: JDIMM1.21(DQ3) UC1.A28(DDR0_DQ_7/DDR0_DQ_7)
DDR_A_D8: JDIMM1.28(DQ8) UC1.B30(DDR0_DQ_8/DDR0_DQ_8)
DDR_A_D9: JDIMM1.38(DQ14) UC1.D30(DDR0_DQ_9/DDR0_DQ_9)
DDR_A_D10: JDIMM1.25(DQ13) UC1.B33(DDR0_DQ_10/DDR0_DQ_10)
DDR_A_D11: JDIMM1.42(DQ11) UC1.D32(DDR0_DQ_11/DDR0_DQ_11)
DDR_A_D12: JDIMM1.24(DQ12) UC1.A30(DDR0_DQ_12/DDR0_DQ_12)
DDR_A_D13: JDIMM1.29(DQ9) UC1.C30(DDR0_DQ_13/DDR0_DQ_13)
DDR_A_D14: JDIMM1.37(DQ15) UC1.B32(DDR0_DQ_14/DDR0_DQ_14)
DDR_A_D15: JDIMM1.41(DQ10) UC1.C32(DDR0_DQ_15/DDR0_DQ_15)
DDR_A_D16: JDIMM1.194(DQ41) UC1.J22(DDR1_DQ_0/DDR0_DQ_16)
DDR_A_D17: JDIMM1.203(DQ46) UC1.H25(DDR1_DQ_1/DDR0_DQ_17)
DDR_A_D18: JDIMM1.191(DQ44) UC1.G22(DDR1_DQ_2/DDR0_DQ_18)
DDR_A_D19: JDIMM1.190(DQ45) UC1.H22(DDR1_DQ_3/DDR0_DQ_19)
DDR_A_D20: JDIMM1.208(DQ43) UC1.F25(DDR1_DQ_4/DDR0_DQ_20)
DDR_A_D21: JDIMM1.204(DQ47) UC1.J25(DDR1_DQ_5/DDR0_DQ_21)
DDR_A_D22: JDIMM1.207(DQ42) UC1.G25(DDR1_DQ_6/DDR0_DQ_22)
DDR_A_D23: JDIMM1.195(DQ40) UC1.F22(DDR1_DQ_7/DDR0_DQ_23)
DDR_A_D24: JDIMM1.169(DQ37) UC1.D22(DDR1_DQ_8/DDR0_DQ_24)
DDR_A_D25: JDIMM1.173(DQ33) UC1.C22(DDR1_DQ_9/DDR0_DQ_25)
DDR_A_D26: JDIMM1.186(DQ35) UC1.C24(DDR1_DQ_10/DDR0_DQ_26)
DDR_A_D27: JDIMM1.183(DQ38) UC1.D24(DDR1_DQ_11/DDR0_DQ_27)
DDR_A_D28: JDIMM1.170(DQ36) UC1.A22(DDR1_DQ_12/DDR0_DQ_28)
DDR_A_D29: JDIMM1.174(DQ32) UC1.B22(DDR1_DQ_13/DDR0_DQ_29)
DDR_A_D30: JDIMM1.187(DQ34) UC1.A24(DDR1_DQ_14/DDR0_DQ_30)
DDR_A_D31: JDIMM1.182(DQ39) UC1.B24(DDR1_DQ_15/DDR0_DQ_31)
DDR_A_D32: JDIMM1.50(DQ16) UC1.H37(DDR0_DQ_16/DDR0_DQ_32)
DDR_A_D33: JDIMM1.45(DQ21) UC1.H34(DDR0_DQ_17/DDR0_DQ_33)
DDR_A_D34: JDIMM1.62(DQ18) UC1.K34(DDR0_DQ_18/DDR0_DQ_34)
DDR_A_D35: JDIMM1.63(DQ19) UC1.K35(DDR0_DQ_19/DDR0_DQ_35)
DDR_A_D36: JDIMM1.49(DQ17) UC1.H36(DDR0_DQ_20/DDR0_DQ_36)
DDR_A_D37: JDIMM1.46(DQ20) UC1.H35(DDR0_DQ_21/DDR0_DQ_37)
DDR_A_D38: JDIMM1.59(DQ23) UC1.K36(DDR0_DQ_22/DDR0_DQ_38)
DDR_A_D39: JDIMM1.58(DQ22) UC1.K37(DDR0_DQ_23/DDR0_DQ_39)
DDR_A_D40: JDIMM1.66(DQ28) UC1.N36(DDR0_DQ_24/DDR0_DQ_40)
DDR_A_D41: JDIMM1.70(DQ24) UC1.N34(DDR0_DQ_25/DDR0_DQ_41)
DDR_A_D42: JDIMM1.79(DQ30) UC1.R37(DDR0_DQ_26/DDR0_DQ_42)
DDR_A_D43: JDIMM1.84(DQ27) UC1.R34(DDR0_DQ_27/DDR0_DQ_43)
DDR_A_D44: JDIMM1.67(DQ29) UC1.N37(DDR0_DQ_28/DDR0_DQ_44)
DDR_A_D45: JDIMM1.71(DQ25) UC1.N35(DDR0_DQ_29/DDR0_DQ_45)
DDR_A_D46: JDIMM1.83(DQ26) UC1.R36(DDR0_DQ_30/DDR0_DQ_46)
DDR_A_D47: JDIMM1.80(DQ31) UC1.R35(DDR0_DQ_31/DDR0_DQ_47)
DDR_A_D48: JDIMM1.211(DQ52) UC1.G31(DDR1_DQ_16/DDR0_DQ_48)
DDR_A_D49: JDIMM1.215(DQ49) UC1.G32(DDR1_DQ_17/DDR0_DQ_49)
DDR_A_D50: JDIMM1.225(DQ55) UC1.H29(DDR1_DQ_18/DDR0_DQ_50)
DDR_A_D51: JDIMM1.229(DQ51) UC1.H28(DDR1_DQ_19/DDR0_DQ_51)
DDR_A_D52: JDIMM1.216(DQ48) UC1.G28(DDR1_DQ_20/DDR0_DQ_52)
DDR_A_D53: JDIMM1.212(DQ53) UC1.G29(DDR1_DQ_21/DDR0_DQ_53)
DDR_A_D54: JDIMM1.224(DQ54) UC1.H31(DDR1_DQ_22/DDR0_DQ_54)
DDR_A_D55: JDIMM1.228(DQ50) UC1.H32(DDR1_DQ_23/DDR0_DQ_55)
DDR_A_D56: JDIMM1.233(DQ61) UC1.L31(DDR1_DQ_24/DDR0_DQ_56)
DDR_A_D57: JDIMM1.237(DQ56) UC1.L32(DDR1_DQ_25/DDR0_DQ_57)
DDR_A_D58: JDIMM1.246(DQ63) UC1.N29(DDR1_DQ_26/DDR0_DQ_58)
DDR_A_D59: JDIMM1.250(DQ59) UC1.N28(DDR1_DQ_27/DDR0_DQ_59)
DDR_A_D60: JDIMM1.236(DQ57) UC1.L28(DDR1_DQ_28/DDR0_DQ_60)
DDR_A_D61: JDIMM1.232(DQ60) UC1.L29(DDR1_DQ_29/DDR0_DQ_61)
DDR_A_D62: JDIMM1.249(DQ58) UC1.N31(DDR1_DQ_30/DDR0_DQ_62)
DDR_A_D63: JDIMM1.245(DQ62) UC1.N32(DDR1_DQ_31/DDR0_DQ_63)
DDR_A_DQS0: JDIMM1.13(DQS0(T)) UC1.D27(DDR0_DQSP_0/DDR0_DQSP_0)
DDR_A_DQS1: JDIMM1.34(DQS1(T)) UC1.C31(DDR0_DQSP_1/DDR0_DQSP_1)
DDR_A_DQS2: JDIMM1.200(DQS5(T)) UC1.G24(DDR1_DQSP_0/DDR0_DQSP_2)
DDR_A_DQS3: JDIMM1.179(DQS4(T)) UC1.D23(DDR1_DQSP_1/DDR0_DQSP_3)
DDR_A_DQS4: JDIMM1.55(DQS2(T)) UC1.J34(DDR0_DQSP_2/DDR0_DQSP_4)
DDR_A_DQS5: JDIMM1.76(DQS3(T)) UC1.P35(DDR0_DQSP_3/DDR0_DQSP_5)
DDR_A_DQS6: JDIMM1.221(DQS6(T)) UC1.H30(DDR1_DQSP_2/DDR0_DQSP_6)
DDR_A_DQS7: JDIMM1.242(DQS7(T)) UC1.N30(DDR1_DQSP_3/DDR0_DQSP_7)
DDR_A_DQS#0: JDIMM1.11(DQS0#(C)) UC1.C27(DDR0_DQSN_0/DDR0_DQSN_0)
DDR_A_DQS#1: JDIMM1.32(DQS1#(C)) UC1.D31(DDR0_DQSN_1/DDR0_DQSN_1)
DDR_A_DQS#2: JDIMM1.198(DQS5#(C)) UC1.H24(DDR1_DQSN_0/DDR0_DQSN_2)
