# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_SLP_S4#_R: length 7.8
  TOP w0.127: PR208.2 226.24,24 226.38,23.86 228.06,23.86 v2(228.29,24.09)
  TOP w0.254: PU200.1 223.91,27.3 224.85,26.36 PC221.1 225.3,26.36 225.56,26.11 225.56,24.82 225.43,24.69 PR209.1 225.44,24.31 PR208.2
SIO_SLP_S5#: length 196.3
  TOP w0.127: v1(252.81,40.55) 252.81,39.23 254.01,38.03 256.24,38.03 256.93,37.34 256.93,33.46 256.5,33.03 256.5,30.65 256.92,30.22 260.23,30.22 260.39,30.39 261.72,30.39 v1(261.89,30.55) ; RC230.1 168.62,57.14 v2(168.97,57.49) v1(169.38,57.9)
  IN3 w0.122: v1(252.81,40.55) 252.12,40.55 250.3,38.74 247.08,38.74 246.25,37.91 245,37.91 244.74,37.65 243.8,37.65 243.55,37.91 237.84,37.91 237.68,37.75 226.99,37.75 225.16,39.58 216.68,39.58 207.1,49.15 190,49.15 182.43,56.72 179.76,56.72 179.34,56.31 179.34,55.4 178.7,54.75 178.7,54.53 177.79,53.62 175.01,53.62 171.7,56.94 169.5,56.94 169.38,57.06 v1(169.38,57.9)
  IN4 w0.076: v1(143.02,73.22) 143.55,72.69 143.55,71.08 143.63,71.01
  IN4 w0.102: v1(169.38,57.9) 168.78,57.9 168.65,58.03 167.2,58.03 167.05,57.87 162.67,57.87 161.56,56.76 159.41,56.76 158.69,57.48 158.69,58.95 153.91,63.74 153.16,63.74 151.5,65.4 151.14,65.4 149.74,66.8 146.65,66.8 145.87,67.58 145.87,68.12 144.04,69.95 144.04,70.59 143.63,71.01
  BOTTOM w0.089: v1(143.02,73.22) 142.71,73.4 UC1.BT29
  BOTTOM w0.127: v1(261.89,30.55) 262.12,30.55 263.57,29.1 264.2,29.1 265.5,27.81 278.2,27.81 278.49,28.1 278.52,28.14 278.52,28.38 280.1,29.97 281.37,29.97 281.82,30.41 286.84,30.41 288.23,29.01 288.23,28.38 290.84,25.77 292.16,25.77 296.95,30.56 JAPS1.4
SIO_SLP_SUS#: length 211.7
  TOP w0.127: RE349.1 290.35,79.89 v1(290.9,80.45) ; RC441.1 RC229.1 CC1465.1 169.51,57.24 v1(169.78,57.5) 170.42,57.5 v2(170.48,57.56)
  IN1 w0.084: v1(288.74,72.54) 288.55,72.35 288.55,72.05 288.16,71.66 287.69,71.66 287.58,71.77 286.17,71.77 284.62,70.22 281.57,70.22 281.5,70.29 280.76,70.29 279.74,71.32 278.47,71.32 v1(278.12,70.96)
  IN2 w0.076: v1(143.93,73.22) 143.38,72.66 143.38,70.6
  IN2 w0.102: v1(169.78,57.5) 168.73,57.5 168.4,57.83 167.76,57.83 167.61,57.67 166.14,57.67 166.02,57.55 163.37,57.55 162.91,58 157.47,58 156.26,59.21 146.91,59.21 145.02,61.1 145.02,61.56 144.53,62.05 144.53,67.45 143.38,68.6 143.38,70.6
  IN2 w0.122: v1(288.74,72.54) 289.23,72.54 290.01,73.32 290.01,73.65 290.15,73.79 290.15,74.54 290.02,74.66 290.02,78.28 289.63,78.67 289.63,79.43 290.64,80.45 v1(290.9,80.45)
  IN3 w0.122: v1(169.78,57.5) 169.78,57.28 169.9,57.16 171.79,57.16 175.1,53.85 177.7,53.85 178.48,54.63 178.48,55.76 179.66,56.95 182.52,56.95 190.09,49.38 196.65,49.38 197.31,50.04 200.04,50.04 200.61,49.47 207.1,49.47 216.77,39.8 225.26,39.8 227.08,37.98 237.59,37.98 237.74,38.13 243.64,38.13 243.89,37.88 244.65,37.88 244.9,38.13 246.16,38.13 246.99,38.96 250.21,38.96 253.69,42.44 256.03,42.44 256.91,43.33 258.47,43.33 261.27,46.13 264.54,46.13 264.81,45.85 266.91,45.85 267.19,46.14 267.19,47.21 268.26,48.28 268.26,49.66 270.38,51.78 270.55,51.78 270.93,52.16 270.93,52.74 272.28,54.08 272.28,56.37 273.23,57.32 274.39,57.32 275.29,58.21 275.29,59.02 275.8,59.53 275.8,64.47 276.74,65.41 276.74,69.58 v1(278.12,70.96)
  BOTTOM w0.089: UC1.BU29 v1(143.93,73.22)
SIO_SLP_SUS#_R: length 7.7
  TOP w0.102: 285.37,78.67 284.5,78.67 v2(284.24,78.93) 283.02,80.16 UE1.N4
  TOP w0.127: RE349.2 287.86,78.98 287.54,78.66 RE561.1 287.27,78.21 286.81,78.67 285.37,78.67
SIO_SLP_WLAN#: length 130.8
  TOP w0.127: v1(248.47,38.33) 248.47,38.68 v2(248.14,39.01) ; v1(164.94,57.1) RC234.1 CC1470.1
  IN3 w0.122: v1(248.47,38.33) 248.29,38.52 247.18,38.52 246.34,37.68 245.09,37.68 244.84,37.43 243.7,37.43 243.45,37.68 237.93,37.68 237.78,37.53 226.89,37.53 225.07,39.35 216.59,39.35 207.01,48.93 189.91,48.93 182.34,56.5 179.98,56.5 179.57,56.09 179.57,55.3 178.92,54.66 178.92,54.44 177.88,53.4 174.92,53.4 171.6,56.71 165.79,56.71 165.4,57.1 v1(164.94,57.1)
  IN4 w0.076: 143.47,70.84 143.39,70.92 143.39,72.22 v1(143.02,72.58)
  IN4 w0.102: v1(164.94,57.1) 164.37,57.67 162.76,57.67 161.65,56.56 159.32,56.56 158.44,57.44 158.44,58.92 153.81,63.55 153.08,63.55 151.45,65.18 151.1,65.18 149.7,66.58 146.3,66.58 145.08,67.8 145.08,68.58 143.7,69.97 143.7,70.61 143.47,70.84
  BOTTOM w0.089: v1(143.02,72.58) 142.71,72.75 UC1.BT30
  BOTTOM w0.127: v1(248.47,38.33) 248.47,37.67 QZ15.1
SKTOCC#: length 4.8
  TOP w0.127: v1(110.81,93.19) v3(110.81,94.01)
  BOTTOM w0.076: 110.14,94.1 110.81,93.42 v1(110.81,93.19) 110.81,92.89 111.53,92.17 UC1.E1
  BOTTOM w0.127: RC565.1 110.14,94.1
SLEEVE: length 15
  IN1 w1.27: 287.34,41.01 295.92,41.01 298.14,43.24 301.44,43.24
  vias: v1(285.88,40.63) v1(286.45,40.63) v1(302.58,44.44) v1(303.22,44.44) v3(303.85,44.81)
SLEEVE_R: length 6.9
  TOP w0.127: CA1.2 307.9,45.49 v3(308.2,45.19)
  BOTTOM w1.27: JHP1.3 309.71,43.3 308.63,44.38 306.71,44.38 305.9,45.19 DA3.2
  vias: v1(307.09,46.29) v1(307.09,45.71)
SLOT2_SATA_LED#: length 3.8
  TOP w0.127: v2(271.39,63.81) 270.92,63.34 v1(270.44,63.34) RZ1477.1
  BOTTOM w0.127: JNGFF2.10 269.43,63.56 269.65,63.34 270.32,63.34 270.32,63.34 v1(270.44,63.34)
SLP_WLAN#_GATE: length 94.4
  TOP w0.127: RE552.1 282.54,96.66 282.73,96.86 282.73,98.81 v1(282.07,99.47)
  IN2 w0.122: v1(273.3,99.19) 273.46,99.02 277.82,99.02 278.68,99.89 281.65,99.89 v1(282.07,99.47)
  IN3 w0.122: v1(273.3,99.19) 274.44,98.05 274.44,87.99 274.23,87.78 274.23,78.79 274.99,78.04 275.38,78.04 276.19,77.23 276.19,75.89 274.43,74.14 274.43,72.25 273.44,71.26 273.44,68.24 271.81,66.61 271.81,64.41 271.55,64.15 271.55,62.66 270.95,62.06 270.95,60.38 270.38,59.81 270.38,55.13 270.74,54.77 270.74,54.44 270.35,54.05 269.98,54.05 269.01,53.08 269.01,52.31 267.31,50.61 266.3,50.61 266.08,50.83 265.62,50.83 265.04,50.24 265.04,49.93 262.81,47.7 260.37,47.7 259.28,46.61 257.96,46.61 256.31,44.95 254.37,44.95 253.58,44.16 253.2,44.16 250.75,41.72 v1(250.25,41.72)
  BOTTOM w0.127: QZ15.2 247.91,39.18 247.91,39.98 247.92,39.99 RZ518.2 247.92,40.89 248.16,41.14 249.68,41.14 v2(249.7,41.16) 250.25,41.7 v1(250.25,41.72)
SLP_WLAN#_GATE_R: length 21.6
  TOP w0.127: RE552.2 282.78,94.34 283.04,94.6 283.04,97.2 v2(283.25,97.41) v1(284.5,98.66) ; v1(280.2,85.35) 280.2,85.34 UE1.K10
  IN3 w0.122: v1(284.5,98.66) 282.96,97.12 282.96,94.18 281.53,92.75 281.53,92.24 279.75,90.45 279.75,88.3 280.05,87.99 280.05,87.31 280.61,86.75 280.61,85.78 280.21,85.37 280.21,85.36 v1(280.2,85.35)
SLP_WLAN#_M: length 5.8
  BOTTOM w0.127: v2(251.65,41.9) RZ71.1 251.65,40.63 251.9,40.38 DZ9.3 250.11,39.58 250.01,39.68 249.26,39.68 249.06,39.49 QZ15.3
SM_RCOMP0: length 2
  TOP w0.381: RC5.1 140.14,74.83 140.61,74.37 140.61,74.32 141.07,73.85 v1(141.2,73.85)
  BOTTOM w0.254: UC1.BN28 v1(141.2,73.85)
SM_RCOMP1: length 1.3
  TOP w0.381: RC504.1 140.88,74.81 v1(141.2,74.49)
  BOTTOM w0.254: UC1.BN27 v1(141.2,74.49)
SM_RCOMP2: length 1.9
  TOP w0.381: RC7.1 140.35,73.84 140.97,73.22 v1(141.2,73.22)
  BOTTOM w0.254: UC1.BN29 v1(141.2,73.22)
SMART_SPK_DET0#: length 225.4
  TOP w0.127: v1(304.55,15.6) 304.51,15.6 303.35,16.77 299.79,16.77 v2(299.24,16.22) 298.71,15.69 v1(295.88,15.69)
  IN3 w0.122: v1(183.81,49.33) 183.55,49.59 181.76,49.59 180.82,50.53 168.91,50.53 165.56,53.88 156.62,53.88 156.41,54.1 150.53,54.1 147.28,57.35 147.28,58 150.43,61.16 150.78,61.16 151.64,62.02 151.64,63.34 152.61,64.31 v1(152.61,66.15) ; v1(295.88,15.69) 294.52,17.05 294.52,26.92 294.07,27.36 293.44,27.36 292.42,28.38 292.42,29.39 292.01,29.81 286.74,29.81 286.14,30.41 283.16,30.41 281.16,32.41 278.59,32.41 276.53,30.34 275.91,30.34 275.79,30.46 275.79,31.12 275.5,31.41 274.77,31.41 273.53,30.17 267.25,30.17 266.62,30.79 264.83,30.79 264.2,30.16 260.75,30.16 259.96,29.36 254.04,29.36 253.69,29.02 251.09,29.02 250.44,28.37 239.34,28.37 238.7,29.01 232.67,29.01 231.13,30.55 225.16,30.55 224.28,31.43 220.04,31.43 217.88,33.6 213.48,33.6 210.57,36.51 207.68,36.51 207.56,36.39 v1(207.56,35.32)
  IN4 w0.084: v1(207.56,35.32) 207.31,35.56 207.15,35.56 205.26,37.46 203.37,37.46 202.62,38.2 202.62,40.86 201.18,42.3 196.22,42.3 194.61,43.9 189.79,43.9 184.36,49.33 v1(183.81,49.33)
  BOTTOM w0.076: v1(152.61,66.15) 152.61,66.65 152.16,67.1 151.39,67.1 150.88,67.61 150.88,68.12 150.72,68.49 150.72,68.72 150.81,68.81 150.81,69.5 150.96,69.64 UC1.CK34
  BOTTOM w0.127: JSPK1.4 296.39,7.03 296.89,6.52 303.03,6.52 304.55,8.05 v1(304.55,15.6) 304.55,16.28 304.88,16.61 RA66.2
SMART_SPK_DET1#: length 222
  TOP w0.127: v1(252.36,44.3) 251.8,43.75 251.8,36.09 253.26,34.63 254.78,34.63 255.64,33.77 255.64,30.31 258.17,27.78 281.57,27.78 281.63,27.85 286.57,27.85 288.3,26.12 288.3,22.38 294.47,16.21 v2(296.89,16.21) 298.57,16.21 299.51,17.15 306.52,17.15 v1(307.03,16.64)
  IN1 w0.102: v1(155.17,83.73) 155.39,83.73 155.91,83.2 174.06,83.2 175.39,81.87 176.02,81.87 176.35,81.54 176.35,80.5 176.91,79.94 176.91,77.3 176.4,76.8 176.4,75.89 180.22,72.07 182.08,72.07 193.13,61.02 197.67,61.02 215.03,43.66 215.03,43.66 216.41,42.27 220.05,42.27 221.06,41.27 228.87,41.27 229.55,40.59 242.41,40.59 243.41,41.59 244.57,41.59 245.66,42.68 246.24,42.68 246.94,43.38 250.42,43.38 251.34,44.3 v1(252.36,44.3)
  BOTTOM w0.076: UC1.CN12 152.78,84.33 153.12,83.99 153.47,83.99 153.79,83.82 154.17,83.82 154.39,84.04 154.69,84.04 155.01,83.73 v1(155.17,83.73)
  BOTTOM w0.127: v1(307.03,16.64) RA67.2 305.7,16.17 304.78,15.26 304.78,7.95 303.12,6.29 295.98,6.29 295.14,7.14 JSPK1.3
SML0_SMBCLK: length 22.4
  IN4 w0.084: v1(150.22,82.66) 150.62,83.06 152.16,83.06 152.22,83.12 154.52,83.12 154.75,83.35 156.98,83.35 157.06,83.43 160.78,83.43 161.35,82.86 166.38,82.86 167.12,82.12 168.85,82.12 169.11,82.38 169.11,82.63 v1(169.02,82.72)
  BOTTOM w0.089: v1(150.22,82.66) UC1.CH14
  BOTTOM w0.127: v1(169.02,82.72) 169.1,82.79 169.1,83.19 169.12,83.21 CC318.1 169.12,84.3 RC347.1
SML0_SMBDATA: length 24.1
  IN4 w0.084: v1(169.6,82.72) 169.57,82.69 169.57,82.18 169.04,81.65 166.93,81.65 166.19,82.4 161.57,82.4 160.71,83.26 157.13,83.26 157.05,83.18 154.82,83.18 154.59,82.95 152.33,82.95 151.65,82.27 149.6,82.27 v1(148.95,81.62)
  BOTTOM w0.089: v1(148.95,81.62) UC1.CF15
  BOTTOM w0.127: RC348.1 169.93,83.31 169.6,82.98 v1(169.6,82.72)
SML0B_SMBCLK: length 17.7
  IN1 w0.102: v1(167.89,76.02) 167.71,76.19 167.27,76.64 166.69,76.64 166.25,76.19 165.8,76.19 165.41,76.59 161.56,76.59 161.36,76.38 160.69,76.38 v1(160.49,76.18)
  BOTTOM w0.076: v1(160.49,76.18) 159.97,76.7 158.33,76.7 157.99,77.03 155.02,77.03 154.95,77.11 153.83,77.11 153.71,77.06 153.53,77.06 153.07,77.23 UC1.CN23
  BOTTOM w0.127: v1(167.89,76.02) 167.95,76.08 CC1476.1 RC829.1
SML0B_SMBDATA: length 16.5
  IN1 w0.102: v1(166.95,75.98) 165.32,75.98 165.19,76.11 162.02,76.11 161.53,75.62 161.28,75.62 161.28,75.62 160.98,75.62 160.97,75.62 160.65,75.62 160.41,75.62 v1(159.94,76.09)
  BOTTOM w0.076: UC1.CM24 152.27,77.03 153.15,77.03 153.5,76.9 153.74,76.9 153.85,76.94 154.88,76.94 154.95,76.87 157.74,76.87 158.07,76.54 159.49,76.54 v1(159.94,76.09)
  BOTTOM w0.127: RC830.1 v1(166.95,75.98)
SML1_SMBCLK: length 200.6
  TOP w0.127: v1(274.65,83.79) 274.65,83.73 UE1.D8
  IN2 w0.089: 161.76,83 160.79,82.03 160.23,82.03 160.05,81.85 159.35,81.85 159.04,82.16 159.04,82.33 v1(159.26,82.56)
  IN2 w0.122: v1(265.08,69.24) 265.13,69.28 265.61,69.28 265.82,69.07 265.82,65.35 267.29,63.88 267.29,61.74 266.02,60.47 265.54,59.99 265.54,56.96 264.42,55.84 264.42,52.54 263.33,51.45 263.33,50.16 262.38,49.21 262.38,46.41 263.5,45.29 263.5,43.52 262.8,42.82 260.14,42.82 259.49,43.46 257.04,43.46 256.19,42.61 245.7,42.61 244.85,41.76 244.85,41.13 243.33,39.61 230.12,39.61 228.18,41.55 219.32,41.55 199.77,61.09 199.77,62.95 196.7,66.03 188.23,66.03 183.27,70.98 181.21,70.98 174.55,77.64 169.33,77.64 168.72,78.25 168.72,79.48 169.05,79.81 169.05,80.69 168.34,81.4 167.52,81.4 165.64,83.28 162.08,83.28 161.8,83 161.76,83
  IN4 w0.084: v1(274.65,83.79) 274.48,83.79 274.05,84.22 273.48,84.22 271.93,85.76 267.09,85.76 263.74,82.41 263.74,79.75 263.15,79.15 263.15,76.06 266.19,73.01 266.19,69.71 265.78,69.3 265.14,69.3 v1(265.08,69.24)
  BOTTOM w0.076: 158.25,81.78 154.92,81.78 154.55,82.15 153.83,82.15 153.71,82.11 153.53,82.11 153.07,82.27 UC1.CN15 ; v1(159.26,82.56) 159.03,82.79 159.03,82.9 159.33,83.2 159.72,83.2 159.89,83.03 159.91,83.03
  BOTTOM w0.102: v1(159.26,82.56) 159.26,82.42 158.63,81.78 158.25,81.78
  BOTTOM w0.127: 159.91,83.03 161.76,83.03 161.87,82.92 161.87,82.91 CC319.1 RC15.1
SML1_SMBDATA: length 202.5
  TOP w0.127: UE1.E11 275.65,85.93 275.65,86.02 v1(275.49,86.18)
  IN2 w0.089: v1(158.63,82.56) 158.86,82.33 158.86,82.09 159.28,81.67 160.09,81.67 160.23,81.53 161.06,81.53 161.76,82.23
  IN2 w0.122: v1(265.08,69.82) 265.13,69.78 265.82,69.78 266.32,69.28 266.32,65.56 267.79,64.08 267.79,61.53 266.37,60.11 266.04,59.78 266.04,56.75 264.93,55.64 264.93,52.33 263.83,51.24 263.83,49.95 262.88,49 262.88,46.62 264.01,45.49 264.01,43.31 263.01,42.31 259.93,42.31 259.28,42.96 257.25,42.96 256.4,42.11 251.75,42.11 250.77,41.13 249.21,41.13 248.84,40.76 245.19,40.76 243.54,39.11 229.91,39.11 227.97,41.05 219.11,41.05 199.27,60.89 199.27,62.74 196.49,65.53 188.02,65.53 183.07,70.48 181,70.48 174.34,77.14 169.12,77.14 168.22,78.04 168.22,79.69 168.55,80.01 168.55,80.48 168.14,80.89 167.32,80.89 165.43,82.78 162.31,82.78 161.76,82.23
  IN4 w0.084: v1(265.08,69.82) 265.14,69.76 265.58,69.76 265.73,69.91 265.73,72.82 262.68,75.87 262.68,79.35 263.28,79.94 263.28,82.61 266.9,86.23 272.13,86.23 273.38,84.98 274.92,84.98 275.09,85.15 275.09,85.78 v1(275.49,86.18)
  BOTTOM w0.076: v1(158.63,82.56) 158.86,82.79 158.86,82.97 159.26,83.37 159.74,83.37 159.91,83.54 ; UC1.CM15 152.58,82.64 153.06,82.64 153.18,82.59 153.41,82.59 153.53,82.64 153.71,82.64 153.83,82.59 155.28,82.59 155.71,82.16 156.79,82.16
  BOTTOM w0.102: v1(158.63,82.56) 158.63,82.42 158.38,82.16 156.79,82.16
  BOTTOM w0.127: RC507.1 161.87,83.69 161.72,83.54 v2(160.93,83.54) 159.91,83.54
SNK0_CONFIG1: length 2.3
  TOP w0.076: RT129.1 27.46,81.74 v2(27.96,82.24)
  TOP w0.127: RT129.1 27.06,81.09 v1(27.1,81.04)
  BOTTOM w0.127: v1(27.1,81.04) UT1.N4
SNUB1_CHG: length 1.2
  TOP w0.127: 56.13,73.07 55.85,73.34 v2(55.85,74.21)
SNUB1_IA: length 1.5
  TOP w0.127: v3(77.48,93.22) 78.04,93.79 PC662.1
SNUB2_CHG: length 1.8
  TOP w0.127: v2(56.04,76.31) 56.43,75.91 PC747.1
SNUB2_IA: length 2.3
  TOP w0.127: PR676.2 83.59,80.24 v2(85.15,78.68)
SNUB_1.05VALWP: length 1.2
  TOP w0.127: v2(193.21,113.13) 192.7,112.62 PC302.1
SNUB_1.8VALW: length 1.2
  BOTTOM w0.127: v2(174.49,105.86) 175.05,106.42 PC506.1
SNUB_1V_PRIM_CORE: length 1.5
  TOP w0.127: v2(185.71,23.51) 186.06,23.87 PR409.2
SNUB_1VS_VCCIO: length 1.1
  TOP w0.127: v2(78.1,23.29) 78.43,23.62 PC401.1
SNUB_3V: length 1.6
  TOP w0.127: PC112.1 v3(193.55,90.76)
SNUB_5V: length 1.7
  TOP w0.127: PR112.2 v2(46.43,19.41)
SNUB_DDR: length 0.6
  TOP w0.127: 212.26,36.84 v2(212.26,37.41)
SNUB_GT: length 1.7
  TOP w0.127: PR669.2 v2(85.36,71.11)
SNUB_SA: length 2.7
  TOP w0.127: PR627.2 95.16,89.32 95.7,88.78 v2(95.7,87.87)
SPKR: length 175.7
  TOP w0.127: RA12.2 282.28,57.22 281.44,56.38 281.44,55.6 v1(282.09,54.95) ; v1(150.52,64.9) 151,64.9 v2(151.2,64.7) ; v1(181.68,62.25) 181.7,62.22 RC183.1
  IN1 w0.084: v1(181.68,62.25) 181.91,62.48 183.71,62.48 184.73,61.46 184.73,59.54 188.67,55.6 189.44,55.6 190.97,54.06 191.88,54.06 193.28,52.67 197.38,52.67 213.42,36.63 216.58,36.63 219.81,33.4 229.56,33.4 230.89,34.74 239.13,34.74 239.65,34.22 245.11,34.22 245.57,33.76 247.33,33.76 247.79,34.22 251.88,34.22 252.38,33.72 252.92,33.72 253.48,33.16 255.74,33.16 256.66,34.08 257.25,34.08 257.47,34.29 261.61,34.29 261.87,34.03 262.78,34.03 263.67,34.93 266.8,34.93 267.19,35.32 268.32,35.32 269.57,36.57 271.47,36.57 272.78,37.88 272.78,43.69 273.1,44.02 273.96,44.02 275.31,45.36 275.91,45.36 276.8,46.25 276.8,46.73 278.33,48.25 278.9,48.25 279.34,48.7 279.34,50.42 281.18,52.27 281.18,54.05 v1(282.09,54.95)
  IN2 w0.102: 181.03,61.6 175.82,61.6 175.3,62.13 175.3,62.78 175.08,63 174.49,63 174.23,63.26 169.14,63.26 167.72,61.83 166.68,61.83 165.04,63.47 160.56,63.47 160.19,63.84 152.12,63.84 151.85,64.12
  IN2 w0.122: v1(150.52,64.9) 151.06,64.9 151.85,64.12 ; 181.03,61.6 v1(181.68,62.25)
  BOTTOM w0.076: v1(150.52,64.9) 149.6,65.82 149.6,66.09 148.37,67.32 148.37,68.12 148.17,68.31 148.17,68.69 148.28,68.89 148.28,69.52 UC1.CF35
SPKR_R: length 4.3
  TOP w0.127: v2(281.93,56.31) RA12.1
  TOP w0.203: CA27.1 285.81,57.23 284.89,56.31 RA51.1 CA72.1 RA12.1
SRTCRST#: length 21.6
  TOP w0.127: v2(149.53,55.16) v1(149.53,54.54) 149.78,54.54 150.4,53.92 RC56.1 150.89,53.92 151.15,54.17 CC24.1
  IN4 w0.084: v1(144.11,64.85) 144.85,64.11 144.85,62.03 145.33,61.55 145.33,55.96 145.89,55.4 148.67,55.4 v1(149.53,54.54)
  BOTTOM w0.076: 143.46,66.29 143.46,66.4 142.28,67.58 142.28,68.46 UC1.BR37
  BOTTOM w0.114: v1(144.11,64.85) 143.81,64.85 143.46,65.19 143.46,66.29 143.46,66.29
SS_1V_PRIM_CORE: length 4.3
  TOP w0.254: PU402.7 183.41,29.54 184.09,30.21 v2(184.4,30.21) 184.83,30.64 186.16,30.64 186.43,30.91 PR428.1
SS_1VS_VCCIO: length 1.7
  TOP w0.254: PU401.7 85.11,25.51 85.94,24.68 PR427.1
SSD_EN: length 7.3
  TOP w0.127: UZ53.3 27.33,33.41 v2(28.16,34.25) 28.16,34.5 29.16,35.51 UZ54.4 30.79,35.51 30.99,35.3 RZ1471.2
SSD_SCP#: length 365.7
  TOP w0.127: v1(33.08,27.68) 33.28,27.48 RN129.2 ; UE1.L6 280.7,81.76 v1(281.03,81.43) ; v1(286.92,98.74) 286.92,98.38 v2(286.52,97.98) 286.07,97.54 286.07,94.23 285.87,94.02 RE821.1
  IN1 w0.084: v1(281.03,81.43) 281.06,81.43 281.89,80.6 283.73,80.6 285.03,79.31 286.92,79.31 289.54,81.92 290.67,81.92 v1(292.35,83.6)
  IN3 w0.122: v1(292.35,83.6) 292.35,82.71 293.12,81.93 293.12,77.85 292.42,77.15 292.42,74.61 290.81,73 290.81,71.47 292.49,69.8 292.49,67.24 290.58,65.33 290.58,63.29 291.53,62.33 291.53,61.4 290.69,60.55 290.69,59.02 289.54,57.87 289.54,57.24 289.02,56.73 288.07,56.73 287.31,55.97 287.31,54.49 284.48,51.65 283.07,51.65 281.76,50.34 280.96,50.34 280.05,49.44 280.05,48.33 279.85,48.12 279.85,48.12 277.7,45.97 277.7,37.21 275.28,34.79 272.99,34.79 272.55,35.24 271.39,35.24 269.67,33.52 265.31,33.52 264.07,32.28 262.03,32.28 259.34,29.58 253.94,29.58 253.6,29.24 251,29.24 250.35,28.59 239.44,28.59 238.21,29.82 232.18,29.82 231.23,30.77 225.42,30.77 224.42,31.77 220.02,31.77 217.97,33.82 213.57,33.82 210.66,36.73 207.37,36.73 206.64,35.99 202.3,35.99 199.76,38.54 173.43,38.54 173.22,38.33 170.46,38.33 170.06,38.72 137.86,38.72 136.15,40.44 136.15,41.21 135.58,41.78 132.72,41.78 132.02,42.48 126.12,42.48 125.39,41.75 122.98,41.75 122.12,42.61 96.27,42.61 95.34,41.68 69.55,41.68 67.95,40.07 47.13,40.07 45.18,38.12 36.01,38.12 33.86,35.97 33.86,30.72 34.62,29.96 34.62,28.96 33.98,28.31 33.71,28.31 v1(33.08,27.68) ; v1(286.92,98.74) 286.3,98.11 286.3,95.02 284.61,93.33 284.61,91.28 282.31,88.98 282.31,87.36 282.11,87.15 282.11,85.49 282.74,84.86 282.74,84.42 282.07,83.75 282.07,82.54 281.03,81.5 v1(281.03,81.43)
SSD_SCP#_R: length 9.1
  TOP w0.127: v1(32.51,27.68) 32.7,27.49 RN129.1 v2(31.79,27.12)
  IN4 w0.084: v1(32.51,27.68) 32.86,27.32 32.86,23.48 32.13,22.75 JNGFF3.8
SSD_SCP_PWR_EN: length 322.6
  TOP w0.127: v1(287.13,71.4) 286.02,70.29 283.09,70.29 282.4,70.97 RE823.2 281.95,72.46 281.95,73.46 282.25,73.76 282.25,76.78 281.42,77.61 UE1.M1 ; v1(30.93,29.46) 31.29,29.82 QZ22.3 32.23,30.8 v2(32.68,30.35)
  IN3 w0.122: v1(287.13,71.4) 287.13,70.63 286.21,69.71 286.21,69.39 286.9,68.69 286.9,67.11 287.34,66.67 288.03,66.67 288.88,65.82 288.88,63.82 288.65,63.6 288.65,62.3 289.21,61.74 289.21,61.02 288.8,60.61 288.38,60.61 287.8,60.02 287.8,59 286.93,58.13 286.93,57.88 285.87,56.81 285.87,54.63 284.01,52.77 282.6,52.77 281.29,51.46 280.49,51.46 279.38,50.35 278.51,50.35 276.77,48.61 276.77,47.53 276.58,47.34 276.58,40.68 273.21,37.31 273.12,37.31 272.57,36.76 269.56,36.76 268.3,35.5 267.39,35.5 266.59,34.7 263.78,34.7 262.52,33.43 261.34,33.43 260.39,32.47 259.75,32.47 258.73,31.45 256.51,31.45 255.99,30.93 250.03,30.93 249.74,30.64 248.31,30.64 246.93,29.26 240.08,29.26 238.35,30.99 231.32,30.99 231.32,31 225.51,31 224.51,32 220.12,32 218.06,34.05 213.79,34.05 210.88,36.96 207.29,36.96 206.55,36.22 202.39,36.22 199.82,38.79 173.37,38.79 173.13,38.55 170.55,38.55 170.16,38.95 137.99,38.95 136.59,40.34 136.59,41.27 135.52,42.35 132.72,42.35 132.21,42.86 125.74,42.86 124.98,42.1 122.95,42.1 122.13,42.92 96.26,42.92 95.24,41.9 69.46,41.9 68.88,41.32 48.07,41.32 45.08,38.34 35.91,38.34 33.63,36.06 33.63,31.15 31.94,29.46 v1(30.93,29.46)
SSD_SCP_PWR_EN_D: length 9.3
  TOP w0.127: v2(27.58,29.05) 28.06,29.05 28.54,29.53 28.54,30.21 RZ1472.2 RZ1474.1 28.76,31.24 28.95,31.43 29.97,31.43 QZ22.1 31.58,33.04 RZ1471.1 31.58,33.57 31.57,33.59 31.57,34.58 31.84,34.86 UZ54.2
SUSCLK: length 325.5
  TOP w0.127: v1(153.49,55.2) 153.49,55.28 153.89,55.68 154.48,55.68 CC93.2 154.84,55.53 154.88,55.57 RC48.1 155.53,55.57 155.77,55.81 156.53,55.81 v2(156.73,56.01) 156.91,56.19 156.91,59.33 v1(156.04,60.21) ; v1(260.1,33.64) 260.1,35.17 259.02,36.25 259.02,37.2 258.39,37.84 257.88,37.84 257.56,38.16 257.56,40.44 259.15,42.03 259.53,42.03 260.58,43.08 260.58,43.13 260.88,43.43 RZ56.1
  IN1 w0.084: v1(209.07,37.9) 210.88,37.9 212.94,35.84 216.45,35.84 219.54,32.75 229.83,32.75 231.16,34.09 238.86,34.09 240.09,32.86 251.6,32.86 251.81,33.07 252.65,33.07 253.21,32.51 256.04,32.51 256.73,33.2 259.27,33.2 259.71,33.64 v1(260.1,33.64)
  IN2 w0.122: v1(44.29,47) 45.3,47 45.56,47.26 47.06,47.26 47.19,47.38 47.19,48 47.93,48.75 54.25,48.75 54.76,48.23 57.3,48.23 58.34,49.27 63.24,49.27 63.66,48.85 78.93,48.85 82.47,52.39 141.72,52.39 144.26,49.86 145.43,49.86 146.85,51.27 149.08,51.27 149.79,50.57 153.16,50.57 154.57,51.97 154.57,53.02 153.88,53.71 153.88,54.81 v1(153.49,55.2)
  IN4 w0.084: v1(153.49,55.2) 153.86,54.83 156.29,54.83 158.17,52.95 162.31,52.95 162.53,52.73 162.53,52.13 162.84,51.82 168.68,51.82 170.73,53.87 171.19,54.32 171.66,54.8 176.04,54.8 176.8,54.04 177.88,54.04 179.02,55.19 179.11,55.19 179.41,55.49 183.33,55.49 187.48,51.34 187.48,50.98 192.43,46.04 200.47,46.04 208.6,37.9 v1(209.07,37.9) ; v1(44.29,47) 44.29,45.8 43.63,45.14 42.04,45.14 40.36,43.46 40.36,43.14 39.5,42.29 39.5,40.28 35.04,35.82 31.43,35.82 30.69,36.56 28.38,36.56 27.94,36.99 26.35,36.99 25.92,36.56 24.46,36.56 23.45,35.54 23.45,33.05 22.37,31.97 19.48,31.97 17.7,30.19 17.7,28.28 v1(18.4,27.58)
  IN4 w0.094: v1(143.02,71.31) 143.02,70.96 143.35,70.64 143.35,69.99 144.85,68.49 144.85,67.7 146.21,66.35 149.66,66.35 151.02,64.99 151.37,64.99 153,63.36 153.11,63.36 156.04,60.43 v1(156.04,60.21)
  BOTTOM w0.089: UC1.BT32 142.71,71.46 v1(143.02,71.31)
  BOTTOM w0.127: v1(18.4,27.58) 18.4,25.99 RN99.2
SUSCLK_R: length 5.1
  BOTTOM w0.127: RN99.1 v2(18.89,24.02) 18.89,22.31 JNGFF3.68
SVID_ALERT#_PWR_CPU: length 4.3
  TOP w0.127: PR625.2 60.69,59.9 v2(60.87,59.72) 61.78,58.81 PU602.36
SVID_CLK_PWR_CPU: length 4.2
  TOP w0.127: PR618.2 60.67,59.04 v2(61.22,58.48) 61.3,58.41 PU602.37
SVID_DAT_PWR_CPU: length 4.5
  TOP w0.127: PR626.2 60.12,60.56 61.11,60.56 v2(62.21,59.45) 62.46,59.21 PU602.35
SW_USB20_N2: length 14.2
  TOP w0.104: UI3.11 295.83,76.56 296,76.38 296.49,76.38 v1(296.61,76.51) ; v1(293.01,85.35) 292.83,85.53 292.83,85.71 292.93,85.81 293.3,85.81 LI7.4
  IN4 w0.094: v1(293.01,85.35) 292.85,85.19 292.85,84.71 293.1,84.46 294.34,84.46 296.11,82.7 296.11,76.45 296.23,76.32 296.4,76.32 296.59,76.51 v1(296.61,76.51)
SW_USB20_P2: length 15.1
  TOP w0.104: v1(292.43,85.35) 292.64,85.56 292.64,85.79 292.85,86.01 293.3,86.01 LI7.1 ; v1(296.61,75.83) 296.61,75.94 296.36,76.19 296,76.19 295.87,76.06 UI3.10
  IN4 w0.094: v1(292.43,85.35) 292.67,85.11 292.67,84.63 293.02,84.28 294.27,84.28 295.92,82.62 295.92,76.37 296.16,76.14 296.42,76.14 296.61,75.94 v1(296.61,75.83)
SWD_CLK: length 1.1
  TOP w0.127: T220.1 30.69,56.48 v1(30.69,57)
  BOTTOM w0.076: UT5.G4 30.77,57.08 v1(30.69,57)
SWD_DATA: length 1.2
  TOP w0.127: v1(31.27,57) 31.3,57.03 T219.1
  BOTTOM w0.076: UT5.F4 v1(31.27,57)
SYS_PWROK: length 320.6
  TOP w0.127: RC129.1 57.04,99.75 55.67,101.12 55.67,102.97 56.52,103.82 58.22,103.82 v3(58.75,104.34) 59.44,105.04 v1(59.44,105.94) ; v1(277.96,76.27) 277.96,76.22 RE56.1 278.67,75.51 RE548.1
  IN1 w0.084: v1(161.36,85.4) 161.87,84.89 162.18,84.89 162.5,84.58 170.19,84.58 171.01,85.39 173.87,85.39 175.86,83.4 175.86,83.06 176.22,82.7 176.22,82.45 176.9,81.77 176.9,80.73 177.46,80.17 177.46,76.64 177.25,76.44 177.25,75.87 180.46,72.66 182.29,72.66 193.39,61.57 197.89,61.57 216.35,43.12 220.88,43.12 222.18,41.82 229.09,41.82 229.78,41.14 242.12,41.14 243.21,42.22 244.42,42.22 245.44,43.24 246.02,43.24 246.71,43.93 249.75,43.93 250.71,44.89 253.18,44.89 253.54,45.25 257.22,45.25 257.63,44.85 259.3,44.85 261.35,46.9 262.89,46.9 263.47,46.32 265.79,46.32 268.26,48.79 270.95,48.79 271.59,49.42 271.59,56.12 273.25,57.78 273.25,58.6 273.88,59.24 273.88,59.94 274.26,60.31 v1(275.21,60.31)
  IN2 w0.089: v1(161.36,85.4) 161.36,87.24 160.91,87.69 160.39,87.69 159.98,87.27 159.98,85.09 159.7,84.82 157.61,84.82 157.49,84.94 157.49,85.35 156.74,86.1 155.2,86.1 154.48,85.38 153.3,85.38 152.24,84.32 151.39,84.32 151.22,84.49 151.22,85.13 150.97,85.38 149.06,85.38 148.96,85.48 148.63,85.48 148.56,85.41 147,85.41 146.44,85.97 146.44,89.01 145.04,90.4 145.04,92.41
  IN2 w0.122: 145.04,92.41 145.04,104.14 144.14,105.04 137.88,105.04 137.13,104.29 136.2,104.29 135.46,105.04 120.86,105.04 119.19,106.71 114.92,106.71 112.97,108.65 105.76,108.65 103.8,110.61 90.59,110.61 89.65,109.67 88.83,109.67 88.58,109.42 88.12,109.42 87.29,108.59 82.7,108.59 82.1,108 67.37,108 67.32,107.94 66.33,107.94 63.28,104.9 62.01,104.9 61.46,105.44 60.83,105.44 60.32,105.94 v1(59.44,105.94) ; v1(277.96,76.27) 277.96,75.51 275.79,73.34 275.79,71.31 274.9,70.42 274.9,69.55 275.43,69.02 275.43,66.69 276.35,65.77 276.35,61.99 275.61,61.26 275.61,60.51 275.41,60.31 v1(275.21,60.31)
  BOTTOM w0.076: 158.56,85.98 155.35,85.98 154.82,85.45 154.04,85.45 UC1.CR10
  BOTTOM w0.102: 158.56,85.98 160.02,85.98 160.6,85.4 v1(161.36,85.4)
SYS_RESET#: length 191.1
  TOP w0.127: RC243.2 175.14,87.69 v1(175.84,86.99)
  IN1 w0.084: v1(161.93,85.34) 162.38,85.34 162.57,85.15 170,85.15 170.79,85.94 171.85,85.94 172.06,86.15 173.8,86.15 174.77,87.13 175.69,87.13 v1(175.84,86.99) 176.4,86.43 176.4,83.28 176.76,82.92 176.76,82.67 178.19,81.24 178.19,79.88 178.74,79.32 178.74,78.65 178.01,77.93 178.01,75.88 180.68,73.21 182.52,73.21 193.61,62.11 198.12,62.11 216.57,43.66 221.11,43.66 222.41,42.36 229.32,42.36 230,41.68 241.9,41.68 242.99,42.76 244.2,42.76 245.9,44.47 249.53,44.47 250.49,45.43 252.95,45.43 253.31,45.79 259.48,45.79 261.13,47.44 263.12,47.44 263.69,46.87 265.57,46.87 268.18,49.48 v1(271.12,49.48)
  IN4 w0.084: v1(271.12,49.48) 271.12,42.5 272.83,40.79 272.83,37.62 273.95,36.51 273.95,35.62 274.33,35.24 274.33,34.57 276.9,32 279.02,32 280.8,30.22 280.8,30.22 281.02,30 281.56,30 282.46,29.1 282.59,29.1 282.67,29.01 285.14,29.01 285.94,28.21 287.45,28.21 287.86,27.79 290.51,27.79 290.93,28.22 v1(291.63,28.22)
  BOTTOM w0.076: 158.64,85.79 155.4,85.79 154.88,85.28 153.85,85.28 153.74,85.32 153.5,85.32 153.39,85.28 153.2,85.28 153.09,85.32 152.98,85.32 UC1.CN10
  BOTTOM w0.102: 159.96,84.98 159.96,85.54 159.71,85.79 158.64,85.79
  BOTTOM w0.127: 159.96,84.98 159.96,84.83 160.22,84.58 CC302.1 161.93,85.01 v1(161.93,85.34) ; v1(291.63,28.22) 292.45,29.04 JAPS1.13
SYSPWR_PRES: length 6.8
  TOP w0.127: v2(270.38,72.93) 270.88,72.93 RE57.1 272.26,74.31 272.26,75.12 RE58.1 271.81,76.05 273.42,77.66 UE1.B1
SYSTEM_ID: length 24.3
  TOP w0.127: RE300.2 CE47.1 283.27,94.48 283.27,95.92 v2(283.4,96.06) 283.4,96.64 284.74,97.98 284.74,98.24 285.01,98.51 285.01,98.98 v1(284.61,99.37) ; UE1.J10 v1(279.41,85.35)
  IN3 w0.122: v1(284.61,99.37) 282.74,97.5 282.74,94.27 281.31,92.84 281.31,92.33 279.52,90.55 279.52,88.2 279.81,87.92 279.81,85.74 279.42,85.35 v1(279.41,85.35)
TACH_FAN1: length 145.6
  TOP w0.127: v1(275.45,78.98) UE1.E3 ; v3(195.59,84) 195.2,83.62 v1(195.2,83.06) 195.52,82.74 RE51.2
  IN2 w0.122: v1(261.49,66.36) 261.49,63.98 262.11,63.37 262.11,59.85 253.91,51.65 250.96,51.65 247.28,47.97 242.58,47.97 241.29,46.68 236.09,46.68 235.92,46.52 221.99,46.52 215.89,52.61 215.28,52.61 205.1,62.79 205.1,65.61 205,65.88 205,65.88 204.95,66.01 203.26,70.59 203.26,71.66 202.67,72.25 202.67,75.2 197.75,80.13 197.75,81.43 197.27,81.9 196.09,81.9 195.2,82.8 v1(195.2,83.06)
  IN4 w0.084: v1(275.45,78.98) 275.06,79.37 272.42,79.37 272.23,79.56 272.23,84.32 271.35,85.2 268.35,85.2 267.47,84.32 267.47,84 265.81,82.34 265.81,75.74 267.13,74.42 267.8,74.42 268.17,74.05 268.17,73.02 267.67,72.52 267.67,69.38 266.94,68.65 264.28,68.65 262,66.36 v1(261.49,66.36)
  BOTTOM w0.127: JFAN1.3 193.41,81.9 194.57,83.06 v1(195.2,83.06)
TBT_A_TRX_C_DTX_N0: length 6.2
  TOP w0.203: JUSBC1.A10 8,83.97 arc(8.04,83.97) 8.07,83.94 8.11,83.91 arc(8.14,83.89) 8.18,83.88 8.35,83.88 arc(8.76,83.71) 8.93,83.29 8.93,83.29 arc(9.25,82.54) 10,82.23 11.58,82.23 arc(11.73,82.25) 11.85,82.34 RT220.1 12.01,82.44 arc(12.13,82.37) 12.26,82.34 12.27,82.34 arc(12.45,82.38) CT327.2
TBT_A_TRX_C_DTX_N1: length 6.6
  TOP w0.156: v1(6.7,87.77) 6.65,87.72 JUSBC1.B10
  BOTTOM w0.203: v1(6.7,87.77) 6.72,87.75 6.72,87.75 arc(6.79,87.8) 6.87,87.81 7.54,87.81 arc(8.03,87.91) 8.44,88.19 9.05,88.79 arc(9.51,89.1) 10.06,89.21 10.84,89.21 arc(11.05,89.17) RT222.1 11.23,89.06 11.35,89.18 arc(11.41,89.22) 11.49,89.24 11.55,89.24 arc(11.58,89.23) 11.62,89.23 arc(11.67,89.2) 11.72,89.16 CT329.2
TBT_A_TRX_C_DTX_P0: length 6.2
  TOP w0.203: CT326.2 12.49,81.96 arc(12.44,82) 12.38,82.03 arc(12.34,82.03) 12.31,82.04 12.25,82.04 arc(12.17,82.02) 12.11,81.98 11.99,81.86 RT219.1 arc(11.91,81.9) 11.82,81.92 10,81.92 arc(9.03,82.32) 8.63,83.29 8.63,83.29 arc(8.55,83.49) 8.35,83.57 8.18,83.57 arc(8.14,83.56) 8.11,83.54 8.07,83.51 arc(8.04,83.48) 8,83.47 JUSBC1.A11
TBT_A_TRX_C_DTX_P1: length 6.6
  TOP w0.156: JUSBC1.B11 6.43,88.22 arc(6.58,88.25) v1(6.7,88.34)
  BOTTOM w0.203: v1(6.7,88.34) arc(6.94,88.18) 7.23,88.12 7.54,88.12 arc(7.91,88.19) 8.23,88.4 8.84,89.01 arc(9.4,89.38) 10.06,89.52 10.84,89.52 arc(11.05,89.56) RT221.1 11.25,89.64 arc(11.37,89.57) 11.5,89.54 11.51,89.54 arc(11.69,89.58) CT328.2
TBT_A_TRX_DTX_N0: length 3.1
  BOTTOM w0.076: UT1.A21 21.81,73.33 arc(21.93,73.44) 21.81,73.56 21.55,73.56 arc(21.51,73.55) 21.47,73.53 21.43,73.49 arc(21.41,73.47) 21.38,73.46
  BOTTOM w0.203: RT191.1 19.6,72.7 19.68,72.63 arc(19.77,72.56) 19.89,72.54 19.95,72.54 arc(20.04,72.56) 20.12,72.61 20.83,73.32 arc(20.99,73.43) 21.17,73.46 21.38,73.46
TBT_A_TRX_DTX_N1: length 4.3
  BOTTOM w0.076: UT1.B15 22.06,75.97 arc(21.94,75.89) 21.79,75.86 21.62,75.86 arc(21.44,75.89) 21.29,75.99 21.17,76.11 arc(21.14,76.14) 21.11,76.16 21.07,76.19 20.98,76.18 20.96,76.2
  BOTTOM w0.203: 20.96,76.2 20.82,76.33 arc(20.7,76.52) 20.66,76.74 20.66,77.62 arc(20.64,77.71) 20.58,77.79 20.34,78.03 arc(20.2,78.13) 20.03,78.16 19.9,78.16 arc(19.8,78.14) 19.72,78.09 RT195.1
TBT_A_TRX_DTX_P0: length 3.1
  BOTTOM w0.076: UT1.B21 22.06,73.21 arc(21.94,73.13) 21.79,73.1 21.65,73.1 arc(21.56,73.12) 21.49,73.17 21.49,73.17 arc(21.44,73.2) 21.39,73.22 21.38,73.16
  BOTTOM w0.203: 21.38,73.16 21.19,73.16 arc(21.11,73.14) 21.04,73.1 20.34,72.4 arc(20.16,72.27) 19.94,72.23 19.85,72.23 arc(19.71,72.21) RT190.1
TBT_A_TRX_DTX_P1: length 4.3
  BOTTOM w0.076: UT1.A15 21.83,76.09 arc(21.94,76.2) 21.83,76.32 21.55,76.32 arc(21.51,76.31) 21.47,76.29 21.46,76.28 arc(21.43,76.25) 21.39,76.24 21.35,76.24 arc(21.3,76.26) 21.25,76.29 21.17,76.34 21.16,76.43 21.16,76.43
  BOTTOM w0.203: 21.16,76.43 21.04,76.54 arc(20.98,76.63) 20.96,76.74 20.96,77.62 arc(20.92,77.83) 20.8,78.01 20.56,78.25 arc(20.32,78.41) 20.03,78.47 19.79,78.47 arc(19.69,78.49) RT194.1
TBT_A_TRX_R_DTX_N0: length 14.2
  TOP w0.203: v1(18.23,72.7) 18.1,72.57 17.79,72.57 arc(17.55,72.62) 17.35,72.75 16.74,73.37 arc(16,74.47) 15.74,75.78 15.74,81.09 arc(15.37,81.97) 14.49,82.34 14.34,82.34 arc(14.11,82.39) DT14.1 13.78,82.38 arc(13.68,82.32) 13.57,82.3 13.51,82.3 arc(13.5,82.3) 13.49,82.3 arc(13.38,82.32) 13.29,82.38 CT327.1
  BOTTOM w0.203: RT191.2 18.88,72.56 18.37,72.56 v1(18.23,72.7)
TBT_A_TRX_R_DTX_N1: length 15.7
  BOTTOM w0.203: CT329.1 arc(12.59,89.15) 12.78,89.19 12.85,89.19 arc(12.96,89.17) 13.04,89.11 DT10.1 13.2,89.01 13.32,89.12 arc(13.41,89.19) 13.53,89.21 14.01,89.21 arc(14.28,89.16) 14.52,89 15.06,88.46 arc(15.35,88.03) 15.45,87.52 15.45,86.52 arc(15.53,86.13) 15.75,85.8 16.38,85.17 arc(16.54,84.94) 16.59,84.66 16.59,79.65 arc(16.67,79.26) 16.89,78.93 17.42,78.4 arc(17.68,78.22) 17.99,78.16 18.56,78.16 arc(18.81,78.11) RT195.2
TBT_A_TRX_R_DTX_P0: length 14.2
  TOP w0.203: v1(18.23,72.12) 18.14,72.21 arc(18.07,72.25) 17.99,72.27 17.79,72.27 arc(17.43,72.34) 17.14,72.54 16.53,73.15 arc(15.72,74.36) 15.44,75.78 15.44,81.09 arc(15.16,81.76) 14.49,82.04 14.28,82.04 arc(14.15,82.01) 14.04,81.94 DT13.1 13.81,81.91 arc(13.72,81.97) 13.62,81.99 13.54,81.99 arc(13.35,81.95) CT326.1
  BOTTOM w0.203: v1(18.23,72.12) 18.37,72.26 18.89,72.26 RT190.2
TBT_A_TRX_R_DTX_P1: length 15.7
  BOTTOM w0.203: CT328.1 12.52,89.58 arc(12.62,89.52) 12.73,89.5 arc(12.74,89.5) 12.75,89.5 12.8,89.5 arc(12.92,89.52) 13.02,89.59 DT9.1 13.27,89.6 arc(13.36,89.54) 13.48,89.52 14.01,89.52 arc(14.4,89.44) 14.73,89.22 15.28,88.67 arc(15.63,88.14) 15.75,87.52 15.75,86.52 arc(15.81,86.25) 15.96,86.02 16.6,85.38 arc(16.82,85.05) 16.9,84.66 16.9,79.65 arc(16.95,79.38) 17.11,79.15 17.64,78.61 arc(17.8,78.5) 17.99,78.47 18.83,78.47 arc(18.93,78.49) RT194.2
TBT_A_TTX_C_DRX_N0: length 7.5
  TOP w0.156: v1(6.74,83.88) 6.7,83.91 arc(6.36,84.14) JUSBC1.B3
  BOTTOM w0.203: v1(6.74,83.88) 6.88,83.73 arc(6.95,83.69) 7.03,83.67 7.47,83.67 arc(7.8,83.61) 8.08,83.42 8.5,83.01 arc(8.73,82.85) 9,82.8 10.13,82.8 arc(10.26,82.77) 10.36,82.7 10.69,82.37 arc(10.84,82.27) 11.02,82.24 11.67,82.24 arc(11.74,82.25) 11.81,82.3 RT489.1 12.01,82.44 arc(12.13,82.37) 12.26,82.34 12.27,82.34 arc(12.45,82.38) CT96.2
TBT_A_TTX_C_DRX_N1: length 5.4
  TOP w0.203: JUSBC1.A3 8,87.47 8.1,87.57 8.33,87.57 arc(8.66,87.71) 8.8,88.05 arc(9.13,88.84) 9.93,89.17 10.93,89.17 arc(11.09,89.14) RT490.1 11.23,89.06 11.35,89.18 arc(11.41,89.22) 11.49,89.24 11.55,89.24 arc(11.58,89.23) 11.62,89.23 arc(11.67,89.2) 11.72,89.16 CT98.2
TBT_A_TTX_C_DRX_P0: length 7.5
  TOP w0.156: v1(6.72,83.3) 6.72,83.35 6.62,83.45 arc(6.31,83.65) JUSBC1.B2
  BOTTOM w0.203: CT95.2 12.49,81.96 arc(12.44,82) 12.38,82.03 arc(12.34,82.03) 12.31,82.04 12.25,82.04 arc(12.17,82.02) 12.11,81.98 11.99,81.86 RT488.1 arc(11.89,81.91) 11.79,81.93 11.02,81.93 arc(10.72,81.99) 10.47,82.16 10.2,82.43 arc(10.13,82.48) 10.06,82.49 9,82.49 arc(8.61,82.57) 8.28,82.79 7.86,83.21 arc(7.73,83.3) 7.57,83.35 7.37,83.36 arc(7.32,83.37) 7.28,83.37 6.89,83.37 arc(6.8,83.35) v1(6.72,83.3)
TBT_A_TTX_C_DRX_P1: length 5.4
  TOP w0.203: JUSBC1.A2 8.02,87.97 8.12,87.88 8.33,87.88 arc(8.45,87.93) 8.49,88.05 arc(8.91,89.06) 9.93,89.48 10.8,89.48 arc(10.91,89.5) 11,89.56 11.11,89.67 RT491.1 11.25,89.64 arc(11.37,89.57) 11.5,89.54 11.51,89.54 arc(11.69,89.58) CT97.2
TBT_A_TTX_DRX_N0: length 2.8
  BOTTOM w0.076: 21.11,74.33 21.12,74.32 21.2,74.29 21.29,74.32 21.48,74.4 arc(21.57,74.46) 21.66,74.48 21.79,74.48 arc(21.94,74.45) 22.06,74.37 UT1.B19
  BOTTOM w0.203: RT193.1 19.75,74.51 arc(19.81,74.46) 19.89,74.45 20.34,74.45 arc(20.44,74.44) 20.53,74.4 arc(20.55,74.38) 20.57,74.37 arc(20.64,74.34) 20.71,74.33 21.11,74.33
TBT_A_TTX_DRX_N1: length 3.4
  BOTTOM w0.076: UT1.B17 22.06,75.05 arc(21.94,74.97) 21.79,74.94 21.65,74.94 arc(21.55,74.96) 21.47,75.01 21.46,75.02 arc(21.37,75.08) 21.28,75.1 arc(21.23,75.1) 21.19,75.11 21.19,75.11 21.12,75.04 20.89,75.05
  BOTTOM w0.203: 20.89,75.05 20.88,75.05 arc(20.66,75.09) 20.48,75.22 20.32,75.37 arc(20.23,75.51) 20.2,75.67 20.2,75.88 arc(20.14,76.03) 19.99,76.09 19.87,76.09 arc(19.79,76.08) 19.73,76.03 RT197.1
TBT_A_TTX_DRX_P0: length 2.8
  BOTTOM w0.076: UT1.A19 21.81,74.25 arc(21.93,74.13) 21.81,74.02 21.59,74.02 arc(21.55,74.03) 21.52,74.05 21.47,74.1 arc(21.42,74.12) 21.37,74.12 21.25,74.07 21.24,74.03 21.21,74.02
  BOTTOM w0.203: 21.21,74.02 20.71,74.02 arc(20.55,74.04) 20.41,74.11 arc(20.35,74.13) 20.3,74.14 19.96,74.14 arc(19.78,74.1) RT192.1
TBT_A_TTX_DRX_P1: length 3.4
  BOTTOM w0.076: 20.9,75.35 21.05,75.35 arc(21.12,75.33) 21.19,75.29 21.19,75.28 arc(21.24,75.28) 21.29,75.28 21.38,75.28 21.45,75.34 arc(21.51,75.38) 21.58,75.4 21.81,75.4 arc(21.93,75.28) 21.81,75.17 UT1.A17
  BOTTOM w0.203: RT196.1 19.64,76.54 arc(19.75,76.46) 19.87,76.41 arc(19.93,76.4) 19.99,76.4 arc(20.35,76.25) 20.5,75.88 20.5,75.67 arc(20.51,75.63) 20.54,75.59 20.68,75.44 arc(20.78,75.38) 20.9,75.35
TBT_A_TTX_R_DRX_N0: length 12.4
  BOTTOM w0.203: CT96.1 13.29,82.38 arc(13.38,82.32) 13.49,82.3 arc(13.5,82.3) 13.51,82.3 13.57,82.3 arc(13.68,82.32) 13.78,82.38 DT6.1 14.04,82.39 arc(14.15,82.32) 14.28,82.29 14.52,82.29 arc(15.35,81.95) 15.69,81.12 15.69,76.56 arc(15.81,75.97) 16.14,75.48 16.73,74.88 arc(17.11,74.63) 17.56,74.54 18.81,74.54 arc(18.93,74.57) RT193.2
TBT_A_TTX_R_DRX_N1: length 18.3
  TOP w0.203: CT98.1 arc(12.59,89.15) 12.78,89.19 12.85,89.19 arc(12.96,89.17) 13.04,89.11 DT18.1 13.3,89.16 arc(13.39,89.22) 13.49,89.26 arc(13.54,89.27) 13.59,89.27 14.13,89.27 arc(14.4,89.22) 14.63,89.07 15.49,88.2 arc(15.65,87.97) 15.7,87.7 15.7,86.25 arc(15.78,85.87) 16,85.54 16.32,85.22 arc(16.47,84.99) 16.53,84.71 16.53,77.17 arc(16.61,76.78) 16.83,76.46 16.96,76.32 arc(17.23,76.14) 17.54,76.08 17.8,76.08 arc(18,76.04) v1(18.17,75.93)
  BOTTOM w0.203: v1(18.17,75.93) 18.23,75.93 18.37,76.07 18.9,76.07 RT197.2
TBT_A_TTX_R_DRX_P0: length 12.4
  BOTTOM w0.203: RT192.2 arc(18.77,74.18) 18.46,74.24 17.56,74.24 arc(17,74.35) 16.52,74.67 15.92,75.26 arc(15.53,75.86) 15.39,76.56 15.39,81.12 arc(15.13,81.73) 14.52,81.99 14.35,81.99 arc(14.25,81.97) 14.17,81.91 14.06,81.81 DT5.1 13.81,81.91 arc(13.72,81.97) 13.62,81.99 13.54,81.99 arc(13.35,81.95) CT95.1
TBT_A_TTX_R_DRX_P1: length 18.3
  TOP w0.203: CT97.1 12.52,89.58 arc(12.62,89.52) 12.73,89.5 arc(12.74,89.5) 12.75,89.5 12.8,89.5 arc(12.92,89.52) 13.02,89.59 DT17.1 13.21,89.66 arc(13.3,89.6) 13.4,89.58 14.13,89.58 arc(14.52,89.5) 14.84,89.28 15.71,88.42 arc(15.93,88.09) 16.01,87.7 16.01,86.25 arc(16.06,85.98) 16.22,85.75 16.54,85.43 arc(16.76,85.1) 16.83,84.71 16.83,77.17 arc(16.89,76.9) 17.04,76.67 17.18,76.53 arc(17.34,76.42) 17.54,76.38 17.86,76.38 arc(18.03,76.42) v1(18.17,76.51)
  BOTTOM w0.203: RT196.2 18.93,76.45 arc(18.84,76.39) 18.73,76.37 18.37,76.37 18.23,76.51 v1(18.17,76.51)
TBT_CIO_PLUG_EVENT#: length 260.9
  TOP w0.127: RT391.1 32.96,90.8 32.71,90.54 32.71,89.53 v1(33.15,89.08)
  IN1 w0.122: v1(32.33,86.73) 33.15,87.56 v1(33.15,89.08)
  IN2 w0.122: v1(32.33,86.73) 32.26,86.73 31.76,86.23 31.76,85.01 30.98,84.23 30.98,84.03 30.59,83.64 v1(30.59,83.46)
  IN3 w0.122: v1(30.59,83.46) 31.32,83.46 31.82,83.96 31.82,84.61 31.95,84.73 35.4,84.73 35.77,84.36 36.13,84.36 36.95,83.54 36.95,78.77 37.86,77.86 37.86,76.3 37.01,75.45 37.01,69.63 35.58,68.21 34.54,68.21 33.47,69.27 26.11,69.27 25.68,68.84 25.68,64.55 26.43,63.81 26.43,60.67 25.15,59.39 25.15,56.7 24.76,56.3 24.51,56.3 24.28,56.08 24.28,55.96 23.12,54.79 23.12,52.32 22.49,51.68 22.49,48.65 21.09,47.26 21.09,46.01 20.02,44.95 20.02,35.7 17.66,33.33 17.66,29.69 19.02,28.33 v1(19.02,27.58) ; v1(154.43,66.72) 152.63,66.72 151.85,65.93 151.85,63.86 151.42,63.43 151.42,62.11 150.69,61.38 150.34,61.38 146.28,57.33 144.28,57.33 144.1,57.33 140.74,60.68 140.74,62.2 140.27,62.68 139.61,62.68 139.49,62.56 139.49,59.51 133.97,53.99 91.08,53.99 87,49.9 83.19,49.9 82.29,49.01 61.44,49.01 60.84,48.4 54.62,48.4 54.01,49.01 v1(54.01,49.75)
  IN4 w0.084: v1(19.02,27.58) 20.39,27.58 24.12,31.32 25.59,31.32 27.1,32.83 27.1,33.63 28.95,35.48 30.85,35.48 31.16,35.17 35.78,35.17 41.04,40.43 41.04,41.33 43.21,43.49 46.69,43.49 48.47,45.27 48.47,46.03 49.3,46.86 50.06,46.86 52.96,49.75 v1(54.01,49.75)
  BOTTOM w0.076: UT1.W2 30.22,82.29 30.23,82.29 30.23,82.79 30.59,83.15 v1(30.59,83.46)
  BOTTOM w0.089: UC1.CL36 151.73,68.83 151.73,68.25 152.14,67.84
  BOTTOM w0.114: v1(154.43,66.72) 153.26,66.72 152.14,67.84
  BOTTOM w0.127: v1(32.33,86.73) 32.26,86.73 32.2,86.67 RT371.1
TBT_DET#: length 12.7
  IN1 w0.084: v1(159.43,77.52) 159.43,77.1 159.51,77.02 160.85,77.02 v1(161.36,77.53)
  BOTTOM w0.076: 155.92,78.54 155.88,78.5 154.97,78.5 154.75,78.28 154.68,78.21 154.36,78.21 154.17,78.41 153.79,78.41 153.59,78.3 152.4,78.3 UC1.CM22
  BOTTOM w0.102: 155.92,78.54 158.4,78.54 v1(159.43,77.52)
  BOTTOM w0.127: RC401.1 RC400.1 161.8,77.97 v1(161.36,77.53)
TBT_DP_RBIAS: length 8
  TOP w0.076: v1(32.63,80.4) 32.95,80.4 v2(33.38,79.97)
  TOP w0.127: v1(32.63,80.4) 32.39,80.16 RT35.2
  IN3 w0.122: v1(32.63,80.4) 32.34,80.4 31.3,79.36 29.48,79.36 28.58,80.26 28.27,80.26 v1(27.75,79.74)
  BOTTOM w0.127: UT1.N6 v1(27.75,79.74)
TBT_FORCE_PWR: length 224.2
  TOP w0.127: RT27.1 22.54,86.35 23.11,85.78 23.11,83.38 24.5,81.99 v1(24.5,81.04) ; v1(55.81,49.85) v2(55.81,50.64)
  IN1 w0.084: v1(24.5,81.04) 24.5,81.39 25.22,82.1 27.94,82.1 28.19,82.35 30.12,82.35 31.11,81.36 31.11,73.57 30.59,73.05 26.28,73.05 25.74,72.51 25.74,70.38 25.06,69.7 25.06,64.11 26.89,62.29 26.89,61.75 28.56,60.07 28.56,56.15 29.07,55.64 29.07,54.6 30.14,53.53 30.29,53.53 31.2,52.63 31.2,48.97 30.49,48.27 30.49,43.23 29.67,42.4 29.67,35.43 v1(29.35,35.11)
  IN3 w0.122: v1(149.59,75.4) 149.59,75.2 149.79,75 149.79,70.98 147.31,68.5 147.31,65.43 146.9,65.02 146.11,65.02 145.99,65.14 145.99,66.22 143.49,68.73 142.37,68.73 141.7,69.4 135.03,69.4 132.5,66.87 132.5,57.52 131.65,56.67 82.68,56.67 80.63,54.62 73.96,54.62 72.35,53.01 70.41,53.01 69.62,53.79 61.99,53.79 60.65,52.45 60.11,52.45 58.62,50.97 56.6,50.97 55.81,50.17 v1(55.81,49.85)
  IN4 w0.084: v1(29.35,35.11) 29.53,35.28 30.45,35.28 31.14,34.59 35.47,34.59 41.23,40.35 41.23,41.25 43.28,43.31 46.76,43.31 48.65,45.2 48.65,45.95 49.37,46.67 50.45,46.67 53.03,49.25 54.08,49.25 54.32,49.48 54.32,49.53 54.64,49.85 v1(55.81,49.85)
  BOTTOM w0.089: UC1.CG25 v1(149.59,75.4)
  BOTTOM w0.127: v1(24.5,81.04) UT1.H4
TBT_I2C_SCL: length 52.7
  IN1 w0.084: v1(32.84,54.99) 32.67,54.82 32.55,54.82 32.43,54.94 31.53,54.94 29.42,57.04 29.42,60.43 27.75,62.11 27.75,62.79 26.74,63.79 26.74,64.33 25.92,65.14 25.92,69.35 28.77,72.19 31.32,72.19 32.02,72.89 32.02,82.05 32.71,82.74 32.71,83.62 32.9,83.81 32.9,84.77 32.39,85.27 29.48,85.27 28.72,86.04 28.72,87.02 v1(28.9,87.2)
  IN2 w0.122: v1(28.9,87.2) 28.7,87 28.7,86.65 29.37,85.98 29.37,83.59 29.09,83.31 v1(29.09,83.18)
  BOTTOM w0.076: UT1.U2 29.3,82.29 29.3,82.97 v1(29.09,83.18) ; v1(32.84,54.99) 32.38,54.99 32.26,55.11 32.26,55.62 32.52,55.88 32.52,56.12 32.27,56.37 UT5.D2
  BOTTOM w0.127: v1(28.9,87.2) 28.77,87.07 28.77,86.8 28.9,86.67 RT19.1
TBT_I2C_SDA: length 52.5
  IN1 w0.084: v1(32.84,54.41) 32.64,54.61 32.47,54.61 32.35,54.73 31.44,54.73 29.21,56.96 29.21,60.34 27.54,62.02 27.54,62.7 26.53,63.71 26.53,64.24 25.71,65.06 25.71,69.43 28.68,72.4 31.23,72.4 31.81,72.98 31.81,82.14 32.5,82.82 32.5,83.71 32.69,83.9 32.69,84.68 32.3,85.06 29.39,85.06 28.51,85.95 28.51,87.02 v1(28.32,87.2)
  IN2 w0.122: v1(28.98,83.75) 28.84,83.9 28.84,86.16 28.45,86.54 28.45,87.07 v1(28.32,87.2)
  BOTTOM w0.076: UT5.D1 32.27,55.86 32.1,55.69 32.1,55.04 32.45,54.69 32.47,54.69 32.75,54.41 v1(32.84,54.41) ; v1(28.98,83.75) 28.73,83.5 28.73,82.96 29.08,82.62 UT1.U1
  BOTTOM w0.127: RT18.1 28.33,86.67 28.52,86.86 28.52,87.01 v1(28.32,87.2)
TBT_JTAG_TCK: length 1.5
  TOP w0.127: v1(28.4,81.04) 28.8,81.44 28.8,81.51 29.09,81.79 RT6.2
  BOTTOM w0.127: v1(28.4,81.04) UT1.T4
TBT_JTAG_TDI: length 1.4
  TOP w0.127: RT8.2 30.63,80.77 v1(30.35,81.05)
  BOTTOM w0.127: v1(30.35,81.05) 30.68,81.37 UT1.Y4
TBT_JTAG_TDO: length 2.2
  TOP w0.127: RT5.2 30.14,81.59 29.7,81.15 v1(29.7,81.04)
  BOTTOM w0.127: v1(29.7,81.04) UT1.W4
TBT_JTAG_TMS: length 3
  TOP w0.127: RT7.2 v2(30.17,82.16) v1(29.05,81.04)
  BOTTOM w0.127: v1(29.05,81.04) UT1.V4
TBT_PCIE_RBIAS: length 1.3
  TOP w0.076: v1(27.75,75.19) 28.29,74.66 RT34.1
  BOTTOM w0.112: UT1.N16 v1(27.75,75.19)
TBT_PERST#: length 45.8
  TOP w0.127: v1(24.39,62.92) 22.99,61.53 v2(22.99,49.18) 22.99,48.44 23.27,48.17 RT495.2 RT496.2
  IN2 w0.122: v1(25.8,81.04) 25.8,79.5 26.13,79.18 27.06,79.18 28.14,78.09 28.14,77.46 28.9,76.7 30.42,76.7 31.06,76.07 31.06,73.59 27.44,69.97 27.44,67.93 27.32,67.81 26.68,67.81 26.1,67.24 26.1,65.4 26.99,64.51 v1(27.18,64.51)
  BOTTOM w0.127: v1(24.39,62.92) 24.39,64.38 24.52,64.51 v1(27.18,64.51) ; UT1.L4 v1(25.8,81.04)
TBT_PERST#_R: length 4.8
  TOP w0.127: UT34.4 24.74,44.37 24.45,44.66 24.45,46.22 24.61,46.37 RT494.2 RT495.1 v2(23.86,47.89)
TBT_RESET_N_EC: length 372.7
  TOP w0.127: v1(272.14,71.3) 271.98,71.3 RE95.2 ; v1(38.13,71.72) 38.01,71.72 v2(37.43,71.14) ; v1(274.21,74.99) 274.21,75.81 275.02,76.62 UE1.D1
  IN1 w0.084: v1(283.06,71.15) 282.74,71.15 281.51,72.38 280.61,72.38 280.3,72.06 277.87,72.06 277.24,71.44 275.29,71.44 274.79,70.94 273.4,70.94 273.14,71.19 272.23,71.19 272.14,71.27 v1(272.14,71.3)
  IN2 w0.122: v1(38.13,71.72) 37.41,71 37.41,69.53 34.99,67.11 33.98,67.11 32.52,65.65 v1(32.52,65.09)
  IN3 w0.122: v1(38.13,71.72) 38.12,71.72 37.45,72.39 37.45,75.27 38.3,76.12 38.3,78.15 37.39,79.07 37.39,84.08 36.67,84.81 36.03,84.81 35.5,85.34 24.96,85.34 23.31,83.69 23.31,83.12 24.26,82.16 24.26,81.85 23.85,81.44 v1(23.85,81.04) ; v1(283.06,71.15) 283.06,70.51 282.33,69.78 282.33,68.71 281.26,67.64 281.26,66.1 281.58,65.78 281.58,62.61 281.67,62.52 281.67,61.74 282.42,60.99 282.42,56.94 281.35,55.88 281.35,54.74 280.32,53.7 278.42,53.7 277.18,52.46 276.33,52.46 276.03,52.16 276.03,51.36 275.58,50.91 275.2,50.91 273.16,48.86 273.16,47.37 272.94,47.16 272.94,43.67 269.71,40.44 265.05,40.44 262.87,38.26 261.22,38.26 259.61,36.65 258.96,36.65 258.23,35.93 256.52,35.93 255.75,35.16 251.64,35.16 251.07,34.59 250.71,34.59 250.51,34.79 245.91,34.79 245.22,34.1 237.46,34.1 237.04,34.53 225.15,34.53 224.88,34.79 220.8,34.79 219.08,36.51 215.02,36.51 210.37,41.16 207.79,41.16 205.03,43.91 201.48,43.91 200.24,45.15 196,45.15 195.4,44.55 154.36,44.55 153.72,43.91 141.95,43.91 138.02,47.84 95.5,47.84 93.43,45.77 84.24,45.77 83.97,45.5 68.01,45.5 67.83,45.33 60.3,45.33 59.96,44.99 58.68,44.99 58.47,45.21 53.12,45.21 49.17,49.16 49.17,51.34 48.94,51.57 44.13,51.57 43.25,52.44 42.68,52.44 41.54,51.3 41.54,50.98 40.71,50.16 39.56,50.16 37.73,52 37.73,52.51 39.06,53.84 39.06,54.67 36.17,57.56 36.17,63.27 35.82,63.62 35.82,64.32 35.31,64.83 32.78,64.83 v1(32.52,65.09)
  IN4 w0.084: v1(274.21,74.99) 272.74,74.99 272.14,74.39 v1(272.14,71.3)
  BOTTOM w0.127: RT110.2 31.9,64.07 32.66,64.07 32.92,64.33 32.92,64.69 v1(32.52,65.09) ; UT1.F4 v1(23.85,81.04)
TBT_ROM_CLK: length 29.3
  IN4 w0.084: v1(32.79,82.25) 33.44,82.25 33.79,82.61 33.79,83.8 34.16,84.17 34.16,84.17 34.24,84.26 36.9,84.26 37.42,83.74 v1(38.66,83.74)
  BOTTOM w0.076: UT1.AB4 31.38,81.15 31.61,81.38 32.03,81.38 32.36,81.71 32.49,82.03 32.72,82.25 v1(32.79,82.25)
  BOTTOM w0.127: UT2.6 41.44,70.19 41.72,69.91 42.92,69.91 43.3,70.29 43.3,72.35 37.9,77.75 37.9,82.44 37.66,82.68 37.66,83.38 38.02,83.74 v1(38.66,83.74)
TBT_ROM_CS#: length 15.1
  TOP w0.127: v1(38.33,82.71) 38,83.04 38,83.85 37.79,84.07 RT2.2
  IN2 w0.122: v1(38.33,82.71) 37.43,82.71 36.07,84.07 34.23,84.07 33.79,83.62 33.79,82.99 33.53,82.73 v1(33.08,82.73)
  BOTTOM w0.076: UT1.AC3 32.02,81.61 32.22,81.8 32.54,82.59 32.69,82.73 v1(33.08,82.73)
  BOTTOM w0.127: UT2.1 38.9,79.43 39.12,79.66 39.12,81.21 v2(38.73,81.6) 38.41,81.92 38.41,82.63 v1(38.33,82.71)
TBT_ROM_DI: length 24.6
  TOP w0.127: v2(39.22,75.44) 39.16,75.38 v1(38.13,75.38)
  IN2 w0.122: v1(33.15,83.29) 32.99,83.29 32.14,82.44 32.14,80.26 32.45,79.94 34.23,79.94 34.55,80.26 36.71,80.26 37.41,79.56 37.41,76.09 v1(38.13,75.38)
  BOTTOM w0.076: v1(33.15,83.29) 33.01,83.29 32.4,82.68 32.08,81.9 32.02,81.84 31.61,81.84 UT1.AB3
  BOTTOM w0.127: v1(38.13,75.38) 39.56,75.38 42.71,72.23 UT2.5
TBT_ROM_DO: length 15.3
  TOP w0.127: v1(38.83,82.45) 38.54,82.16 v2(38.04,82.16) 37.64,82.57 RT3.2
  IN2 w0.122: v1(38.83,82.45) 37.02,80.64 33.98,80.64 32.92,81.7 v1(32.74,81.7)
  BOTTOM w0.076: v1(32.74,81.7) 32.58,81.7 32.03,81.15 UT1.AC4
  BOTTOM w0.127: v1(38.83,82.45) 38.83,82.21 39.63,81.41 39.63,79.81 40.17,79.27 UT2.2
TBT_ROM_HOLD#: length 7.7
  TOP w0.127: RT1.1 39.22,74.38 38.78,74.82 v1(38.13,74.82) 37.82,74.82 37.48,74.48 v2(37.48,74.1)
  BOTTOM w0.127: v1(38.13,74.82) 38.97,74.82 40.17,73.62 UT2.7
TBT_ROM_WP#: length 23
  TOP w0.127: v1(39.39,82.42) 39.39,82.72 38.93,83.18 38.61,83.18 38.23,83.56 38.23,84.4 37.99,84.64 RT4.1
  IN2 w0.122: v1(32.96,86.35) 34.36,86.35 37.6,83.12 38.99,83.12 39.39,82.72 v1(39.39,82.42)
  IN4 w0.084: v1(29.66,83.24) 29.78,83.24 30.17,83.62 30.17,84.77 30.3,84.89 32.45,84.89 32.96,85.4 v1(32.96,86.35)
  BOTTOM w0.076: UT1.V1 29.54,83.06 29.66,83.18 v1(29.66,83.24)
  BOTTOM w0.127: UT2.3 41.44,79.1 40.12,80.43 40.12,81.69 v1(39.39,82.42)
TBT_RTD3_WAKE#: length 213.2
  TOP w0.127: v1(43.37,37.73) v2(42.68,37.73) ; v1(180.87,54.94) 181.22,54.94 182.23,55.95 RC454.2 182.25,56.37 182.06,56.56 RC95.1
  IN2 w0.122: v1(43.37,37.73) 42.69,38.41 40.99,38.41 39.32,40.08 39.32,42.27 38.6,42.99 38.6,45.06 39.96,46.43 v1(39.96,46.54)
  IN3 w0.122: v1(145.54,65.2) 145.49,65.2 143.9,66.8 143.57,66.8 141.21,69.15 135.09,69.15 132.72,66.78 132.72,57.42 131.74,56.45 82.77,56.45 80.72,54.4 74.06,54.4 72.44,52.78 70.32,52.78 69.53,53.57 62.08,53.57 60.57,52.06 v1(60.27,52.06)
  IN4 w0.084: v1(43.37,37.73) 43.87,37.73 52.5,46.36 54.44,46.36 56.46,48.38 58.93,48.38 60.27,49.72 v1(60.27,52.06) ; v1(40.35,61.5) 39.93,61.08 39.25,61.08 38.8,60.64 38.8,59.18 39.82,58.16 39.82,55.49 39.12,54.79 39.12,49.84 39.96,49 v1(39.96,46.54)
  IN4 w0.102: v1(180.87,54.94) 180.79,55.02 179.61,55.02 179.3,54.71 179.22,54.71 178.08,53.57 176.6,53.57 176.32,53.85 175.85,54.32 171.86,54.32 171.66,54.12 171.21,53.67 171.07,53.53 168.88,51.35 162.65,51.35 162.19,51.81 158.65,51.81 156.1,54.35 151.1,54.35 150.91,54.54 150.91,55.35 149.31,56.96 148.92,56.96 148.92,56.96 147.21,56.96 147.01,57.16 147.01,61.47 146.25,62.22 146.25,65.02 146.07,65.2 v1(145.54,65.2)
  BOTTOM w0.076: UC1.BV35 143.99,69.29 143.99,69.07 143.95,68.95 143.95,68.77 144.04,68.52 144.04,67.5 145.24,66.31 145.24,65.28 145.31,65.2 v1(145.54,65.2)
  BOTTOM w0.127: RT456.1 41.22,62.95 40.35,62.08 v1(40.35,61.5)
