# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_ALW2: length 333.5
  TOP w0.102: v3(194.8,96.27) 194.4,95.88 PR104.2
  TOP w0.381: PR860.1 46.03,88.88 v1(46.81,89.66)
  TOP w0.508: RE57.2 271.58,72.89 v1(271.05,72.36) ; PR104.2 194.66,95.03 v1(195.14,94.55)
  IN2 w0.508: v1(46.81,89.66) 46.81,91.43 45.01,93.22 45.01,94.37 46.31,95.67 46.31,98.21 47.91,99.81 v1(47.91,99.97) ; v1(178.84,93.06) 184.29,93.06 185.32,94.09 186.44,94.09 188.11,92.42 190.99,92.42 193.11,94.55 v1(195.14,94.55)
  IN3 w0.508: v1(271.05,72.36) 270.76,72.07 270.76,71.5 269.47,70.21 269.47,69.65 269.2,69.39 269.2,66.89 268.96,66.65 268.96,63.93 269.18,63.71 269.18,60.91 267.52,59.25 267.52,56.52 267.06,56.06 267.06,53.56 266.69,53.19 265.59,53.19 263.34,50.95 263.34,50.64 262.17,49.47 258.58,49.47 258.41,49.3 256.47,49.3 255.48,48.31 254.65,48.31 254.19,47.85 254.19,47.43 252.73,45.97 251.26,45.97 248.9,43.61 246.95,43.61 246.41,43.07 245.1,43.07 244.37,42.34 243.19,42.34 242.19,41.34 235.04,41.34 234.77,41.08 229.85,41.08 228.09,42.84 218.2,42.84 207.88,53.16 195.74,53.16 189.57,59.34 189.57,73.76 186.37,76.96 186.37,78.81 183.23,81.96 183.23,82.83 180.43,85.62 180.43,86.67 180.34,86.76 180.34,91.56 v1(178.84,93.06) 178.24,93.67 178.24,94.18 176.24,96.18 176.24,99.74 173.04,102.94 172.72,102.94 171.02,104.64 161.77,104.64 160.72,105.7 156.7,105.7 155.13,104.12 152.28,104.12 152.17,104.02 145.87,104.02 145.09,104.8 142.93,104.8 142.44,104.32 141.24,104.32 140.7,103.78 138.45,103.78 137.84,103.17 130.93,103.17 130.36,102.6 122.25,102.6 121.05,101.4 112.08,101.4 111.45,102.04 103.64,102.04 103.18,102.5 95.95,102.5 91.48,98.02 88.71,98.02 87.9,97.22 80.28,97.22 79.07,98.43 73.64,98.43 73.02,97.81 66.4,97.81 66.1,97.5 66.1,96.88 65.73,96.51 57.84,96.51 56.9,97.45 56.9,98.5 56.12,99.28 53.75,99.28 51.91,97.44 51.09,97.44 48.56,99.97 v1(47.91,99.97)
+3.3V_ALW_DSW: length 69.8
  TOP w0.254: v1(64.38,94.62) 64.24,94.48 RC241.2
  IN1 w0.508: v1(68.4,64.95) 68.4,67.32 68.17,67.55 68.17,70.55 68.67,71.06 68.67,92.07 68.04,92.7 65.84,92.7 64.38,94.16 v1(64.38,94.62)
  BOTTOM w0.2: UC1.BR24 v1(142.39,76.12) ; v1(143.04,77.8) UC1.BT23
  BOTTOM w0.203: v1(143.07,76.96) 142.72,77.31 UC1.BT23
  BOTTOM w0.508: RC555.2 168.4,65.96 167.76,65.32 v1(161.71,65.32) ; v1(68.4,64.95) 68.4,64.5 67.06,63.16 67.06,62.22 68.92,60.36 75.65,60.36 76.53,59.47 v1(88.84,59.47)
  vias: v3(161.84,63.71)
+3.3V_ALW_DSW_R:
  vias: v2(170.54,62)
+3.3V_ALW_PCH: length 410.6
  TOP w0.254: v1(146.77,54.47) 146.91,54.34 RC187.2
  TOP w0.356: RC866.2 148.37,77.93 v1(148.24,77.8)
  TOP w0.381: v1(169.32,68.49) 169.32,68.53 170.94,70.15 170.94,71.23 170.44,71.72 RC288.2 ; v1(140.12,58.91) 140.12,59.39 RC763.2 ; v1(49.98,104.64) 49.98,104.35 50.74,103.59 50.74,101.63 51.45,100.92 54.84,100.92 55.73,100.03 RC133.2
  TOP w0.508: RC344.2 158.78,55.55 v1(158.78,55.02) ; v1(154.44,50.67) 154.22,50.45 RC451.2 ; RC743.2 172.66,86.04 172.41,85.78 v1(172.22,85.78) 172.22,83.26 v1(172.74,82.73) ; RC73.2 152.42,62.8 v1(152.58,62.64) ; RC73.2 RC834.2 ; RC73.2 RC317.2 ; v1(294.07,26.54) 294.07,27.11 293.29,27.89 292.57,27.89 292.04,27.36 288.36,27.36 287.23,28.49 278.62,28.49 277.52,29.6 276.32,29.6 275.34,30.58 v1(275.34,30.79) ; v1(168.15,80.32) 168.19,80.36 RC277.2 ; RZ69.1 178.71,77.22 v1(178.59,77.34) ; v1(167.52,65.91) 167.52,64.68 167.54,64.66 RC440.2 ; v1(176.18,60.97) 176.46,60.69 RC831.1 ; v1(33.57,93.05) 33.24,92.72 RT391.2 ; RC248.2 v1(176.03,88.51) ; RC183.2 181.7,59.99 v1(181.71,59.99) 182.06,59.64 RC95.2
  TOP w1.016: 251.02,43.43 251.07,43.47 251.07,46.88 248.04,49.9
  IN1 w0.508: v1(33.57,93.05) 34.07,93.54 34.07,97.09 32.35,98.81 32.35,102.65 v1(34.99,105.29)
  IN2 w0.508: v1(34.99,105.29) 34.99,103.68 36.52,102.15 39.17,102.15 39.53,102.51 43.02,102.51 44.04,103.52 46.25,103.52 47.44,104.72 49.9,104.72 v1(49.98,104.64) ; v1(154.44,50.67) 155.01,50.67 158.78,54.44 v1(158.78,55.02) ; v1(165.42,106.39) 167.7,104.11 167.7,101.4 v1(167.7,101.4) ; v1(165.4,61.8) 164.66,62.54 160.18,62.54 159.81,62.91 152.85,62.91 v1(152.58,62.64)
  IN3 w0.508: v1(166.46,58.78) 167.11,59.43 168.28,59.43 169.82,60.97 v1(176.18,60.97) 180.73,60.97 v1(181.71,59.99) ; v1(140.12,58.91) 140.8,58.91 142.82,56.89 144.98,56.89 145.99,55.87 145.99,55.25 v1(146.77,54.47) 146.77,53.63 149.68,50.73 153.04,50.73 153.3,50.98 154.13,50.98 v1(154.44,50.67) ; v1(168.63,94.55) 168.61,94.57 168.61,95.68 167.67,96.62 167.67,97.89 168.1,98.32 168.1,98.89 167.7,99.28 v1(167.7,101.4) ; v1(49.98,104.64) 50.04,104.59 52.53,104.59 53.32,105.38 54.87,105.38 55.7,104.55 60.95,104.55 62.69,102.81 64.7,102.81 66.44,104.55 79.58,104.55 82.1,102.03 87.75,102.03 89.35,103.63 92.12,103.63 93.86,105.37 114.08,105.37 115.13,106.42 117.27,106.42 118.2,107.34 121.58,107.34 122.58,108.34 129.48,108.34 130.1,107.71 136.71,107.71 137.48,106.94 140.04,106.94 141.68,108.58 144.85,108.58 145.36,108.07 148.09,108.07 148.37,107.79 153.09,107.79 153.19,107.89 158.26,107.89 158.73,107.42 161.44,107.42 162.47,106.39 v1(165.42,106.39)
  IN3 w1.016: 196.67,70.29 196.67,67.28 195.87,66.48 195.87,63.37 198.68,60.56 206.38,60.56 219.85,47.1 239.69,47.1 240.26,47.67 241.78,47.67 242.89,48.78 245.75,48.78 246.67,49.7
  IN4 w0.508: v1(174.94,94.36) 174.55,93.97 169.21,93.97 v1(168.63,94.55)
  IN4 w1.016: 269.69,40.44 270.02,40.11 270.02,38.11 273.32,34.82 273.32,32.81 v1(275.34,30.79)
  BOTTOM w0.2: UC1.BP23 v1(141.74,76.96) ; UC1.CB16 v1(146.94,81.16)
  BOTTOM w0.203: v1(154.31,73.84) 153.82,73.84 UC1.CP29
  BOTTOM w0.254: UC1.BV23 v1(144.34,76.96) ; UC1.BW23 v1(144.99,76.96)
  BOTTOM w0.305: RC31.2 175.84,73.48 176.17,73.14 176.47,73.14 177.1,72.52 JSPI1.16
  BOTTOM w0.381: v1(168.63,94.55) 168.24,94.16 RC843.2 ; RC31.2 175.78,73.56 DC4.2 174.29,73.56 v1(174.28,73.57)
  BOTTOM w0.457: v1(175.81,82.32) 176.13,82 UC9.5
  BOTTOM w0.508: 165.14,82.8 165.77,83.43 RC744.2 ; 165.14,82.8 165.09,82.75 v1(165.09,81.83) ; 165.14,82.8 165.01,82.92 RC15.2 RC507.2 ; RC847.2 RC400.2 163.46,77.97 163.6,77.82 164.45,77.82 164.98,78.35 v1(164.98,78.48) ; RC748.2 v1(172.74,82.73) RC753.2 ; v1(164.29,74.99) 164.29,74.47 CC75.1 ; 169.93,84.7 171.14,85.91 172.09,85.91 v1(172.22,85.78) 172.35,85.66 RC557.2 ; 169.93,84.7 RC348.2 ; 169.93,84.7 169.41,85.22 RC347.2 ; v1(165.14,80.2) 165.14,79.8 164.84,79.5 163.32,79.5 RC266.2 ; 298.76,29.46 299.8,29.46 300.84,28.42 RC222.2 ; RC854.2 174.78,82.32 v1(175.81,82.32) ; RC101.1 RC537.2 v1(166,76.57) 166,76.97 166.5,77.48 RC830.2 ; RC443.2 167.72,74.1 167.72,74.41 167.46,74.67 v1(167.46,74.93) ; RC14.2 v1(173.5,78.1) ; RC829.2 168.87,78.94 v1(169.49,79.56) 169.49,79.22 170,78.71 RC12.2
  vias: v1(146.95,77.02) v1(147.59,77.8) v1(147.59,76.96) v1(148.24,76.96) v1(165.82,58.78) v1(167.52,80.32) v1(177.35,86.31) v1(178.89,89.94) v1(178.89,89.36) v1(196.41,71.3) v1(196.98,71.3) v1(246.83,50.6) v1(247.28,51.05) v1(249.03,38.35) v1(249.59,38.34) v1(268.93,40.89) v1(269.31,41.33) v1(294.07,25.9) v3(250.74,38.89)
+3.3V_ALW_PCH_UZ3: length 0.9
  TOP w0.127: 180.35,91.26 v3(181.26,91.26)
+3.3V_ALW_UE1: length 44.8
  TOP w0.127: v3(284.64,91) CE19.1
  TOP w0.203: 280.42,77.27 280.21,77.49 v1(280.21,78.07)
  TOP w0.254: UE1.H1 278.22,77.04 v1(279,76.26) 279.04,76.22 279.27,76.22 279.85,75.64 CE15.1 ; CE13.1 270.83,80.87 271.2,81.24 271.2,81.44 271.47,81.71 271.69,81.71 271.98,82 272.3,82 272.45,82.16 272.78,82.16 272.79,82.16 272.93,82.16 v1(272.99,82.22) 273.05,82.22 273.05,82.23 273.09,82.23 UE1.B7 ; UE1.K2 279.82,78.54 280.21,78.15 v1(280.21,78.07) ; 281.12,76.57 280.42,77.27
  TOP w0.33: UE1.M9 281.82,84.56 v1(281.82,84.58) ; UE1.G8 v1(277.06,83.72)
  TOP w0.381: CE14.1 270.01,80.87 CE13.1 ; 281.12,76.57 281.61,76.09 281.61,76.06 281.69,75.98 CE23.1
  IN3 w0.508: v1(277.06,83.72) 277.06,83.18 277.23,83.01 277.23,81.18 277.91,80.5 277.91,78.7 279,77.62 v1(279,76.26) 278.83,76.26 277.31,74.73 v1(277.31,72.96)
  IN4 w0.457: v1(277.06,83.72) 277.88,83.72 278.06,83.54 278.06,83.52 278.39,83.2 278.4,83.2 278.42,83.18 281.26,83.18 281.72,83.64 281.72,84.48 v1(281.82,84.58)
  IN4 w0.508: v1(272.99,82.22) 273.05,82.28 273.05,82.3 273.56,82.82 275.48,82.82 275.87,83.21 276.44,83.21 276.95,83.72 v1(277.06,83.72) ; v1(281.82,84.58) 281.82,86.54 283.32,88.04 283.65,88.04 284.04,88.43 v1(284.04,89.41)
  BOTTOM w0.508: v1(279,76.26) 279,76.86 v1(280.21,78.07)
+3.3V_ALW_UZ12: length 3.5
  TOP w0.127: v2(187.67,85.64) 187.46,85.64 187.05,86.05 185.92,86.05
  TOP w0.254: CZ51.1 185.6,84.45 184.91,83.76 UZ12.1
+3.3V_ALWP: length 19.7
  TOP w0.254: PU100.14 191.13,95.46 191.41,95.18 v1(192.09,95.18) ; v1(189.05,93.28) 189.3,93.02 190.43,93.02 190.67,93.26 PR108.2
  IN1 w0.254: v1(189.57,88.08) 189.72,88.08 190.05,88.41 190.05,89.08 189.3,89.83 189.3,93.02 v1(189.05,93.28)
  IN1 w0.508: v1(192.09,95.18) 189.38,95.18 188.41,94.22 188.41,89.85 v1(189.57,88.69)
  vias: v1(190.37,90.01) v1(190.37,89.44) v1(191,90.01) v1(191,89.44) v3(189.2,89.85)
+3.3V_CAM: length 8.7
  IN4 w0.508: v1(54.31,110.33) 54.31,110.75 54.71,111.15 60.42,111.15 v1(61.14,110.42)
  BOTTOM w0.203: JEDP1.11 61.43,110.82 61.14,110.53 v1(61.14,110.42)
  vias: v3(52.97,110.18) v3(53.21,111.88) v3(53.18,108.52)
+3.3V_FPBTN: length 65.8
  TOP w0.127: v1(308.6,98.65) v3(308.6,96.78)
  TOP w0.508: RE706.2 RE707.2 292.71,90.64 v1(292.63,90.56) ; v1(290.71,97.21) 290.67,97.21 RE708.2 ; v1(290.56,84.79) 290.68,84.67 RE709.2
  IN2 w0.254: v1(290.71,97.21) 291.31,97.82 292.46,97.82 293.19,97.09 298.4,97.09 299.45,98.15 300.95,98.15 302.32,99.51 308.2,99.51 308.6,99.1 v1(308.6,98.65)
  IN3 w0.254: v1(292.63,90.56) 292.63,92.15 291.24,93.54 291.24,96.68 v1(290.71,97.21)
  IN3 w0.508: v1(308.6,98.65) 308.37,98.42 308.37,96.6 308.91,96.07 311.37,96.07 312.59,97.29 v1(312.59,98.33) 312.77,98.15 313.87,98.15 314.41,98.69 314.41,99.58 313.42,100.58 313.42,102.91 312.61,103.73 v1(311.59,103.73)
  BOTTOM w0.254: v1(290.56,84.79) 291.56,85.79 291.56,87.36 292.94,88.75 292.94,90.24 v1(292.63,90.56) ; CZ309.1 308.09,97.54 DZ15.2 DZ15.8 308.09,94.84
  BOTTOM w0.305: v1(311.59,103.73) 311.66,103.8 JFPBTN1.14
  BOTTOM w0.381: 308.09,94.84 308.18,94.75 QZ18.1 307.64,94.23 RZ1391.1 307.65,93.68 307.87,93.68 308.26,93.29 RZ1390.1 ; v1(308.6,98.65) 308.29,98.33 CZ309.1 ; RZ1392.1 312.86,98.06 v1(312.59,98.33)
+3.3V_HDD_M2: length 0.8
  BOTTOM w0.508: RN37.1 v1(19.77,26.62)
  vias: v3(21.85,25.14) v3(24.07,25.2) v3(25.19,26.54)
+3.3V_MMI_AUX: length 4
  TOP w0.381: RR19.2 288.99,70.97 v2(289.32,71.3) RR3.1
+3.3V_MMI_IN: length 0.8
  TOP w0.127: 297.67,72.88 v3(298.47,72.88)
  vias: v1(291.66,63.47) v1(297.69,71.69) v1(298.08,72.19)
+3.3V_PDA_VOUT: length 2.6
  BOTTOM w0.076: UT5.H2 30.02,56.24 30.02,55.51 29.9,55.38
  BOTTOM w0.127: 29.9,55.38 29.58,55.07 CT83.1
+3.3V_RTC_LDO: length 166.4
  TOP w0.508: v1(232.82,44.72) 232.82,39.76 234.19,38.39 v3(234.19,37.73) 234.19,36.63 236.89,33.94 PD3.3 ; v1(193.94,93.28) 194.4,93.74 PR105.2 ; v1(287.85,42.03) 287.8,42.08 RA53.2
  IN1 w0.508: v1(262.94,57.98) 262.94,57.44 263.89,56.5 268.04,56.5 268.78,55.76 268.78,54.38 269.25,53.91 269.84,53.91 270.35,54.41 v1(270.35,54.6)
  IN3 w0.508: v1(193.94,93.28) 191.78,91.12 191.78,89.02 191.2,88.45 191.2,86.72 192.72,85.2 192.72,82.23 195.58,79.38 195.58,67.54 194.96,66.92 194.96,62.88 198.14,59.7 206.02,59.7 219.49,46.24 232.2,46.24 232.82,45.62 ; 232.82,45.62 233.2,45.99 239.8,45.99 240.2,46.39 243.77,46.39 244.68,47.31 246.36,47.31 251.28,52.23 252.72,52.23 255.69,55.19 257.68,55.19 260.47,57.98 v1(262.94,57.98) ; 232.82,45.62 v1(232.82,44.72)
  BOTTOM w0.508: v1(270.35,54.6) 270.4,54.6 271.74,53.27 274.07,53.27 274.52,52.83 274.52,51.3 276.68,49.14 276.68,47.94 277.25,47.36 284.03,47.36 284.79,46.6 285.88,46.6 286.56,45.93 286.56,42.75 287.28,42.03 v1(287.85,42.03)
+3.3V_RUN: length 551.6
  TOP w0.254: RV732.2 82.07,110.79 81.72,111.14 79.23,111.14 77.71,112.67 RV8.2
  TOP w0.356: FZ1.2 54.99,109.15 CA7.1 55.1,109.69 v1(55.1,110.42)
  TOP w0.381: RC567.2 181.24,59.37 v1(180.56,60.05) ; RD24.1 183.51,35.37 v1(183.93,35.37) ; v1(91.26,105.85) 91.19,105.78 RV99.1 ; v1(124.59,37.08) 124.44,36.93 RD4.1 ; RV325.2 94.86,109.14 94.49,108.77 94.49,108.15 95.16,107.49 RV734.2 95.19,106.8 v1(94.96,106.57) 94.96,104.5 QV20.3 ; v1(154.69,110.51) 154.69,110.43 155.08,110.04 RZ1422.2 ; RC513.2 RC512.2 v1(169.39,67.04) ; v1(102.88,29.51) 102.88,29.88 RD8.1 ; RD6.1 v1(126.56,37.24)
  TOP w0.508: v1(173.55,87.62) RC503.2 RC178.2 ; v1(262.83,89.97) 263.8,90.94 RE547.2 ; RD10.1 122.98,43.14 123.83,43.14 v1(124.3,42.67) ; v1(87.95,111.05) 89.76,112.87 101.17,112.87 101.66,112.38 RZ1476.2 102.58,112.01 102.89,112.31 RC435.1 ; RE48.1 195.59,81.33 RE51.1 196.41,81.65 v1(196.41,80.89) ; v1(9.98,52.32) v1(9.98,54.29) 9.98,54.67 11.18,55.87 14.29,55.87 14.87,56.45 RV19.2 ; v1(234.24,44.7) 234.24,40.38 v3(235.4,39.22) 235.59,39.03 239.53,39.03 241.1,37.46 241.1,35.58 241.47,35.21 243.01,35.21 243.34,35.54 243.34,38.7 243.62,38.98 244.86,38.98 246.67,37.17 ; v1(62.84,104.23) 62.84,102.68 61.51,101.36 61.51,100.74 61.09,100.32 RC137.2 ; v1(15.42,63.94) 15.42,64.65 RV20.2 15.54,65.95 QV5.2 ; v1(248.67,51.87) 249.18,51.37 249.18,50.35 251.4,48.13 252.86,48.13 253.43,47.56 253.43,44.05 252.22,42.83 252.22,36.27 253.43,35.05 254.96,35.05 256.06,33.94 256.06,30.48 256.75,29.8 260.46,29.8 260.63,29.97 264.61,29.97 ; v1(282.64,65.77) 282.63,65.78 RE67.2 ; v1(304.88,18.23) 299.48,18.23 298.14,16.88 294.48,16.88 291.14,20.23 v1(291.14,21.22) ; RV18.1 19.53,61.73 20.04,61.22 v1(20.04,60.19) ; RC502.2 RC176.2 153.55,102.05 v1(153.24,102.36) ; v1(193.31,82.77) 192.14,81.6 189.03,81.6 188.52,82.11 188.52,82.63 RZ362.1 ; PR612.1 58.77,58.21 v1(58.4,57.84)
  IN1 w0.508: 23.5,35.55 23.5,36.57 22.55,37.52 22.55,49.9 19.88,52.57 19.88,60.04 v1(20.04,60.19) ; v1(54.04,32.38) 54.08,32.42 54.08,35.72 61.09,42.73 71.15,42.73 78.31,49.89 v1(78.31,60.28)
  IN1 w1.016: v1(102.88,29.51) 102.88,28.92 v1(104.38,27.41)
  IN2 w0.508: v1(183.93,35.37) 183.79,35.23 183.79,31.6 184.24,31.15 190.98,31.15 192.15,32.32 198.34,32.32 199.78,33.76 199.78,34.92
  IN3 w0.508: v1(291.14,21.22) 290.96,21.39 289.69,21.39 289.12,21.96 289.12,24.19 285.06,28.25 280.8,28.25 279.46,29.6 277,29.6 276.7,29.29 266.9,29.29 266.33,29.86 v1(265.31,29.86) ; v1(9.98,54.29) 9.98,54.86 10.82,55.7 14.38,55.7 15.94,57.27 15.94,59.56 16.58,60.19 v1(20.04,60.19) ; v1(78.31,60.28) 78.31,59.63 75.13,56.45 74.11,56.45 72.21,58.35 69.73,58.35 67.89,56.51 64.14,56.51 62.05,58.6 59.89,58.6 59.13,57.84 v1(58.4,57.84)
  IN4 w0.381: v1(20.04,60.19) 16.14,60.19 15.94,60 15.06,60 14.44,60.62 14.44,61.16 14.87,61.59 14.87,63.62 15.18,63.94 v1(15.42,63.94)
  IN4 w1.016: 182.73,50.44 182.73,49.23 183.74,48.21 184.56,48.21 191.02,41.75 191.02,40.27 192.44,38.86 198.76,38.86 199.84,37.78 199.84,36.89
  BOTTOM w0.254: RC319.2 173.88,76.24 173.17,76.96 QC2.2 ; RC345.1 170.2,76.96 QC2.5 171.84,76.96 172.02,76.78 172.02,76.26 171.66,75.9 RC318.2
  BOTTOM w0.381: RC104.1 170.86,96.32 170.48,95.94 RC82.1 170.48,92.09 170.89,91.68 170.89,90.39 170.44,89.94 170.44,89.4 170.92,88.92 170.92,88.29 170.31,87.69 v1(170.31,87.43) ; QV3.5 v1(9.98,52.32) ; QV3.2 v1(9.98,54.29) ; v1(282.64,65.77) 282.9,65.77 283.28,66.16 283.28,66.79 283.66,67.17 284.18,67.17 284.87,66.48 288.55,66.48 289.06,65.97 289.06,62.41 288.17,61.53 288.17,60.49 v1(288.76,59.9)
  BOTTOM w0.508: RZ1391.2 306.37,93.05 305.9,93.52 v1(305.9,95.36) ; v1(170.31,87.43) 170.31,87.18 169.74,86.61 RC765.1 ; v1(153.24,102.36) 153.24,102.79 152.66,103.37 152.66,107.5 154.69,109.53 154.69,110.51 v1(154.69,110.51) ; v1(172.41,75.37) 172.18,75.14 RC318.2 ; RD19.2 90.3,65.88 89.43,65 80.15,65 78.83,63.68 78.83,60.79 v1(78.31,60.28) ; v1(173.32,81.21) RC749.2 ; v1(55.1,110.42) 55.1,110.07 54.45,109.42 54.45,107.2 55,106.65 55.82,106.65 58.24,104.23 v1(62.84,104.23) ; RA67.1 RA66.1 v1(304.88,18.23) ; v1(167.39,86.37) 166.96,85.94 RC766.1 166.9,85.53 166.9,85.41 166.77,85.29 RC764.1 ; v1(174.04,75.66) RC319.2
  BOTTOM w1.016: 54.34,33.33 54.34,41.82 56.01,43.49 124.07,43.49 ; v1(104.38,27.41) 105.41,27.41 106.16,26.66 116.27,26.66 117.61,28 126.88,28 129.17,30.28 129.61,30.28 131.21,31.88 131.21,35.73 128.4,38.54 127.13,38.54
  vias: v1(19.04,94.3) v1(19.61,94.3) v1(20.18,94.33) v1(20.76,94.33) v1(20.99,31.2) v1(20.99,30.63) v1(21.32,94.33) v1(21.29,30.12) v1(21.58,31.2) v1(21.58,30.63) v1(21.9,30.12) v1(24.83,34.86) v1(25.46,35.43) v1(25.46,34.86) v1(25.75,34.37) v1(26.04,35.43) v1(26.04,34.86) v1(32.58,94.29) v1(32.61,93.72) v1(33.08,95.14) v1(33.06,94.58) v1(33.08,94.02) v1(54.04,31.74) v1(89.24,108.56) v1(99.74,106.56) v1(100.3,106.56) v1(170.06,72.83) v1(170.57,58.76) v1(171.15,58.76) v1(172.81,59.84) v1(178.5,82.61) v1(178.8,82.09) v1(179.16,60.05) v1(179.67,63.65) v1(179.79,60.05) v1(180.3,63.65) v1(180.94,63.65) v1(181.57,63.65) v1(181.84,50.92) v1(182.32,51.22) v1(182.5,102.76) v1(182.95,102.31) v1(183.08,103.08) v1(183.27,101.78) v1(183.52,102.63) v1(183.84,102.17) v1(184.16,102.67) v1(184.47,102.17) v1(192.67,68.64) v1(192.67,67.94) v1(193.11,67.49) v1(193.17,68.26) v1(200.37,35.34) v1(200.37,34.78) v1(288.19,59.46) v1(288.19,58.82) v1(288.76,59.26) v1(295.09,78.29) v1(295.09,77.72) v1(297.12,50.67) v1(297.69,50.67)
+3.3V_RUN_AUDIO: length 53.7
  TOP w0.127: v1(300.17,49.46) v3(300.17,47.94)
  TOP w0.381: v1(273.34,45.32) 273.04,45.03 RA18.2 273.04,44.46 273.5,44 273.69,44 274.01,43.68 274.01,43.62 274.03,43.6 274.03,43.3 LA14.2 ; v1(275.53,46.98) 275.53,46.81 275.94,46.4 RA59.1 276.05,46.4 RA61.2
  TOP w0.508: CA67.1 CA68.1 v1(278.39,33.15) LA12.2 ; v1(273.82,38.54) 273.65,38.71 273.65,39.4 274.01,39.76 274.01,41.18 273.37,41.82 273.37,42.65 LA14.2
  IN2 w0.508: v1(275.53,46.98) 275.79,46.98 276.42,47.62 276.42,49.02 277.69,50.28 279.99,50.28 281.77,52.06 285.45,52.06 285.45,52.06 291.73,52.06 293.44,50.35 295.73,50.35 296.55,49.52 299.22,49.52
  IN4 w0.508: v1(273.34,45.32) 273.34,45.49 274.33,46.48 275.02,46.48 v1(275.53,46.98)
  BOTTOM w0.508: v1(273.82,38.54) 274.17,38.19 274.99,38.19 276.36,36.82 277.56,36.82 278.71,35.68 278.71,33.47 v1(278.39,33.15)
  vias: v1(300.74,49.46)
+3.3V_RUN_AUDIO_DVDD: length 1.4
  TOP w0.508: CA61.1 274.81,43.04 LA14.1
+3.3V_RUN_AUDIO_IO: length 4.7
  TOP w0.203: UA1.18 281.12,36.83 v2(280.23,35.94) 279.91,35.62 279.4,35.62 CA55.1
  TOP w0.254: CA55.1 279.38,35.27 279.41,35.25 CA56.1 278.79,34.8 278.74,34.85 LA12.1
+3.3V_RUN_AUDIO_UZ5:
  vias: v3(297.05,52.83)
+3.3V_RUN_CARD: length 8
  IN3 w1.016: 299.36,61.33 298.12,62.56 296.3,62.56 294.88,61.14 293.45,61.14 292.77,61.82
  vias: v1(292.28,63.33) v1(292.34,62.73) v1(299.03,59.81) v1(299.03,59.18) v3(299.69,59.49)
+3.3V_RUN_DIMM1: length 1.3
  BOTTOM w0.305: JDIMM1.255 122.96,40.41 v1(122.88,40.48)
  vias: v2(121.13,41.8)
+3.3V_RUN_DIMM2: length 1.4
  BOTTOM w0.305: v1(199.87,40.44) 199.85,40.44 200.16,40.14 200.16,39.23 JDIMM2.255
  vias: v3(200.45,40.71)
+3.3V_RUN_F: length 11.8
  TOP w0.127: v1(60.53,109.53) v2(60.53,110.07)
  TOP w0.457: v1(55.37,107.56) 54.98,107.18 FZ1.1 53.56,107.18 53.21,106.83 QZ1.3
  IN2 w0.508: v1(60.53,109.53) 59.46,108.46 55.74,108.46 55.37,108.08 v1(55.37,107.56)
  BOTTOM w0.203: v1(60.53,109.53) 60.52,109.54 60.52,110.48 61.03,110.99 JEDP1.10
+3.3V_RUN_R: length 5.9
  TOP w0.127: RC435.2 104.81,110.91 v3(104.08,111.64)
  BOTTOM w0.508: v1(106.72,111.2) 106.72,110.96 107.09,110.59 108.78,110.59 109.33,111.14 JASA1.4
+3.3V_RUN_UZ3:
  vias: v3(175.74,96.48)
+3.3V_SPI: length 50
  TOP w0.381: UC5.8 188.45,59.97 CC9.1 188.4,60.45 188.02,60.84 v2(187.48,60.84) 187.38,60.94 v1(186.49,60.94)
  IN2 w0.508: v1(173.55,73.32) 173.88,72.99 174.37,72.99 176.43,70.92 176.43,69.5 175.88,68.95 175.88,68.06 176.19,67.75 179.33,67.75 180.31,66.77 181.36,66.77 186.49,61.64 v1(186.49,60.94)
  IN3 w0.508: v1(173.23,75.69) 173.5,75.42 173.5,73.37 v1(173.55,73.32)
  BOTTOM w0.305: JSPI1.15 177.6,72.69 176.09,74.2 RC31.1
  BOTTOM w0.381: RC31.1 175.53,74.51 DC4.1 ; UC6.8 198.1,66.85 CC10.1 198.21,66.41 197.55,65.75 195.65,65.75 190.84,60.94 v1(186.49,60.94)
  BOTTOM w0.508: v1(173.55,73.32) 173.55,73.71 174.35,74.51 DC4.1
+3.3V_SSD:
  vias: v3(23.26,31.46)
+3.3V_TBT: length 17.8
  TOP w0.254: v1(24.5,78.44) 24.5,78.55 24.21,78.84 CT43.1
  IN3 w0.508: 22.55,82.48 22.61,82.54
  IN3 w0.762: 21.85,86.54 21.85,88.39 22.3,88.84 v1(22.46,88.84) ; 21.85,86.54 21.85,85.02 22.61,84.26 22.61,82.54 ; 21.85,86.54 22.01,86.71 24.41,86.71 24.83,86.29 29.79,86.29 30.68,87.18
  BOTTOM w0.203: v1(24.5,78.44) UT1.H9
  vias: v1(20.53,82.97) v1(20.48,82.39) v1(20.58,81.8) v1(21.01,82.2) v1(21.09,82.8) v1(31.44,87.31) v1(32.07,87.31) v3(31.27,86.67)
+3.3V_TBT_FLASH_R: length 27.3
  TOP w0.381: RT3.1 RT2.1 37.04,84.08 37.04,84.62 RT4.2 36.91,84.64 36.52,85.03 v1(36.52,85.2) ; v1(38.08,74.26) 38.25,74.1 RT1.2
  IN3 w0.381: v1(38.08,74.26) 38.38,74.26 38.66,74.54 38.66,78.3 37.75,79.21 37.75,84.3 36.85,85.2 v1(36.52,85.2) 35.43,86.29 33.79,86.29 33.14,86.94 33.14,87.46 v1(31.9,88.7)
  BOTTOM w0.381: CT1.1 38.42,69.98 38.9,70.46 UT2.8 38.9,71.75 39.38,72.23 39.38,73.53 38.64,74.26 v1(38.08,74.26)
  vias: v3(30.84,93.38)
+3.3V_TBT_LC: length 14.9
  TOP w0.254: v1(28.41,79.73) CT41.1
  TOP w0.381: 30.09,88.43 30.09,86.28
  IN3 w0.381: v1(28.41,79.73) 28.54,79.73 29.26,79.02 29.29,79.02 29.3,79.01 31.65,79.01 32.33,79.69 33.22,79.69 33.72,80.19 33.72,83.47 33.33,83.85 32.79,83.85 32.07,83.13 v1(32.07,82.92)
  BOTTOM w0.203: UT1.R6 v1(28.41,79.73)
  vias: v3(30.12,88.96)
+3.3V_TBT_S0: length 0.5
  BOTTOM w0.203: UT1.R13 28.09,76.82 v1(28.41,76.5)
  vias: v1(34.8,76.32) v1(35.25,75.94) v3(36.62,75.62)
+3.3V_TBT_SX: length 22.4
  TOP w0.127: v1(31.43,88.2) v3(32.52,88.2)
  TOP w0.356: CT42.1 23.87,79.76 v1(23.85,79.74)
  TOP w0.381: v1(33.72,87.12) 34.42,86.42 RT338.2 ; RT48.1 26.22,90.43 v1(26.74,89.91) 27.55,89.1 RT455.2 27.55,87.26 26.79,86.49 25.77,86.49 25.34,86.93 RT16.2 RT372.2 24.24,87.35 24.14,87.45 v1(24.14,88.05)
  BOTTOM w0.203: UT1.F8 v1(23.85,79.74)
  BOTTOM w0.254: v1(24.14,88.05) 24.07,87.98 RT20.2 RT17.2 ; RT18.2 27.4,87.2 28.45,88.26 29.36,88.26 29.62,88 29.62,86.69 RT19.2 RT371.2 31.08,87.04 30.99,87.13 30.99,87.76 v1(31.43,88.2)
+3.3V_TBTA_FLASH: length 127.1
  TOP w0.254: RT67.1 36.75,58.52 37.15,58.92 38.3,58.92 v1(38.55,58.67) ; RT76.2 27.94,56.14 27.67,55.87 27.67,53.05 27.35,52.74 v1(27.13,52.74)
  TOP w0.381: RT66.1 36.75,55.89 v1(38.07,54.57) ; 32.77,46.73 32.73,46.77 32.73,47.83 33,48.1 RT51.2 RT98.2 ; 32.77,46.73 v2(34.51,45) 34.87,44.63 35.82,44.63 36.52,45.33 RT52.2 36.8,45.16 36.9,45.06 36.9,45.03 37.34,44.59 37.34,44.51 37.38,44.47 RT53.2 ; 32.77,46.73 31.59,46.73 RT50.2 30.78,46.64 CT70.1 29.65,46.68 v1(29.61,46.71) ; RT107.2 33.92,53.27 33.29,52.65 RT106.2 32.77,52.32 32.47,52.01 v1(32.47,52)
  IN1 w0.508: 26.55,93.4 24.68,95.27 18.31,95.27 16.63,93.59 14.04,93.59 13.04,94.6 11.31,94.6 10.29,93.58 10.29,92.64 9.14,91.48 4.74,91.48 3.54,90.28 3.54,81.5 4.83,80.21 8.76,80.21 13.34,75.62 13.34,71.49 13.07,71.23 13.07,70.43 14.31,69.2 14.31,59.8 14.42,59.68 v1(14.42,54.79)
  IN3 w0.381: v1(38.07,54.57) 38.01,54.51 36.17,54.51 35.76,54.1 34.61,54.1 32.52,52 v1(32.47,52)
  IN4 w0.381: v1(38.07,54.57) 38.07,58.18 v1(38.55,58.67)
  IN4 w0.508: v1(27.13,52.74) 27.13,52.07 26.61,51.56 18.42,51.56 16.77,53.21 16.77,53.27 15.19,54.85 14.47,54.85 v1(14.42,54.79)
  BOTTOM w0.127: 30.6,54.39 30.6,54.54 30.92,54.85 30.92,55.3 30.77,55.45 UT5.G1
  BOTTOM w0.203: CT84.1 30.6,53.95 30.6,54.39
  BOTTOM w0.254: v1(27.13,52.74) 27.13,52.4 RT95.2 ; CT84.1 30.91,53.3 30.56,53.3 v1(30.28,53.02)
  BOTTOM w0.508: UT6.8 v1(29.61,46.71)
  vias: v1(27.12,93.66) v1(27.76,93.66)
+3.3V_TP: length 4.3
  BOTTOM w0.305: JKBTP1.12 250.58,33.65 v1(250.51,33.71)
  BOTTOM w0.508: RZ21.1 251.66,35.64 RZ117.1 RZ116.1 252.3,34.82 251.73,34.82 RZ20.1 250.94,34.95 v1(250.91,34.98)
  vias: v3(251.43,33.98)
+3.3V_VDD_DCIN: length 82.9
  TOP w0.254: PR33.1 54.53,91.35 54.74,91.13 v1(55.16,91.13) ; v1(67.57,93.72) 67.02,94.27 PC12.1 65.67,94.04 PR17.1 64.34,93.47 PR27.2 ; PR47.1 55.8,97.17 56.13,97.5 v1(56.13,97.75) ; v1(44.02,72.09) 43.12,72.99 PR809.1 PR806.1 41.87,73.64 41.63,73.87 v1(41.63,75.55) 41.1,76.08 v2(41.1,77.15) PD800.3 41.46,80.38 PR832.1 PR866.1
  IN2 w0.254: v1(55.16,91.13) 54.2,91.13 52.44,92.89 v1(52.44,93.23) 52.44,94.71 55.48,97.75 v1(56.13,97.75)
  IN4 w0.254: v1(52.44,93.23) 51.14,91.92 51.14,88.27 50.05,87.19 50.05,83.38 45.41,78.73 45.41,78.04 43.88,76.51 43.19,76.51 42.22,75.55 v1(41.63,75.55) ; v1(67.57,93.72) 65.41,93.72 64.71,93.02 56.65,93.02 55.16,91.54 v1(55.16,91.13)
  BOTTOM w0.254: PR3002.1 52.9,62.07 51.99,62.07 51.63,61.72 PU3000.8
  BOTTOM w0.457: PC3002.1 53.04,62.9 PR3002.1
  BOTTOM w0.508: PC3002.1 52.09,63.85 49.52,63.85 49.22,64.15 49.22,64.68 48.24,65.65 47.45,65.65 46.36,66.75 46.36,67.76 PD3000.2 45.47,69.85 44.02,71.29 v1(44.02,72.09)
+3.3V_VDD_PIC: length 67.7
  TOP w0.254: PD800.2 39.8,72.74 36.39,69.34 35.95,69.34
  TOP w0.508: PR810.1 47.97,103.86 49.33,102.5 49.33,95.49 48.99,95.16 48.99,94.63 49.22,94.41 49.22,93.2 v2(49.37,93.05) 49.37,92.56 49.14,92.34 49.14,91.14 48.67,90.67 PR859.1 ; PR810.1 45.34,103.88 PR813.1 ; PR810.1 45.36,104.47 v1(45.54,104.64) ; PR822.2 v1(42.06,103.1)
  IN2 w0.508: v1(45.54,104.64) 45.54,104.83 44.96,105.4 41.83,105.4 39.16,108.07 33.22,108.07 31.38,106.23 31.38,97 29.43,95.05 27.76,95.05
  IN4 w0.508: v1(45.54,104.64) 44.52,104.64 42.97,103.1 v1(42.06,103.1)
  vias: v1(18.42,81.78) v1(18.87,81.4) v1(22.12,94.25) v1(22.75,94.25) v1(34.99,50.79) v1(35.31,51.3) v1(35.5,69.72) v1(35.95,70.1)
+3.3V_VDD_PIC_PDA: length 9
  TOP w0.127: v1(34.27,52.79) v2(34.27,52.2)
  IN2 w0.508: v1(34.27,52.79) 34.23,52.83 34.04,52.83 33.22,53.65 29.88,53.65 29.52,54.01 29.52,54.59 29.88,54.95 v1(30.1,54.95)
  BOTTOM w0.254: v1(30.1,54.95) 30.27,55.12 UT5.H1 ; UT5.B1 33.27,55.76 33.64,55.39
+3.3V_VDD_PIC_R: length 1.3
  TOP w0.127: v3(26.74,93.19) 26.54,93.39 RT398.1
  vias: v1(24.9,92.58) v1(25.47,92.58)
+3.3V_VPS_UZ12: length 18.4
  TOP w0.127: v1(177.31,84.69) 176.86,85.15 v3(176.57,85.15)
  TOP w0.254: CZ54.1 179.26,79.76 v1(179.32,79.82) 179.32,79.88 179.58,80.13 UZ12.14 ; UZ12.22 v1(183.91,77.34)
  TOP w0.508: v1(177.31,84.69) 177.5,84.88 RZ1408.2 178.33,84.14 RZ1409.2
  IN1 w0.508: v1(179.32,79.82) 179.98,79.82 181.76,78.04 183.21,78.04 v1(183.91,77.34)
  IN3 w0.508: v1(179.32,79.82) 178.61,80.53 178.61,81.43 178.03,82.01 177.52,82.01 176.86,82.67 176.86,83.46 177.31,83.92 v1(177.31,84.69)
+3.3V_WLAN:
  vias: v1(265.31,35.36) v1(265.69,35.81) v1(265.86,54.4) v1(265.86,53.82) v1(266.01,35.3) v1(266.33,35.81) v1(266.45,54.41) v1(266.45,53.83) v1(266.64,35.3) v3(260.48,36) v3(264.17,35.74) v3(264.42,54.29)
+3.3V_WLAN_UZ47:
  vias: v3(263.85,41.46)
+3.3V_WWAN: length 40.2
  TOP w0.127: v1(243.64,40.77) 243.48,40.77 v3(242.65,39.95)
  TOP w0.254: UZ29.10 244.05,46.77 v1(243.63,47.19)
  TOP w0.381: 268.95,62.68 270.5,62.68 270.91,62.27 RZ43.2
  TOP w0.508: v1(243.63,47.19) 243.63,47.27 243.21,47.68 CZ156.1
  IN3 w0.508: v1(263.37,63.44) 262.16,62.24 262.16,60.75 257.21,55.8 254.98,55.8 252.42,53.23 251.42,53.23 246.11,47.92 244.35,47.92 v1(243.63,47.19)
  BOTTOM w0.508: v1(243.64,40.77) 243.02,41.39 243.02,44.95 243.63,45.56 v1(243.63,47.19)
  vias: v1(263.37,64.04) v1(263.68,64.57) v1(268.21,63.09) v1(268.2,62.53) v1(268.2,61.94) v1(283.98,62.67) v1(283.98,62.1) v1(284.36,63.24) v1(284.55,62.67) v1(284.55,62.1) v1(284.93,63.24)
+3.3V_WWAN_UZ43:
  vias: v3(263.87,57.97)
+5V_ALW: length 495.9
  TOP w0.203: v1(183.9,94.48) 183.76,94.34 UZ3.4 ; UZ5.4 v1(294.63,49.45) ; UZ43.4 259.39,52.52 v1(259.38,52.5)
  TOP w0.254: v1(141.63,112.01) 141.63,111.07 UZ19.3 ; UZ27.3 145.9,46.22 v1(145.6,45.92) ; v1(295.34,19.42) 294.88,19.89 UZ8.4 ; UZ21.3 146.45,111.28 145.91,111.82 v1(145.48,111.82) ; 27.88,34.73 27.88,34.68 27.12,33.91 UZ53.4
  TOP w0.381: 27.88,34.73 28.71,35.55 28.71,38.4 ; v1(74.91,53.46) 74.91,53.08 74.53,52.7 PR634.2 ; v1(71.7,55.75) 71.76,55.75 72.19,55.32 PR615.2
  TOP w0.508: DT1.2 24.83,88.89 v1(24.84,88.91) ; PR602.2 v1(60.58,62.55) ; RI13.2 289.95,74.18 v1(289.76,74.38) ; v1(275.98,32.05) 276.87,31.16 276.87,31.11 278.87,29.1 289.41,29.1 290.26,28.25 v1(290.26,28.19) ; LED3.2 v1(311.21,105.92) ; v1(52.8,81.12) 52.8,80.65 54.11,79.34 54.72,79.34 55.56,80.19 PR7.1
  TOP w0.635: PC685.1 91.17,92.6 89.64,92.6 89.46,92.42 v1(89.13,92.42)
  TOP w1.27: 75.83,77.5 77.2,77.5 77.81,76.89 78.62,76.89 79.25,76.26 79.25,76
  TOP w2.032: 33.29,41.54 37.34,37.48 37.34,33.08
  IN1 w0.508: v1(270.29,52.54) 270.09,52.75 264.64,52.75 264.39,52.99 262.62,52.99 262.13,52.5 v1(259.38,52.5) ; v1(310.58,8.12) 310.58,9.78 308.49,11.87 308.49,13.9 305.78,16.61 295.43,16.61 294.57,17.47 294.57,18.65 v1(295.34,19.42) 295.34,22.6 294.71,23.23 294.71,27.3 294.2,27.81 292.17,27.81 291.83,27.47 290.99,27.47 v1(290.26,28.19)
  IN1 w1.27: 73.09,77.27 71.75,75.93 71.75,72.59 70.16,71
  IN1 w1.524: 75.51,52.32 75.51,49.84 74.07,48.41 66,48.41 64.6,49.8
  IN2 w0.508: v1(24.84,88.91) 26.06,88.91 27.18,87.78 27.18,86.82 26.63,86.27 21.53,86.27 17.79,82.52 17.79,78.92 19.25,77.46 19.25,71.48 16.15,68.38 16.15,65.26 17,64.41 17,62.63 19.06,60.57 19.06,56.95 19.75,56.25 19.75,52.51 21.21,51.05 23.75,51.05 28.76,46.04 28.76,40.56 28.33,40.13 v1(28.33,39.49) ; v1(205.18,40.14) 205.18,40.94 204.67,41.45 202.98,41.45 198.99,45.44 198.99,48.09 197.68,49.4 v1(197.68,56) ; v1(141.63,112.01) 142.5,112.01 143.08,112.59 144.86,112.59 145.48,111.97 v1(145.48,111.82) 146.57,111.82 147.02,111.38 148.73,111.38 149.33,111.98 152.57,111.98 152.79,112.2 157.29,112.2 157.96,112.88 164.83,112.88 171.63,106.07 171.63,103.51 172.92,102.23 172.92,100.58 174.77,98.72 177.06,98.72 179.96,95.82 181.17,95.82 182.58,94.41 183.83,94.41 v1(183.9,94.48) ; v1(60.58,62.55) 59.76,63.37 59.76,71.1 57.55,73.3 57.55,74.25 55.26,76.54 55.26,79.41 53.55,81.12 v1(52.8,81.12)
  IN3 w0.508: v1(76.34,61.73) 76.34,61.3 75.93,60.89 71.63,60.89 71.19,61.33 61.8,61.33 v1(60.58,62.55) ; v1(197.68,56) 197.68,57.77 193.76,61.69 193.76,71.4 193.62,71.54 193.62,74.17 193.2,74.59 193.2,79.9 190.15,82.95 190.15,83.27 188.02,85.39 188.02,86.68 184.65,90.05 184.65,93.6 183.88,94.37 183.88,94.46 v1(183.9,94.48) ; v1(294.73,73.89) 294.73,75.01 295.66,75.94 295.66,76.77 296.36,77.46 296.36,92.51 295.47,93.4 295.47,94.43 299.95,98.91 304.63,98.91 305.49,98.05 306.01,98.05 306.43,98.47 306.43,98.9 307.74,100.21 307.74,104.41 308.63,105.3 310.59,105.3 v1(311.21,105.92) ; v1(265.69,31.64) 266.21,32.15 269.76,32.15 270.66,33.06 273.96,33.06 274.98,32.05 v1(275.98,32.05)
  IN3 w0.635: 82.81,88.51 83.32,88.51 84.23,89.43 84.23,91.14 85.52,92.42 v1(89.13,92.42)
  IN4 w1.27: 83.89,87.75 84.09,87.55 84.09,79.56 81.97,77.44 81.97,77.13 81.41,76.57 77.54,76.57 76.59,77.53 75.83,77.53
  BOTTOM w0.254: JLED1.4 v1(310.58,8.12)
  BOTTOM w0.508: v1(145.6,45.92) 145.6,43.86 145.23,43.49 134.63,43.49 132.07,40.94 v1(132.07,29.58) ; v1(294.63,49.45) 295.47,50.3 295.47,65.02 298.01,67.56 299.41,67.56 299.98,68.13 299.98,71.88 298.96,72.89 297.81,72.89 296.81,73.89 v1(294.73,73.89)
  vias: v1(28.33,38.86) v1(28.96,39.49) v1(28.96,38.86) v1(38.11,64.89) v1(38.11,64.32) v1(38.11,63.75) v1(38.11,63.18) v1(38.68,64.99) v1(38.68,64.42) v1(38.68,63.85) v1(39,32.82) v1(39,32.25) v1(39,31.68) v1(39,31.11) v1(39,30.54) v1(39.31,33.33) v1(39.63,32.82) v1(39.63,32.25) v1(39.63,31.68) v1(39.63,31.11) v1(39.63,30.54) v1(40.27,32.82) v1(40.27,32.25) v1(40.27,31.68) v1(40.27,31.11) v1(40.27,30.54) v1(63.19,50.67) v1(63.89,50.67) v1(69.64,70.15) v1(70.14,69.87) v1(74.3,77.78) v1(74.87,77.78) v1(77.02,61.73) v1(78.88,74.86) v1(79.57,74.8) v1(81.68,88.58) v1(82.24,88.58) v1(92.26,27.92) v1(92.83,27.92) v1(92.97,28.53) v1(162.79,27.78) v1(163.35,27.78) v1(164.01,27.71) v1(181.62,28.81) v1(182.19,28.8) v1(202.89,33.14) v1(202.89,32.57) v1(202.89,31.93) v1(203.4,32.89) v1(203.4,32.25) v1(203.33,30.78) v1(203.97,31.05) v1(204.41,31.49) v1(204.37,28.94) v1(204.37,28.3) v1(268.06,46.74) v1(268.06,46.16) v1(268.06,45.57) v1(268.65,46.74) v1(268.65,46.16) v1(268.65,45.57) v1(288.84,76.96) v1(289,77.53) v1(288.99,76.38) v1(288.99,75.81) v1(294.09,73.89) v3(34.73,31.4)
+5V_ALW2: length 4
  TOP w0.127: PC126.1 42.54,31.17 41.78,31.93 41.78,33.88 v3(42.26,34.36)
+5V_ALW_PDA: length 1.6
  TOP w0.508: CT22.1 29.9,60.01 v1(29.8,59.9)
  BOTTOM w0.254: v1(29.8,59.9) 30.27,60.38 UT5.H10
  vias: v1(32.91,62.7) v1(32.95,62.14) v1(33.54,62.79) v1(33.54,62.16) v1(34.23,62.8) v1(34.23,62.16) v3(32.06,66.22)
+5V_ALWP: length 31.5
  TOP w0.254: v1(43.95,30.54) 43.95,30.41 43.99,30.36 PU102.14 ; PR117.2 42.98,33.26 v1(42.82,33.09)
  IN4 w0.254: v1(42.82,33.09) 43.38,32.53 43.38,31.05 42.3,29.97 37.47,29.97 35.46,27.96 35.46,25.55 37.32,23.69 v1(37.47,23.69)
  IN4 w0.508: v1(37.47,24.28) 35.95,25.8 35.95,27.74 37.66,29.46 42.87,29.46 v1(43.95,30.54)
  vias: v1(36.76,21.65) v1(37.2,21.2) v1(37.2,20.62) v1(37.2,20.06) v1(37.2,19.5) v1(37.2,18.94) v1(37.47,23.11) v1(37.47,22.52) v1(38.07,26.74) v1(38.07,26.16) v1(38.07,25.57) v1(38.65,26.74) v1(38.65,26.16) v1(38.65,25.57) v1(40.6,20.49) v1(40.6,19.93) v1(40.6,19.37) v1(40.6,18.82) v1(40.91,22.4) v1(40.91,21.84) v2(39.01,20.28)
+5V_PD_VDD: length 0.7
  TOP w0.127: v1(22.05,35.33) v3(22.05,36.07)
  vias: v1(22.05,34.75) v1(25.41,88) v1(25.98,88)
+5V_RUN: length 71.5
  TOP w0.127: CZ71.1 259.37,33.73 v3(258.45,34.64)
  TOP w0.508: v1(264.2,30.71) 264.47,30.98 264.47,32.08 263.85,32.7 260.23,32.7
  IN1 w1.016: 183.14,60.41 183.14,59.32 189.99,52.46 191.65,52.46 193.29,50.82 194.83,50.82 197.36,48.29 198.78,48.29 206.81,40.27 206.81,36.28 206.23,35.7 206.23,32.42 205.37,31.55 205.37,26.6 204.67,25.9
  IN3 w1.016: 183.01,62.03 183.01,62.13 183.87,62.99 183.87,71.27 183.52,71.62 183.52,74.76 183.09,75.19
  BOTTOM w0.305: JUSH1.7 264.43,30.94 v1(264.2,30.71)
  vias: v1(20.9,49.27) v1(20.9,48.7) v1(25.91,46.35) v1(25.91,45.78) v1(81.39,108.42) v1(81.97,108.42) v1(181.93,76.45) v1(182.38,76.06) v1(182.51,61.27) v1(182.51,60.7) v1(189.17,83.24) v1(189.17,82.67) v1(189.55,78.04) v1(189.95,77.65) v1(206.38,25.33) v1(207.02,25.33) v1(246.7,30.73) v1(247.28,30.73) v1(271.79,38.08) v1(272.36,40.63) v1(272.36,40) v1(272.36,39.36) v1(272.36,38.72) v1(272.36,38.09) v1(292.63,49.4) v1(293.19,49.4) v1(293.19,48.83) v1(293.76,49.4) v1(293.76,48.83)
+5V_RUN_AUDIO:
  vias: v1(278.76,51.59) v1(279.54,51.75) v1(282.39,49.24) v1(282.39,48.69) v1(288.3,54.29) v1(288.29,53.71) v1(288.87,54.29) v1(288.87,53.71) v3(281.84,52.62)
+5V_RUN_AUDIO_UZ5:
  vias: v3(292.06,53.64)
+5V_RUN_PVDD_L: length 4.8
  TOP w0.254: CA46.1 281.41,48.15 282.07,48.15 282.58,47.65 282.58,47.01 282.33,46.76 CA45.1 282.16,45.8 282.22,45.75 282.22,45 282.24,44.98
  vias: v1(277.39,48.19) v1(277.87,48.65) v1(281.25,49.28) v1(281.5,49.78) v2(282.25,44.61)
+5V_RUN_UZ47:
  vias: v3(270.8,42.37)
+5V_TBT_VBUS: length 0.8
  TOP w0.127: v1(20.66,32.99) 21.09,32.99 v3(21.34,32.73)
+5V_TBTA_VBUS_D: length 1.8
  BOTTOM w0.127: UT8.3 v2(24.68,34.05)
+5V_USB_CHG_PWR: length 1.5
  TOP w0.127: v1(303.49,72.12) v3(305.03,72.12)
  vias: v1(297.2,79.61) v1(297.2,79.05) v1(297.2,78.49) v1(297.2,77.93) v1(297.2,77.37) v1(300.95,72.12) v1(301.59,72.12) v1(302.22,72.12) v1(302.86,72.12)
+13.2VB_BATT: length 241.1
  TOP w0.127: v1(111,25.27) v3(109.99,25.27)
  TOP w0.508: PR738.2 51.06,38.55 55.7,33.92 v1(55.7,27.3)
  IN3 w0.508: v1(55.7,27.3) 56.37,27.97 68.39,27.97 71.53,24.84 72.24,24.84 73.34,23.74 78.75,23.74 80.46,25.46 83.28,25.46 85.12,23.62 108.15,23.62 109.8,25.27 v1(111,25.27)
  BOTTOM w0.508: v1(111,25.27) 111,24.67 112.06,23.62 144.91,23.62 149.83,28.54 156.48,28.54 157.11,29.17 160.45,29.17 163.01,26.6 171.43,26.6 173.68,24.36 174.23,24.36 174.97,23.62 191.71,23.62 192.07,23.98 192.07,24.84 191.2,25.71 191.2,27.36 192.35,28.51 198.44,28.51 203.49,23.46 227.9,23.46 229.36,24.92 234.04,24.92 234.98,25.86 234.98,26.57 236.59,28.19 240.93,28.19 241.69,28.95 241.69,32.99 241.49,33.2 241.49,34.41 243.26,36.19 243.26,37.57 240.9,39.93 240.04,39.93
+13.2VB_PBATT_C: length 6.8
  TOP w0.127: v3(240.86,38.63) 241.52,37.97 241.52,36.75 v1(241.69,36.58) ; v3(242.14,37.5) 242.14,37.04 v1(241.69,36.58) ; v3(242.07,35.78) 241.69,36.16 v1(241.69,36.58)
  BOTTOM w0.127: 239.54,37.1 241.17,37.1 v1(241.69,36.58)
+13.5VB: length 121
  TOP w0.127: v1(51.12,33.84) v3(51.12,34.78)
  TOP w0.254: v1(55.51,53.27) 55.43,53.19 PR721.2
  TOP w0.508: PD702.2 39.22,60.56 v1(39.92,59.87)
  IN1 w0.254: 191.14,101.91 191.14,99.05 189.81,97.72 189.81,96.79 188.96,95.94 187.71,95.94 187.52,95.75 v1(187.52,95.31)
  IN1 w1.092: 198.44,85.66 196.28,87.81 196.28,90.74 197.75,92.2 197.75,101.53 196.22,103.05 193.43,103.05
  IN2 w1.016: 193.43,103.05 192.86,102.48
  IN2 w1.092: 198.44,85.66 196.28,87.81 196.28,90.74 197.75,92.2 197.75,101.53 196.22,103.05 193.43,103.05
  IN3 w0.508: v1(43.91,69.72) 43.12,68.93 43.12,67.72 41.42,66.02 41.42,64.31 41.79,63.94 41.79,61.17 40.49,59.87 v1(39.92,59.87)
  IN4 w1.092: 193.43,103.05 196.22,103.05 197.75,101.53 197.75,92.2 196.28,90.74 196.28,87.75 198.38,85.66
  BOTTOM w0.254: v1(187.52,95.31) 186.99,94.77 PR102.2
  BOTTOM w0.508: 53.79,51.75 52.14,50.1 48.08,50.1 47.47,50.71 45.43,50.71 43.5,52.64 42.81,52.64 41.66,53.78 41.66,58.85 40.64,59.87 v1(39.92,59.87) ; PR3006.1 45.47,66.3 PD3000.3 45.47,67.51 44.05,68.93 44.05,69.58 v1(43.91,69.72)
  vias: v1(50.55,33.27) v1(50.55,32.7) v1(51.12,33.27) v1(51.12,32.7) v1(51.7,33.84) v1(51.7,33.27) v1(51.7,32.7) v1(52.27,33.84) v1(52.27,33.27) v1(52.27,32.7) v1(52.84,33.84) v1(52.84,33.27) v1(52.84,32.7) v1(55.51,53.84) v1(55.51,52.7) v1(55.51,52.13) v1(56.08,53.84) v1(56.08,53.27) v1(56.08,52.7) v1(56.08,52.13) v1(56.65,53.84) v1(56.65,53.27) v1(56.65,52.7) v1(57.22,53.84) v1(57.22,53.27) v1(57.22,52.7) v1(57.79,53.84) v1(57.79,53.27) v1(57.79,52.7) v1(58.36,53.84) v1(58.36,53.27) v1(58.36,52.7) v1(58.88,84.04) v1(60,86.8) v1(60.01,86.2) v1(60,85.6) v1(59.99,84.8) v1(60.57,86.8) v1(60.57,84.78) v1(60.81,72.69) v1(60.81,72.1) v1(61.08,86.48) v1(61.08,85.91) v1(61.08,85.34) v1(61.17,84.77) v1(61.4,72.69) v1(61.4,72.1) v1(61.49,81.54) v1(61.65,86.48) v1(61.65,85.91) v1(61.65,85.34) v1(61.74,84.77) v1(61.98,72.69) v1(61.98,72.1) v1(62.22,86.48) v1(62.22,85.91) v1(62.22,85.34) v1(62.31,84.77) v1(62.78,86.48) v1(62.73,81.54) v1(63.98,81.54) v1(65.22,81.54) v1(66.81,85.4) v1(66.81,84.83) v1(66.81,84.26) v1(66.81,83.69) v1(87.88,95.02) v1(88.37,95.35) v1(88.39,94.66) v1(96.72,100.7) v1(97.29,100.7) v1(183.08,109.19) v1(183.08,108.55) v1(183.72,109.19) v1(183.72,108.55) v1(184.41,107.65) v1(184.41,107.08) v1(190.02,103.19) v1(190.02,102.55) v1(190.6,103.19) v1(190.6,102.55) v1(191.23,103.19) v1(191.23,102.55) v1(191.87,103.19) v1(191.87,102.55) v1(199.4,84.45) v1(199.4,83.81) v1(199.9,84.83) v1(199.9,84.19) v1(199.9,83.56) v1(199.9,82.92) v1(200.54,84.83) v1(200.54,84.19) v1(200.54,83.56) v1(200.54,82.92)
+13.5VB_1.05VALWP: length 3.8
  TOP w0.127: v3(183.86,110.69) 184.26,110.69 185.78,109.16 185.78,108.53 186.2,108.11
  vias: v1(187.29,106.65) v1(187.85,106.65) v1(188.54,106.97) v1(189.18,106.97)
+13.5VB_3V:
  vias: v1(186.8,101.23) v1(187.38,101.21) v1(187.95,101.21) v1(188.28,100.74) v1(188.82,101.24) v1(188.84,100.68) v1(190.51,100.32) v1(190.51,99.75) v3(189.66,101.11)
+13.5VB_5V:
  vias: v1(44.99,24.57) v1(44.99,23.99) v1(45.14,32.33) v1(45.14,31.74) v1(45.14,31.16) v1(45.55,24.57) v1(45.55,23.99) v1(45.73,32.33) v1(45.73,31.74) v1(45.73,31.16) v1(46.11,23.57) v1(46.61,24.96) v1(46.61,24.4) v1(46.68,23.57) v1(47.25,23.55) v1(47.76,23.81) v1(47.82,23.23) v1(48.32,24.48) v1(48.32,23.83) v1(48.39,23.23) v1(48.85,24.17) v1(48.85,23.61) v3(48.51,22.51)
+13.5VB_CPU: length 24
  TOP w0.508: 70.3,81.21 69.92,80.83 69.92,79.69 69.16,78.92 69.16,75.94 68.01,74.8 65.22,74.8 63.29,72.87 63.29,72.4 57.53,66.64 PR603.2
  vias: v1(71.57,88.2) v1(71.57,87.62) v1(71.57,87.05) v1(71.57,86.48) v1(71.57,85.91) v1(72.14,86.23) v1(72.4,88.26) v1(72.97,88.26) v1(73.54,88.51) v1(74.11,88.51) v1(75.38,83.71) v1(75.88,89.26) v1(75.88,88.59) v1(76.27,84) v1(76.69,83.08) v1(76.84,84) v1(77.09,89.26) v1(77.09,88.59) v1(77.26,83.08) v1(78.22,80.63) v1(78.22,79.42) v1(78.3,83.56) v1(78.89,80.63) v1(78.89,79.42) v3(74.45,85.83)
+13.5VB_DDR:
  vias: v1(217.68,27.44) v1(218.26,27.44) v1(218.76,26.32) v1(219.33,26.32) v2(217.14,29.86)
+13.5VB_IR:
  vias: v1(100.65,111) v1(101.25,111) v1(101.85,111.01) v3(102.89,109.71)
+13.5VB_VCCGT:
  vias: v1(71.86,79.78) v1(72.5,79.78) v1(72.74,74.82) v1(73.13,79.78) v1(73.32,74.82) v1(73.67,72.76) v1(73.77,79.78) v1(74.24,74.23) v1(74.75,71.37) v1(74.75,70.16) v1(75,73.59) v1(75.42,71.37) v1(75.42,70.16) v3(74.29,72.23)
+13.5VB_VCCSA: length 0.8
  TOP w0.127: v2(100.54,97.95) 100.37,97.95 v1(99.89,97.47)
+13.5VB_VCHGR:
  vias: v2(230.5,37.88)
+19.5V_AC: length 4.1
  BOTTOM w0.127: PD701.1 56.89,83.8 56.89,84.6 v3(59.14,86.85)
+19.5V_CHARGER: length 0.7
  TOP w0.127: v2(50.09,71.04) 50.01,70.95 v1(50.01,70.42)
  vias: v1(47.9,70.21) v1(47.9,69.63) v1(50.01,69.17) v1(50.01,67.93) v1(50.01,66.68) v1(51.76,77.39) v1(51.76,76.8) v1(52.34,77.39) v1(52.34,76.8) v1(52.93,77.39) v1(52.93,76.8)
+19.5V_DC_IN: length 23.6
  TOP w0.254: PQ11.3 59.22,89.19 59.22,89.5 59.87,90.15 v1(59.87,90.91) 59.12,90.91 58.87,91.17 58.87,91.23 58.83,91.27 PC7.1
  TOP w0.381: PR13.1 56.2,86.23 55.76,85.78 55.76,84.7 56.84,83.62 56.84,83.1 56.22,82.48 56.22,80.02 54.39,78.19 v2(52.62,78.19) 51.72,78.19 50.41,76.88 50.41,76.51 49.85,75.95 PR800.1
  BOTTOM w0.254: PQ9.3 58.36,90.69 58.59,90.46 59.41,90.46 v1(59.87,90.91)
+19.5V_DC_IN_SS: length 40.4
  TOP w0.508: v1(56.33,85.4) 56.33,85.08 56.58,84.83 PR14.1 56.95,84.28 57.4,83.84 57.4,82.8 56.8,82.2 56.8,79.65 53.08,75.93 51.36,75.93 50.41,74.97 50.41,72.24 49.03,70.86 38.87,70.86 37.6,69.59 37.6,68.24 v3(39.57,66.27) 40.07,65.76 40.07,62.99 39.38,62.29 PD700.2
+19.5V_DCIN_JACK: length 3.6
  TOP w0.127: v1(47.05,95.03) 47.58,95.03 v3(47.71,95.16) ; v1(47.05,95.03) 46.92,95.16 46.31,95.16 v3(45.62,95.84) ; v1(47.05,95.03) 46.97,95.03 v3(46.24,94.3)
+19.5V_SDC_IN: length 71.7
  TOP w0.102: v3(37.88,55.58) 38.15,55.31 PR705.1
  TOP w0.254: PR703.1 39.68,56.37 v1(39.31,56) 39.03,55.72 39.03,55.32 PR705.1 ; v1(37.22,89.72) 37.22,90.72 36.96,90.98 PQ805.3 ; v1(67.76,94.48) 68.37,94.48 69.25,93.61 PR10.1 69.79,94.29 v3(70.5,95) 71.82,96.32 v3(72.28,96.32) 73.09,96.32 73.67,96.89 74.87,96.89 75,96.77 76.37,96.77 PQ5.3
  IN3 w0.254: v1(67.76,94.48) 67.64,94.48 66.28,93.12 62.4,93.12 61.33,94.19 55.8,94.19 v1(51.73,90.12) ; v1(48.28,78.04) 47.69,78.04 44.53,74.87 44.53,69.16 44.23,68.86 44.23,62.21 43.4,61.38 43.4,60.53 39.31,56.45 v1(39.31,56)
  BOTTOM w0.254: v1(37.22,89.72) 39.38,89.72 39.82,89.27 40.84,89.27 41.28,89.72 45.98,89.72 46.68,89.02
+19.5VB_WC_C: length 0.9
  TOP w0.127: v1(42.82,41.76) v3(42.82,42.65)
+19.5VB_WC_SDC: length 1.8
  BOTTOM w0.127: PL902.2 v3(50.32,43.43)
+20V_LDO_INPUT: length 2.4
  TOP w0.127: v2(62.91,91.56) 62.91,93.39 v1(62.48,93.82)
+20V_TBTA_VBUS: length 6
  TOP w0.127: v1(11.31,92.96) 11.31,93.35 v3(10.8,93.86) ; v3(12.58,93.9) 12.58,93.08 v1(12.45,92.96) ; v1(11.31,91.81) v3(10.53,91.81)
  TOP w0.254: JUSBC1.A9 6.9,84.47 6.88,84.5 6.79,84.5 v1(6.74,84.45) 6.67,84.51 6.48,84.51 6.27,84.72 JUSBC1.B4 ; 7.2,86.97 6.95,87.22 v1(6.67,87.22) JUSBC1.B9
  vias: v1(8.39,86.99) v1(8.39,84.51) v1(8.96,86.89) v1(8.97,84.55) v1(9.53,87.46) v1(9.53,86.89) v1(9.54,84.55) v1(9.72,84) v1(11.31,92.39) v1(11.88,92.96) v1(11.88,92.39) v1(11.88,91.81) v1(12.45,92.39) v1(12.45,91.81) v1(13.02,91.81) v1(29.95,94.19) v1(30.41,94.57) v1(39.95,87.62) v1(40.2,88.2) v1(40.47,88.73) v1(40.52,87.69) v1(40.77,88.26) v1(41.09,87.69) v1(41.09,87.12) v1(41.15,88.83) v1(41.34,88.26) v1(41.73,88.83) v1(41.66,87.69) v1(41.92,88.26)
+20V_TBTA_VBUS_1: length 46.9
  TOP w0.127: v1(18.79,30.46) 18.79,31.12 v3(18.97,31.3)
  TOP w0.381: v1(45.04,87.5) 46.23,87.5 46.81,86.93 PR831.1
  TOP w0.508: v1(51.77,89.15) 50.61,87.99 46.81,87.99 ; PR801.1 44.6,89.91 45.04,89.47 45.04,88.08 45.03,88.07 45.04,88.06
  IN3 w0.508: v1(51.77,89.15) 55.99,93.38 59.73,93.38 60.74,92.37 60.74,89.2 v1(61.33,88.6)
  IN3 w1.524: 41.34,71.11 41.34,72.5 40.29,73.55 40.29,81.32 40.88,81.91 40.88,83.51 42.52,85.15 43.95,85.15
  BOTTOM w0.508: v1(61.33,88.6) 60.98,88.96 PR892.2
  vias: v1(18.79,29.83) v1(18.79,29.2) v1(19.36,30.46) v1(19.36,29.83) v1(19.36,29.2) v1(28.77,63.05) v1(28.82,62.41) v1(28.82,61.71) v1(29.41,63.05) v1(29.46,62.41) v1(29.46,61.71) v1(34.59,60.63) v1(35.04,61.05) v1(44.01,86.84) v1(44.48,87.15) v1(44.54,86.58) v1(45.06,88.06) v1(45.04,86.93)
+20V_VBUS_DC_SS: length 29.3
  TOP w0.127: v1(39.41,59.43) 39.28,59.43 38.98,59.14 v2(38.82,59.14)
  TOP w0.254: PR870.1 49.46,79.13 49.22,78.89 46.89,78.89 46.32,78.31 44.53,78.31 44.03,77.81 v1(43.52,77.81)
  TOP w0.508: PD704.2 39.41,59.43 v1(39.41,59.43)
  IN3 w0.508: v1(39.41,59.43) 38.69,60.15 38.69,60.6 38.33,60.95 38.33,61.79 40.81,64.27 40.81,66.27 42.46,67.92 42.46,76.05 43.52,77.11 v1(43.52,77.81)
+VCC1V8A_TBTA_LDO: length 3.1
  TOP w0.089: v2(28.82,54.48) 28.8,54.5 28.76,54.5 v1(28.33,54.93)
  BOTTOM w0.203: UT5.K1 29.27,55.86 v1(28.33,54.93) 28.33,54.8 27.79,54.26 CT73.1
+VCC1V8D_TBTA_LDO: length 12
  TOP w0.127: v1(30.3,63.56) v3(30.3,62.76)
  TOP w0.254: CT72.1 34.74,56.13 34.41,56.46 v1(34.23,56.46)
  IN1 w0.254: v1(34.23,56.46) 34.23,57.48 33.58,58.13 33.58,59.85 30.36,63.07 30.36,63.43 30.3,63.49 v1(30.3,63.56)
  BOTTOM w0.203: v1(34.23,56.46) 33.8,56.46 UT5.A2
  BOTTOM w0.254: v1(30.3,63.56) 30.26,63.52 RT97.1
+VCC3V3_ANA_PCIE: length 5.2
  TOP w0.127: v3(22.27,73.72) 22.8,73.18 RT497.1
  TOP w0.254: RT497.1 CT63.1 24.45,73.63 24.45,73.84 v1(25.8,75.19)
  BOTTOM w0.203: UT1.L16 v1(25.8,75.19)
+VCC3V3_ANA_USB2: length 1.1
  TOP w0.254: CT64.1 25.66,75.7 v1(25.8,75.84)
  BOTTOM w0.203: UT1.J16 25.5,75.52 25.8,75.83 v1(25.8,75.84)
+VCC_CORE: length 154.8
  IN2 w0.254: v1(48.49,59.52) 49.62,58.39 53.08,58.39 57.35,62.66 58.87,62.66 60.04,61.49 62.29,61.49 62.54,61.23 62.54,55.79 68.01,50.31 70.22,50.31 71.06,51.15 77.53,51.15 90.18,63.8 90.18,66.31 95.33,71.47 95.33,73.2
  BOTTOM w0.1: 131.41,85.38 UC1.AV10 ; UC1.AV10 131.85,85.83 ; UC1.AV10 131.85,85.38 ; UC1.AV10 131.41,85.83 ; 122.62,86.29 UC1.AC8 ; UC1.AC8 122.62,86.74 ; UC1.AC8 122.17,86.74 ; UC1.AC8 122.17,86.29 ; UC1.AP26 129.58,75.02 ; UC1.AP26 129.13,75.02 ; UC1.AP26 129.58,75.47 ; UC1.AP26 129.13,75.47 ; UC1.AW10 132.75,85.8 132.75,85.86 ; UC1.AW10 132.33,85.83 ; UC1.AW10 132.33,85.38 ; UC1.AY26 132.77,75.47 ; UC1.AY26 133.22,75.02 ; UC1.AY26 132.77,75.02 ; UC1.AY26 133.22,75.47 ; UC1.AL10 126.73,85.32 ; UC1.AL10 127.29,85.32 ; UC1.AL10 127.24,85.83 ; UC1.AL10 126.79,85.83 ; 130.01,85.83 UC1.AR10 ; UC1.AR10 129.56,85.83 ; UC1.AR10 130.01,85.38 ; UC1.AR10 129.56,85.38 ; 128.63,85.38 UC1.AN10 128.63,85.83 ; UC1.AK9 126.77,86.28 ; UC1.AK9 126.32,86.28 ; UC1.AK9 126.77,85.84 ; UC1.AK9 126.32,85.84 ; 135.55,86.74 UC1.BD8 ; UC1.BD8 135.1,86.29 ; UC1.BD8 135.55,86.29 ; 134.64,86.28 UC1.BC9 ; UC1.BC9 134.64,85.84 ; UC1.BC9 135.09,86.28 ; UC1.BC9 135.09,85.84 ; UC1.BE24 135.96,75.95 ; UC1.BE24 135.51,76.4 ; UC1.BE24 135.96,76.4 ; UC1.BE24 135.51,75.95 ; UC1.AW26 131.86,75.47 ; UC1.AW26 132.31,75.02 ; UC1.AW26 131.86,75.02 ; UC1.AW26 132.31,75.47 ; 127.24,86.29 UC1.AL8 ; UC1.AL8 127.24,86.74 ; UC1.AL8 126.79,86.29 ; UC1.AL8 126.79,86.74 ; 132.78,86.74 UC1.AW8 ; UC1.AW8 132.78,86.29 ; UC1.AW8 132.33,86.29 ; UC1.BE26 135.51,75.02 ; UC1.BE26 135.51,75.47 ; UC1.BE26 135.96,75.02 ; UC1.BE26 135.96,75.47 ; UC1.AY24 132.77,75.95 ; UC1.AY24 132.77,76.4 ; UC1.AY24 133.22,76.4 ; UC1.AY24 133.22,75.95 ; 130.93,86.74 UC1.AU8 ; UC1.AU8 130.48,86.29 ; UC1.AU8 130.93,86.29 ; UC1.AU8 130.48,86.74 ; 132.77,75.48 UC1.AW25 ; UC1.AW25 132.77,75.93 ; UC1.AW25 132.32,75.93 ; UC1.AW25 132.32,75.48 ; 136.42,75.95 UC1.BF24 136.42,76.4 ; UC1.AF10 123.96,85.32 ; UC1.AF10 124.02,85.83 ; UC1.AF10 124.52,85.32 ; UC1.AF10 124.46,85.83 ; 126.31,85.83 UC1.AJ10 ; UC1.AJ10 126.37,85.32 ; UC1.AJ10 125.86,85.83 ; UC1.AJ10 125.81,85.32 ; UC1.AE9 124,86.28 ; UC1.AE9 123.55,86.28 ; UC1.AE9 124,85.84 ; UC1.AE9 123.55,85.84 ; UC1.AA9 120.78,85.84 ; UC1.AA9 121.23,86.28 ; UC1.AA9 120.78,86.28 ; UC1.AA9 121.23,85.84 ; UC1.AF8 124.46,86.74 ; UC1.AF8 124.02,86.29 ; UC1.AF8 124.02,86.74 ; UC1.AF8 124.46,86.29 ; 130.94,85.84 UC1.AU9 ; UC1.AU9 131.39,86.28 ; UC1.AU9 131.39,85.84 ; UC1.AU9 130.94,86.28 ; UC1.AW24 132.31,75.95 ; UC1.AW24 132.31,76.4 ; UC1.AW24 131.86,75.95 ; 130.26,75.24 UC1.AT26 ; 130.26,75.24 130.04,75.02 ; 130.26,75.24 130.49,75.47 ; 130.26,75.24 130.04,75.47 ; 130.26,75.24 130.49,75.02 ; UC1.AL9 127.25,85.84 ; UC1.AL9 127.25,86.28 ; UC1.AL9 127.7,85.84 ; UC1.AL9 127.7,86.28 ; UC1.BE9 135.56,86.28 ; UC1.BE9 136.01,86.28 ; UC1.BE9 135.56,85.84 ; UC1.BE9 136.01,85.84 ; 129.58,75.93 UC1.AR25 ; UC1.AR25 129.58,75.48 ; UC1.AR25 130.03,75.48 ; UC1.AR25 130.03,75.93 ; 136.71,86.06 UC1.BF9 ; 136.71,86.06 136.49,85.84 ; 136.71,86.06 136.49,86.28 ; UC1.AE8 123.54,86.74 ; UC1.AE8 123.09,86.74 ; UC1.AE8 123.54,86.29 ; UC1.AE8 123.09,86.29 ; 134.63,85.83 UC1.BC10 ; UC1.BC10 134.22,85.78 134.22,85.89 ; UC1.BC10 134.63,85.38 ; 130.26,76.17 130.04,75.95 ; 130.26,76.17 130.49,76.4 ; 130.26,76.17 130.49,75.95 ; 130.26,76.17 130.04,76.4 ; 130.26,76.17 UC1.AT24 ; 130.47,86.28 UC1.AT9 ; UC1.AT9 130.02,85.84 ; UC1.AT9 130.47,85.84 ; UC1.AT9 130.02,86.28 ; 124.93,85.84 UC1.AG9 ; UC1.AG9 124.93,86.28 ; UC1.AG9 124.48,85.84 ; UC1.AG9 124.48,86.28 ; UC1.BE25 135.96,75.93 ; UC1.BE25 135.96,75.48 ; UC1.BE25 136.41,75.93 ; UC1.BE25 136.41,75.48 ; 135.1,85.83 UC1.BD10 ; UC1.BD10 135.55,85.38 ; UC1.BD10 135.1,85.38 ; UC1.BD10 135.55,85.83 ; 127.71,86.74 UC1.AM8 ; UC1.AM8 128.16,86.74 ; UC1.AM8 127.71,86.29 ; UC1.AM8 128.16,86.29 ; UC1.BC26 134.6,75.02 ; UC1.BC26 135.04,75.02 ; UC1.BC26 135.04,75.47 ; UC1.BC26 134.6,75.47 ; UC1.AJ8 125.86,86.29 ; UC1.AJ8 126.31,86.29 ; UC1.AJ8 126.31,86.74 ; UC1.AJ8 125.86,86.74 ; UC1.BA25 133.23,75.48 ; UC1.BA25 133.68,75.48 ; UC1.BA25 133.68,75.93 ; UC1.BA25 133.23,75.93 ; UC1.BB26 133.68,75.02 ; UC1.BB26 134.13,75.47 ; UC1.BB26 134.13,75.02 ; UC1.BB26 133.68,75.47 ; 133.25,86.29 UC1.BA8 ; UC1.BA8 133.7,86.74 ; UC1.BA8 133.25,86.74 ; UC1.BA8 133.7,86.29 ; 136.87,75.47 UC1.BF26 ; UC1.BF26 136.42,75.47 ; UC1.BF26 136.42,75.02 ; UC1.BF26 136.87,75.02 ; UC1.AU26 130.95,75.47 ; UC1.AU26 131.4,75.47 ; UC1.AU26 130.95,75.02 ; UC1.AU26 131.4,75.02 ; UC1.BD25 135.5,75.48 ; UC1.BD25 135.5,75.93 ; UC1.BD25 135.05,75.93 ; UC1.BD25 135.05,75.48 ; UC1.AP24 129.58,75.95 ; UC1.AP24 129.13,75.95 ; UC1.AP24 129.58,76.4 ; 131.87,86.28 UC1.AW9 ; UC1.AW9 131.87,85.84 ; UC1.AW9 132.32,86.28 ; UC1.AW9 132.32,85.84 ; 124.94,86.74 UC1.AG8 ; UC1.AG8 125.39,86.29 ; UC1.AG8 124.94,86.29 ; UC1.AG8 125.39,86.74 ; UC1.AB9 121.71,85.84 ; UC1.AB9 122.15,86.28 ; UC1.AB9 121.71,86.28 ; UC1.AB9 122.15,85.84 ; 125.85,85.84 UC1.AH9 ; UC1.AH9 125.4,86.28 ; UC1.AH9 125.4,85.84 ; UC1.AH9 125.85,86.28 ; 129.1,85.84 UC1.AP9 ; UC1.AP9 129.55,85.84 ; UC1.AP9 129.1,86.28 ; UC1.AP9 129.55,86.28 ; 123.54,85.83 UC1.AE10 ; UC1.AE10 123.09,85.83 ; UC1.AE10 123.6,85.32 ; UC1.AE10 123.04,85.32 ; 128.66,75.47 UC1.AN26 128.66,75.02 ; UC1.AU25 130.49,75.48 ; UC1.AU25 130.94,75.48 ; UC1.AU25 130.49,75.93 ; UC1.AU25 130.94,75.93 ; UC1.AB10 121.19,85.32 ; UC1.AB10 121.24,85.83 ; UC1.AB10 121.75,85.32 ; UC1.AB10 121.69,85.83 ; 128.66,75.95 UC1.AN24 128.44,76.49 ; 120.77,85.38 UC1.Y10 120.77,85.83 ; 128.71,86.06 UC1.AN9 128.4,85.74 ; 130.95,75.95 UC1.AU24 ; UC1.AU24 131.4,75.95 ; UC1.AU24 130.95,76.4 ; 122.63,86.28 UC1.AD9 ; UC1.AD9 123.08,86.28 ; UC1.AD9 122.63,85.84 ; UC1.AD9 123.08,85.84 ; 130.01,86.29 UC1.AR8 130.01,86.74
  BOTTOM w0.18: UC1.AP2 v1(129.19,91.69) ; UC1.AK2 126.75,91.24 127.2,91.69 v1(127.64,91.69) ; UC1.BB2 v1(134.07,91.69) ; UC1.AF2 v1(124.31,91.69) ; UC1.V2 v1(119.43,91.69) ; UC1.BF2 v1(136.51,91.69) ; UC1.AB2 v1(121.87,91.69) ; UC1.AV2 v1(131.63,91.69)
  BOTTOM w0.508: RC150.1 v1(124.28,99.41) ; v1(48.49,59.52) 48.16,59.52 47.81,59.17 PR3004.1 ; PC1086.1 v1(127.41,107.4) ; v1(126.56,107.4) PC1088.1
  vias: v1(86.37,85.2) v1(86.37,84.63) v1(86.37,83.29) v1(86.49,82.72) v1(86.94,85.2) v1(86.94,84.63) v1(86.94,83.29) v1(87.13,82.72) v1(87.26,82.09) v1(87.26,81.52) v1(87.26,80.88) v1(87.57,86.35) v1(87.57,85.78) v1(87.57,85.2) v1(87.57,84.63) v1(87.57,83.29) v1(87.7,82.72) v1(87.83,82.09) v1(87.83,81.52) v1(87.83,80.88) v1(88.14,88.07) v1(88.14,87.5) v1(88.14,86.93) v1(88.14,86.35) v1(88.14,85.78) v1(88.14,85.2) v1(88.14,84.63) v1(88.14,83.29) v1(88.23,80.27) v1(88.23,79.7) v1(88.33,82.72) v1(88.46,82.09) v1(88.46,81.45) v1(88.46,80.88) v1(88.72,88.07) v1(88.72,87.5) v1(88.72,86.93) v1(88.72,86.35) v1(88.72,85.78) v1(88.78,85.2) v1(88.78,84.63) v1(88.78,83.29) v1(88.8,80.27) v1(88.8,79.7) v1(88.91,82.72) v1(89.03,82.09) v1(89.03,81.45) v1(89.03,80.88) v1(89.29,88.07) v1(89.29,87.5) v1(89.29,86.93) v1(89.29,86.35) v1(89.29,85.78) v1(89.35,85.2) v1(89.35,84.63) v1(89.35,83.29) v1(89.38,80.27) v1(89.38,79.7) v1(89.54,82.72) v1(89.6,82.09) v1(89.6,81.45) v1(89.6,80.88) v1(89.86,86.35) v1(89.86,85.78) v1(89.99,84.63) v1(89.99,83.29) v1(90.11,82.72) v1(90.18,82.09) v1(90.18,81.45) v1(90.18,80.88) v1(90.43,85.91) v1(90.43,85.27) v1(90.68,84.7) v1(90.68,83.29) v1(90.68,82.72) v1(90.75,82.09) v1(90.75,81.45) v1(90.75,80.88) v1(91.38,83.23) v1(91.38,82.66) v1(91.38,82.09) v1(91.38,81.45) v1(91.38,80.88) v1(91.95,83.23) v1(91.95,82.66) v1(91.95,82.02) v1(91.95,81.45) v1(91.95,80.88) v1(92.51,82.87) v1(92.51,82.29) v1(92.51,81.71) v1(92.51,81.12) v1(92.51,80.55) v1(120.61,84.73) v1(121.01,86.77) v1(121.07,85.11) v1(121.53,84.73) v1(121.93,86.77) v1(121.97,85.11) v1(122.85,86.77) v1(122.92,85.11) v1(123.39,84.7) v1(123.78,86.77) v1(123.96,101.99) v1(124.18,84.91) v1(124.7,86.77) v1(124.7,85.15) v1(124.89,101.99) v1(125.48,101.99) v1(125.63,86.77) v1(125.69,85.15) v1(126.06,101.99) v1(126.09,84.73) v1(126.22,108.93) v1(126.55,86.77) v1(126.61,85.15) v1(126.81,108.93) v1(127.01,84.73) v1(127.39,108.93) v1(127.47,86.77) v1(127.51,85.11) v1(128.4,86.77) v1(128.4,85.11) v1(128.44,77.06) v1(128.85,84.77) v1(129.22,100.05) v1(129.32,85.11) v1(129.35,74.49) v1(129.79,84.77) v1(129.81,76.39) v1(130.03,108.93) v1(130.22,76.9) v1(130.24,88.67) v1(130.24,88.04) v1(130.24,87.4) v1(130.24,86.77) v1(130.24,85.11) v1(130.26,74.49) v1(130.62,108.93) v1(130.72,76.39) v1(130.89,76.92) v1(131.17,88.67) v1(131.17,88.04) v1(131.17,87.4) v1(131.17,86.77) v1(131.17,85.11) v1(131.17,74.49) v1(131.37,101.95) v1(131.62,101.44) v1(131.58,84.7) v1(131.98,85.1) v1(132.09,88.67) v1(132.09,87.4) v1(132.4,84.7) v1(132.54,76.39) v1(133.02,88.67) v1(133.02,88.04) v1(133.02,87.4) v1(133.02,86.77) v1(132.94,74.51) v1(133.07,76.92) v1(133.45,76.39) v1(133.69,102.28) v1(133.7,101.72) v1(133.82,108.93) v1(133.91,74.49) v1(133.94,88.67) v1(134.25,101.56) v1(134.4,108.93) v1(134.6,84.7) v1(134.82,74.49) v1(134.86,88.67) v1(134.86,88.04) v1(134.86,87.4) v1(135.07,85.02) v1(135.28,76.39) v1(135.58,84.7) v1(135.79,86.77) v1(135.73,76.9) v1(135.73,74.49) v1(136.19,76.39) v1(136.71,85.4) v3(120.95,109.29)
