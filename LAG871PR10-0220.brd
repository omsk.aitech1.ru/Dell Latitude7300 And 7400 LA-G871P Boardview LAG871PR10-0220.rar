# Allegro board LAG871PR10-0220.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_VDD_PIC on TOP (solid shape): 26.61,94.95 26.61,93.97 26.53,93.89 24.7,93.89 24.46,93.65 24.46,92.69 24.41,92.63 24.23,92.63 24.22,92.64 24.22,93.14 24.18,93.18 23.67,93.18 23.67,92.72 23.58,92.63 22.45,92.63 21.85,93.22 21.85,94.8 22.2,95.15 26.41,95.15
+3.3V_VDD_PIC on TOP (solid shape): outline of 203 points within 17.79,67.94 36.33,82.16
+3.3V_VDD_PIC on BOTTOM (solid shape): 35.5,51.56 35.5,50.79 35.19,50.48 34.87,50.48 34.61,50.73 34.61,51.81 34.68,51.87 35.19,51.87
+3.3V_VDD_PIC on IN2 (solid shape): 29.53,95.24 29.53,94.99 29.22,94.67 29.22,94.26 28.85,93.9 28.07,93.9 28.01,93.97 27.86,93.97 27.85,93.97 27.76,93.99 27.66,93.97 27.65,93.97 27.23,93.97 27.22,93.97 27.12,93.99 27.02,93.97 27.01,93.97 26.58,93.97 26.51,93.9 22.06,93.9 21.69,94.26 21.69,95 22.06,95.36 27.69,95.36 27.7,95.37 29.41,95.37
+3.3V_VDD_PIC on IN4 (solid shape): outline of 607 points within 33.28,50.48 37.66,70.56
+3.3V_VDD_PIC on IN1: 17.91,87.62 17.91,81.53 18.09,81.35 18.56,81.35 18.78,81.13 18.98,81.13 19.12,81.27 19.12,81.74 19.02,81.84 19.02,81.84 18.99,81.87 18.99,86.1 23.5,90.61 23.5,94.3 23.12,94.68 22.01,94.68 21.85,94.52 21.85,91.56
+3.3V_VDD_PIC_PDA on BOTTOM (solid shape): 34.61,54.86 34.61,52.57 34.68,52.51 34.93,52.51 34.93,52.5 35.06,52.38 35.06,52.06 34.99,52 33.98,52 33.85,52.13 33.85,54.29 33.66,54.48 33.66,55.18 33.41,55.43 33.41,55.62 33.85,55.62
+3.3V_VDD_PIC_R on TOP (solid shape): 25.82,93.58 25.82,92.41 25.71,92.3 24.86,92.3 24.67,92.49 24.67,92.51 24.61,92.57 24.61,93.53 24.83,93.74 25.66,93.74
+3.3V_VDD_PIC_R on BOTTOM (solid shape): 25.71,93.14 25.71,92.53 25.47,92.3 25.47,90.31 25.34,90.18 24.88,90.18 24.74,90.32 24.74,91.61 24.36,91.99 23.78,91.99 23.55,92.21 23.55,93.57 23.75,93.76 25.09,93.76
+3.3V_VPS_UZ12 on BOTTOM (solid shape): 184.64,78.64 184.64,77.9 184.25,77.5 184.25,77.24 184.08,77.08 183.52,77.08 183.03,77.57 183.03,78.01 183.14,78.13 183.59,78.13 183.76,78.3 183.76,78.71 183.82,78.77 184.51,78.77
+3.3V_WLAN on TOP (solid shape): 266.8,55.73 266.8,53.36 266.21,52.77 264.32,52.77 264.29,52.74 263.37,52.74 263.18,52.92 263.18,55.77 263.25,55.83 266.7,55.83
+3.3V_WLAN on TOP (solid shape): outline of 109 points within 259.47,33.65 267.43,38.79
+3.3V_WLAN on BOTTOM (solid shape): outline of 738 points within 263.66,34.47 274.88,55.68
+3.3V_WLAN_UZ47 on TOP (solid shape): 264.99,43.43 264.99,42.73 265.05,42.67 265.79,42.67 265.84,42.62 265.84,41.4 265.53,41.09 265.53,40.64 265.47,40.58 265.04,40.58 264.93,40.46 264.93,39.43 264.48,38.98 261.12,38.98 260.93,39.17 260.93,40.8 261.05,40.92 262.77,40.92 262.8,40.95 262.89,40.95 263.15,41.21 263.15,41.31 263.17,41.33 263.17,42.18 263.15,42.2 263.15,42.38 263.02,42.51 263.02,43.24 263.4,43.62 264.8,43.62
+3.3V_WWAN on TOP (solid shape): 284.8,63.75 284.8,63.62 284.87,63.56 285.25,63.56 285.38,63.43 285.38,62.17 285.38,62.1 285.38,62.03 285.38,61.08 285.18,60.89 282.96,60.89 282.86,60.99 282.86,61.52 283.08,61.74 283.08,61.74 283.09,61.76 283.09,62.18 282.83,62.44 282.83,63.15 282.57,63.41 282.57,64.12 282.71,64.26 284.3,64.26
+3.3V_WWAN on TOP (solid shape): 247.09,44.75 247.09,44.2 247.52,43.77 247.52,43.12 247.94,42.7 247.94,40.99 247.46,40.51 246.13,40.51 245.9,40.64 245.65,40.57 245.58,40.55 245.52,40.57 245.26,40.64 245.03,40.51 244.16,40.51 243.91,40.25 243.47,40.25 243.15,40.57 243.15,40.89 243.27,41.01 243.72,41.01 243.91,41.21 243.91,42.02 243.98,42.08 244.24,42.08 245.12,41.21 246.94,41.21 247.33,41.6 247.33,42.32 246.41,43.24 246.41,43.59 246.26,43.74 246.25,43.75 246.21,43.86 246.12,43.94 246.09,43.96 245.94,44 245.79,43.97 245.78,43.97 244.7,43.97 244.62,44.05 244.62,44.22 244.7,44.3 246,44.3 246.16,44.47 246.22,44.47 246.43,44.68 246.43,44.7 246.55,44.82 247.01,44.82
+3.3V_WWAN on TOP (solid shape): outline of 100 points within 261.02,57.39 269.74,64.99
+3.3V_WWAN on BOTTOM (solid shape): 264.67,64.28 264.67,60.89 264.48,60.7 261.49,60.7 261.35,60.84 261.35,64.25 261.98,64.89 264.07,64.89
+3.3V_WWAN on BOTTOM (solid shape): 267.86,65.27 267.95,65.18 268.06,65.13 268.1,65.12 268.1,63.49 268.7,62.9 268.7,61.56 268.54,61.4 267.1,61.4 267.01,61.46 267.03,61.57 267.21,62.29 266.71,62.85 266.71,64.76 267.04,65.09 267.06,65.09 267.23,65.14 267.36,65.27
+3.3V_WWAN on BOTTOM (solid shape): outline of 169 points within 283.53,60.13 288.3,65.59
+3.3V_WWAN on IN4: outline of 82 points within 263.09,59.68 285.21,66.08
+3.3V_WWAN_UZ43 on TOP (solid shape): outline of 177 points within 259.56,54.86 265.82,61.09
+5V_ALW on TOP (solid shape): 79.91,76.13 79.91,74.79 79.71,74.59 78.78,74.59 78.64,74.72 78.64,76.11 78.86,76.32 79.73,76.32
+5V_ALW on TOP (solid shape): 82.54,88.76 82.54,88.04 82.53,88.02 82.53,87.81 81.22,86.5 79.31,86.5 79.18,86.63 79.18,87.63 80.42,88.87 82.42,88.87
+5V_ALW on TOP (solid shape): 266.26,31.8 266.26,31.43 266.68,31.02 266.68,29.75 266.63,29.7 265.89,29.7 265.8,29.8 265.8,30.3 265.28,30.81 265.28,31.68 265.5,31.9 266.16,31.9
+5V_ALW on TOP (solid shape): 76.13,78.18 76.23,78.08 76.23,77.01 76.07,76.86 74.45,76.86 74.08,77.22 74.06,77.24 74.06,77.92 74.32,78.18 75.76,78.18
+5V_ALW on TOP (solid shape): 92.13,94.51 92.13,93.31 91.9,93.07 91.9,92.47 91.8,92.38 91.52,92.38 91.52,92.37 91.05,92.37 90.96,92.46 90.96,93.06 91.07,93.16 91.28,93.16 91.83,93.71 91.83,94.51 91.89,94.57 92.07,94.57
+5V_ALW on TOP (solid shape): 93.41,29.39 93.41,28.14 92.96,27.68 92.96,26.52 92.84,26.41 92.02,26.41 91.83,26.6 91.83,28.51 91.83,28.52 91.83,28.71 92.31,28.71 92.31,29.1 91.83,29.1 91.83,29.46 91.89,29.52 93.29,29.52
+5V_ALW on TOP (solid shape): 295.2,75.11 295.2,73.4 294.98,73.18 294.45,73.18 294.37,73.21 294.35,73.29 294.26,73.57 293.99,73.67 293.91,73.7 293.88,73.77 293.88,75.07 294.06,75.25 295.06,75.25
+5V_ALW on TOP (solid shape): 291.24,78.09 291.54,77.9 291.83,78.09 292.51,78.09 292.73,77.87 292.73,76.96 292.6,76.83 291.09,76.83 290.86,76.6 290.54,76.6 290.35,76.41 290.35,76.15 289.95,75.75 289.38,75.75 289.37,75.75 289.32,75.75 289.13,75.56 288.87,75.56 288.55,75.88 288.55,77.55 288.81,77.81 288.81,77.89 288.82,77.89 288.82,78.11 288.93,78.23 291.1,78.23
+5V_ALW on TOP (solid shape): 38.14,65.24 38.92,65.24 39.32,64.85 39.32,63.37 38.87,62.92 38.42,62.92 38.23,62.73 38.23,61.97 37.79,61.53 37.21,61.53 36.9,61.98 36.59,61.53 36.25,61.53 36.06,61.72 36.06,62.87 35.53,62.87 35.53,63.16 36.06,63.16 36.06,63.67 35.53,63.67 35.53,63.96 36.06,63.96 36.06,64.54 36.08,64.57 36.08,65.68 36.38,65.98 37.39,65.98
+5V_ALW on TOP (solid shape): 38.55,33.78 40.2,33.78 41.03,32.95 41.03,30.47 39.44,28.89 39.44,27.71 39.22,27.5 37.67,27.5 37.67,27.98 37.01,27.98 37.01,27.5 36.47,27.5 36.47,27.98 35.81,27.98 35.81,27.5 34.43,27.5 34.14,27.79 34.14,28.59 34.18,28.7 34.18,28.82 34.2,28.9 34.27,28.94 34.56,29.32 34.16,29.59 34.14,29.59 34.14,33.05 34.61,33.52 36.01,33.52 36.52,34.03 38.3,34.03
+5V_ALW on TOP (solid shape): 34.82,41.55 34.82,40.68 33.93,39.79 33.51,39.79 32.92,40.38 30.31,40.38 29.85,39.92 29.85,38.54 29.6,38.28 27.95,38.28 27.57,38.66 27.57,40.74 28.46,41.63 31.34,41.63 31.34,41.57 31.34,41.52 31.36,41.47 31.38,41.43 31.42,41.38 31.45,41.35 31.49,41.32 31.54,41.29 31.59,41.28 31.64,41.27 31.69,41.27 31.74,41.28 31.79,41.29 31.84,41.32 31.88,41.35 31.92,41.38 31.95,41.43 31.97,41.47 31.99,41.52 32,41.57 32,41.63 31.99,41.68 31.97,41.73 31.95,41.77 31.92,41.81 31.88,41.85 31.84,41.88 31.79,41.91 31.74,41.92 31.69,41.93 31.64,41.93 31.59,41.92 31.54,41.91 31.49,41.88 31.45,41.85 31.42,41.81 31.38,41.77 31.36,41.73 31.34,41.68 31.34,41.63 28.46,41.63 28.58,41.75 28.58,42.53 28.9,42.86 29.72,42.86 30.3,43.43 32.94,43.43
+5V_ALW on TOP (solid shape): 269.42,47 269.42,44.81 268.57,43.95 268.25,43.95 268.2,43.9 267.28,43.9 267.19,43.99 267.19,44.59 267.19,44.59 267.19,44.79 267.03,45.36 266.67,44.88 266.68,44.87 266.68,43.94 266.64,43.9 266.42,43.9 266.39,43.94 266.39,44.8 266.47,45.02 266.39,45.23 266.39,45.27 266.41,45.27 266.41,45.42 266.46,45.47 266.46,45.79 266.85,46.18 266.98,46.18 267.25,46.46 267.25,46.58 267.73,47.06 269.36,47.06
+5V_ALW on BOTTOM (solid shape): 266.15,33.22 266.15,30.92 266.02,30.79 265.37,30.79 265.28,30.88 265.28,33.25 265.37,33.34 266.03,33.34
+5V_ALW on BOTTOM (solid shape): 30.68,42.08 30.68,41.29 30.47,41.08 30.47,38.55 30.33,38.41 28.09,38.41 27.92,38.58 27.92,41.23 29,42.31 30.45,42.31
+5V_ALW on BOTTOM (solid shape): 75.12,77.87 75.12,77.67 75.37,77.42 75.37,76.84 75.32,76.79 74.42,76.79 74.05,77.16 74.05,77.87 74.21,78.04 74.95,78.04
+5V_ALW on BOTTOM (solid shape): 81.44,89.45 81.44,89.36 81.93,88.87 82.46,88.87 82.54,88.79 82.54,88.43 82.42,88.31 81.12,88.31 80.24,89.19 79.55,89.19 79.48,89.25 79.48,89.46 79.55,89.52 81.37,89.52
+5V_ALW on BOTTOM (solid shape): 79.19,76.96 79.19,76.38 79.77,75.79 79.93,75.79 80.02,75.7 80.02,75.18 79.91,75.07 79.91,75.06 79.88,75.04 79.88,74.72 79.78,74.61 78.93,74.61 78.72,74.67 78.63,74.86 78.63,74.97 78.52,75.08 78.52,75.89 78.84,76.2 78.84,76.95 78.93,77.05 79.1,77.05
+5V_ALW on BOTTOM (solid shape): 70.49,70.23 70.49,69.87 70.63,69.74 71.73,69.74 71.81,69.66 71.81,68.99 71.69,68.87 70.36,68.87 70.02,69.2 69.93,69.58 69.55,69.61 69.45,69.61 69.4,69.7 69.4,70.32 69.5,70.42 70.3,70.42
+5V_ALW on BOTTOM (solid shape): outline of 107 points within 74.33,61.08 77.5,67.79
+5V_ALW on BOTTOM (solid shape): outline of 205 points within 288.51,73.57 295.17,77.97
+5V_ALW on BOTTOM (solid shape): outline of 437 points within 162.44,24.42 182.78,29.09
+5V_ALW on IN1 (solid shape): 75.17,77.92 75.17,77.28 74.43,76.53 72.94,76.53 72.68,76.8 72.68,77.73 73.01,78.06 75.03,78.06
+5V_ALW on IN1 (solid shape): 65.47,50.01 65.47,49.72 64.63,48.88 64.44,48.88 62.9,50.41 62.9,50.94 63.13,51.17 64.31,51.17
+5V_ALW on IN3 (solid shape): 82.87,88.78 82.87,88.16 82.74,88.02 81.49,88.02 81.34,88.18 81.34,88.81 81.44,88.91 82.74,88.91
+5V_ALW on IN4 (solid shape): 76.09,78.17 76.09,76.97 75.98,76.86 74.14,76.86 73.99,77.01 73.99,78.03 74.19,78.23 76.03,78.23
+5V_ALW on IN4 (solid shape): 84.61,88.72 84.61,87.18 84.42,86.99 83.63,86.99 82.96,87.67 81.52,87.67 81.34,87.85 81.34,88.25 81.34,88.25 81.34,88.71 81.51,88.88 84.44,88.88
+5V_ALW on IN1: 75,51.11 71.44,54.67 71.44,55.94 71.89,56.38 72.4,56.38 73.86,54.92 74.28,54.92 74.42,55.06 74.44,55.06 74.44,56.83 74.49,56.91 74.59,56.92 75.06,57.22 74.59,57.52 74.49,57.52 74.44,57.61 74.44,57.69 74.45,57.72 74.45,57.83 71.01,61.26 71.01,66.91 70.51,67.41 70.51,69.17 69.9,69.78 69.52,69.78 69.4,69.9 69.4,71.32 69.75,71.67 71.34,71.67 73.09,69.91 73.12,69.82 73.05,69.74 72.9,69.19 73.45,69.34 73.53,69.41 73.62,69.38 73.79,69.22 73.79,68.96 75.21,67.54 75.21,67.44 75.24,67.41 75.24,63.94 77.41,61.76 77.41,54.82 76.3,53.71 76.3,51.26 76.15,51.11
+5V_ALW on IN3: 173.93,28.51 172.92,27.49 162.44,27.49 160.66,29.27 156.72,29.27 155.77,28.31 149.74,28.31 148.77,27.35 120.78,27.35 120.41,26.98 104.08,26.98 103.77,27.3 103.77,27.35 73.81,27.35 71,30.16 70.81,29.97 55.89,29.97 53.98,28.06 50.68,28.06 49.83,27.21 42.43,27.21 42.2,27.45 42.2,27.68 42.02,27.85 40.54,27.85 40.36,28.02 40.36,28.45 40.26,28.56 39.78,28.56 39.65,28.43 39.65,27.67 39.47,27.5 37.94,27.5 36.5,28.94 36.5,37.14 36.78,37.14 37.36,37.71 43.13,37.71 43.29,37.55 45.46,37.55 47.77,39.86 68,39.86 69.6,41.46 95.98,41.46 97.04,42.53 130.42,42.53 130.45,42.49 133.87,42.49 137.8,38.56 169.8,38.56 170.26,38.1 173.22,38.1 173.23,38.09 173.3,38.09 173.49,38.28 199.84,38.28 202.44,35.69 205.62,35.69 206.25,35.05 206.25,28.38 204.92,27.04 199.9,27.04 198.82,28.12 191.4,28.12 190.95,27.68 185.62,27.68 185.05,27.11 181.11,27.11 179.58,28.63 179.58,28.95 178.63,29.9 177.3,29.9 175.9,28.51
+5V_ALW on VCC: 204.71,27.36 201.3,30.77 201.3,31.89 204.6,35.19 204.6,41.29 208.82,37.08 256.52,37.08 261.25,41.8 261.25,42.18 267.21,48.15 267.21,50.18 271.03,54 271.03,54 271.03,56.78 271.52,57.27 273.93,57.27 274.33,57.67 274.33,59.06 275.46,60.19 277.88,60.19 277.91,60.22 278.04,60.4 281.74,67.11 282.12,67.62 282.85,68.6 284.34,70.09 284.75,70.5 284.75,74.32 286.39,75.96 286.39,77.85 286.64,78.1 289.57,78.1 291.09,76.58 291.09,75.54 290.45,74.9 290.45,67.66 285.87,63.08 285.87,61.69 284.61,60.43 284.61,55.24 281.59,55.24 280.7,54.35 278.67,54.35 273.06,48.74 273.06,46.45 270.01,43.41 270.01,31.85 269.65,31.49 232.31,31.49 228.18,27.36
+5V_ALW on VCC: 38.34,28.57 37.6,29.31 37.6,31.6 35.69,33.5 35.69,65.17 36.31,65.78 40.79,65.78 41.92,64.66 41.92,48.15 43.33,46.73 57.39,46.73 61.82,51.16 64.05,51.16 64.73,50.49 64.73,50.37 55.38,41.02 55.38,31.24 49.05,31.24 46.38,28.57
+5V_ALW2 on TOP (solid shape): 43.18,31.37 43.18,30.8 43.68,30.31 43.68,29.36 43.61,29.29 43.47,29.29 42.73,30.03 42.73,30.3 42.47,30.56 42.47,31.32 42.56,31.4 42.56,31.44 42.73,31.44 42.73,31.45 43.11,31.45
+5V_ALW_PDA on TOP (solid shape): outline of 347 points within 31.25,60.73 35.95,66.48
+5V_ALW_PDA on BOTTOM (solid shape): 35.6,68.2 35.6,61.6 35.5,61.51 34.68,61.51 34.68,61.51 34.03,60.86 32.26,60.86 32.16,60.96 32.16,61.21 32.29,61.34 32.32,61.35 32.36,61.37 32.37,61.38 32.57,61.58 32.57,61.71 33.58,61.71 33.58,61.66 33.58,61.61 33.6,61.56 33.62,61.51 33.65,61.47 33.69,61.43 33.73,61.4 33.78,61.38 33.83,61.36 33.88,61.36 33.93,61.36 33.98,61.36 34.03,61.38 34.08,61.4 34.12,61.43 34.16,61.47 34.19,61.51 34.21,61.56 34.23,61.61 34.24,61.66 34.24,61.71 34.23,61.76 34.21,61.81 34.19,61.86 34.16,61.9 34.12,61.94 34.08,61.97 34.03,61.99 33.98,62.01 33.93,62.02 33.88,62.02 33.83,62.01 33.78,61.99 33.73,61.97 33.69,61.94 33.65,61.9 33.62,61.86 33.6,61.81 33.58,61.76 33.58,61.71 32.57,61.71 32.57,62.11 32.59,62.12 32.63,62.15 32.67,62.19 32.7,62.23 32.73,62.27 32.74,62.32 32.75,62.37 32.76,62.42 32.75,62.48 32.74,62.53 32.72,62.58 32.7,62.62 32.67,62.66 32.65,62.68 32.65,62.99 32.88,63.22 34.63,63.22 34.73,63.32 34.73,68.19 34.82,68.28 35.52,68.28
+5V_ALW_PDA on IN2 (solid shape): outline of 259 points within 29.28,59.56 34.87,63.51
+5V_ALWP on TOP (solid shape): 38.81,27.31 40.95,25.18 40.95,23.01 41.19,22.77 41.21,22.75 41.81,22.75 41.92,22.65 41.92,20.72 40.95,19.76 40.95,17.72 40.34,17.11 37.68,17.11 36.86,17.93 36.86,20.98 36.29,21.55 36.26,21.58 36.21,21.63 36.16,21.68 36.13,21.71 35.81,22.03 35.81,23.35 38.6,23.35 38.6,23.3 38.62,23.24 38.64,23.19 38.66,23.15 38.7,23.11 38.73,23.07 38.78,23.04 38.83,23.02 38.88,23 38.93,22.99 38.96,22.99 39.24,22.99 39.24,22.8 40.08,22.8 40.08,23.9 39.24,23.9 39.24,23.71 38.96,23.71 38.93,23.7 38.88,23.7 38.83,23.68 38.78,23.66 38.73,23.63 38.7,23.59 38.66,23.55 38.64,23.5 38.62,23.45 38.6,23.4 38.6,23.35 35.81,23.35 35.81,25.5 35.7,25.61 34.81,25.61 34.42,26 34.42,27.16 34.57,27.31 38.69,27.31
+5V_ALWP on BOTTOM (solid shape): 41.56,24.57 41.56,23.72 41.31,23.72 41.28,23.72 41.23,23.71 41.18,23.69 41.13,23.67 41.08,23.64 41.05,23.6 41.01,23.56 40.99,23.52 40.97,23.47 40.95,23.42 40.95,23.36 40.95,23.31 40.97,23.26 40.99,23.21 41.01,23.16 41.05,23.12 41.08,23.08 41.13,23.05 41.18,23.03 41.23,23.01 41.28,23.01 41.31,23.01 41.56,23.01 41.56,21.72 40.84,21 40.84,17.63 40.33,17.13 37.66,17.13 36.86,17.93 36.86,20.98 36.29,21.55 36.26,21.58 36.21,21.63 36.16,21.68 36.13,21.71 35.25,22.59 35.25,23.35 38.6,23.35 38.6,23.3 38.62,23.24 38.64,23.19 38.66,23.15 38.7,23.11 38.73,23.07 38.78,23.04 38.83,23.02 38.88,23 38.93,22.99 38.96,22.99 39.24,22.99 39.24,22.8 40.08,22.8 40.08,23.9 39.24,23.9 39.24,23.71 38.96,23.71 38.93,23.7 38.88,23.7 38.83,23.68 38.78,23.66 38.73,23.63 38.7,23.59 38.66,23.55 38.64,23.5 38.62,23.45 38.6,23.4 38.6,23.35 35.25,23.35 35.25,27.41 35.76,27.92 38.2,27.92
+5V_ALWP on IN1: 40.32,17.09 37.7,17.09 36.86,17.93 36.86,20.98 36.34,21.5 36.34,25.41 38.09,27.16 38.97,27.16 40.62,25.51 40.62,23.24 41.2,22.67 41.2,17.97
+5V_ALWP on IN2: 40.32,17.09 37.7,17.09 36.86,17.93 36.86,20.98 36.34,21.5 36.34,27.17 36.48,27.31 38.8,27.31 39.65,26.46 39.65,24.21 41.2,22.67 41.2,17.97
+5V_ALWP on IN3: 40.32,17.09 37.7,17.09 36.86,17.93 36.86,20.98 36.34,21.5 36.34,27.17 36.48,27.31 38.8,27.31 39.65,26.46 39.65,24.22 41.2,22.67 41.2,17.97
+5V_PD_VDD on TOP (solid shape): 26.75,89.32 26.75,88.3 26.22,87.78 25.3,87.78 25.18,87.9 25.18,88.57 25.25,88.64 25.25,89.12 25.71,89.59 26.49,89.59
+5V_PD_VDD on BOTTOM (solid shape): 23.93,35.4 23.93,34.19 23.78,34.03 22.49,34.03 22.48,34.03 22.05,34.03 21.79,34.29 21.79,35.48 21.92,35.61 23.73,35.61
+5V_PD_VDD on BOTTOM (solid shape): 24.64,91.08 24.64,90.16 24.83,89.97 25.71,89.97 25.81,89.88 25.81,89.45 26.26,89 26.26,87.89 26.13,87.76 25.33,87.76 25.13,87.97 25.14,88.02 25.14,88.07 25.13,88.12 25.12,88.17 25.09,88.21 25.06,88.26 25.03,88.29 24.99,88.32 24.94,88.35 24.89,88.37 24.84,88.38 24.79,88.38 24.74,88.37 24.69,88.36 24.66,88.34 24.3,88.34 24.2,88.38 23.87,88.7 23.47,88.7 23.43,88.74 23.43,88.91 24.51,88.91 24.51,88.88 24.52,88.83 24.53,88.78 24.56,88.73 24.59,88.69 24.63,88.65 24.67,88.62 24.71,88.6 24.76,88.58 24.81,88.57 24.87,88.57 24.92,88.58 24.97,88.6 25.01,88.62 25.06,88.65 25.09,88.69 25.12,88.73 25.15,88.78 25.16,88.83 25.17,88.88 25.17,88.93 25.16,88.98 25.15,89.03 25.12,89.08 25.09,89.12 25.06,89.16 25.01,89.19 24.97,89.21 24.92,89.23 24.87,89.24 24.81,89.24 24.76,89.23 24.71,89.21 24.67,89.19 24.63,89.16 24.59,89.12 24.56,89.08 24.53,89.03 24.52,88.98 24.51,88.93 24.51,88.91 23.43,88.91 23.43,91.06 23.64,91.27 24.44,91.27
+5V_PD_VDD on IN1: 15.82,62.29 15.82,68.76 17.6,70.54 19.06,70.54 19.5,70.99 19.5,77.65 18.61,78.54 18.61,80.51 19.23,81.13 19.23,81.79 19.12,81.89 19.12,85.21 23.56,89.66 26.3,89.66 26.8,89.15 26.8,87.69 25.53,86.42 24.63,86.42 24.59,86.45 22.75,86.45 20.94,84.65 20.64,84.65 20.64,84.64 20.39,84.39 20.39,82.8 20.33,82.73 20.33,80 20.87,79.46 20.87,73.25 21.28,72.84 21.11,72.67 21.11,70.92 21.02,70.92 20.92,70.82 20.92,69.98 19.96,69.02 18.04,69.02 17.15,68.13 17.15,63.6 19.41,61.33 19.41,51.72 20.02,51.12 20.02,36.56 20.87,35.71 22.66,35.71 22.93,35.43 22.93,34.51 22.65,34.22 20.26,34.22 18.31,36.18 18.31,43.66 18.04,43.92 18.04,50.29 16.64,51.68 16.64,61.46
+5V_RUN on TOP (solid shape): 247.59,30.91 247.59,30.09 247.41,29.92 246.82,29.92 246.47,30.27 246.47,30.91 246.6,31.05 247.45,31.05
+5V_RUN on TOP (solid shape): 83.38,109.66 83.38,109.15 83.19,108.96 82.75,108.96 82.27,108.47 82.27,108.37 81.98,108.09 81.11,108.09 81.06,108.14 81.06,108.48 81.14,108.56 81.14,108.56 81.34,108.76 81.71,108.76 81.71,109.65 81.85,109.79 83.25,109.79
+5V_RUN on TOP (solid shape): 272.93,40.82 272.93,40.19 272.61,39.87 272.61,37.2 272.55,37.14 271.63,37.14 271.26,37.51 271.26,38.8 271.77,38.8 271.77,39.25 271.26,39.25 271.26,39.6 271.77,39.6 271.77,40.05 271.26,40.05 271.26,41.16 271.56,41.46 272.29,41.46
+5V_RUN on TOP (solid shape): 259.68,33.5 259.91,33.24 260.25,33.22 260.34,33.21 260.38,33.13 260.38,32.12 260.27,32.01 259.29,32.01 259.23,32.08 259.23,32.72 259.08,32.86 259.08,33.46 259.15,33.53 259.67,33.53
+5V_RUN on TOP (solid shape): 291.95,51.66 291.95,51.65 292.85,51.65 293.18,51.33 293.18,50.78 293.18,50.73 293.33,50.58 293.9,50.58 293.97,50.51 293.97,49.84 294,49.81 294,48.76 294.28,48.47 295.32,48.47 295.47,48.32 295.47,47.62 295.28,47.43 293.55,47.43 292.55,48.33 291.3,48.82 291.28,48.82 291.15,48.95 290.01,48.95 289.95,49.01 289.95,50.93 289.93,50.95 289.93,50.97 289.36,50.97 289.36,51.22 289.93,51.22 289.93,51.77 289.37,51.77 289.37,52.01 289.93,52.01 289.93,52.51 290.09,52.66 290.95,52.66
+5V_RUN on BOTTOM (solid shape): 26.69,46.89 26.69,45.66 26.46,45.44 24.29,45.44 24.01,45.72 24.01,46.79 24.38,47.16 26.42,47.16
+5V_RUN on BOTTOM (solid shape): 192.48,83.5 192.48,82.93 192.17,82.61 190.83,82.61 190.82,82.61 190.49,82.61 189.88,82 189.88,81.56 189.75,81.44 188.77,81.44 187.81,82.4 187.21,82.4 186.98,82.63 186.98,83.52 187.02,83.56 188.6,83.56 188.73,83.68 192.3,83.68
+5V_RUN on BOTTOM (solid shape): 247.28,33.14 247.28,31.52 247.27,31.51 247.31,31.25 247.53,31.1 247.57,31.09 247.57,30.54 247.51,30.47 246.66,30.47 246.49,30.64 246.49,31.58 246.89,31.98 246.89,33.14 246.98,33.23 247.19,33.23
+5V_RUN on IN1 (solid shape): 183.9,61.21 183.9,60.19 183.78,60.06 182.12,60.06 182.06,60.13 182.06,61.14 182.44,61.53 183.58,61.53
+5V_RUN on IN1 (solid shape): 207.33,26.35 207.33,24.82 207.14,24.63 203.78,24.63 203.59,24.82 203.59,25.57 204.62,26.6 207.08,26.6
+5V_RUN on IN2 (solid shape): outline of 142 points within 181.74,75.75 190.76,78.23
+5V_RUN on IN3 (solid shape): 183.52,62.48 183.52,60.51 183.46,60.45 182.44,60.45 182.19,60.7 182.19,61.97 182.23,62.02 182.23,62.08 182.82,62.67 183.33,62.67
+5V_RUN on IN3 (solid shape): 189.79,83.12 189.79,82.8 190.63,81.96 190.63,77.34 190.38,77.08 189.91,77.08 189.25,77.74 189.25,81.24 189.17,81.32 189.17,81.59 188.35,82.42 188.35,83.43 188.66,83.75 189.16,83.75
+5V_RUN on IN3 (solid shape): 183.71,75.28 183.71,75.24 183.01,74.54 182.45,74.54 182.45,74.59 182.38,74.81 182.17,74.93 182.1,74.98 182.09,75.06 181.85,75.5 181.45,75.21 181.4,75.17 181.35,75.2 181.33,75.26 181.3,75.31 181.3,76.57 181.43,76.7 182.29,76.7
+5V_RUN on IN4 (solid shape): 26.42,46.6 26.42,45.65 26.1,45.33 23.44,45.33 21.1,47.67 21.14,47.71 21.17,48.12 20.78,48.25 20.69,48.26 20.64,48.34 20.64,49.33 20.93,49.62 23.41,49.62
+5V_RUN on VCC: outline of 171 points within 9.53,1.17 315.51,113.13 ; 1 cut-out
+5V_RUN_AUDIO on TOP (solid shape): outline of 233 points within 276.04,48 290.26,55.3
+5V_RUN_AUDIO on BOTTOM (solid shape): outline of 147 points within 278.07,48.44 289.19,54.79
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): 292.24,55.25 292.24,54.38 292.77,53.85 293.29,53.85 293.36,53.79 293.36,53.31 293.96,52.71 293.96,51.86 293.9,51.79 291.96,51.79 290.99,52.76 290.99,52.76 290.93,52.82 290.9,52.89 290.93,52.96 290.99,53.38 290.59,53.52 290.53,53.51 290.47,53.56 290.4,53.62 290.4,55.21 290.6,55.41 292.07,55.41
+5V_RUN_PVDD_L on TOP (solid shape): 281.74,49.92 281.74,49.16 281.45,48.86 281.45,48.09 281.32,47.97 280.74,47.97 280.68,48.02 280.68,49.37 281.35,50.04 281.63,50.04
+5V_RUN_PVDD_L on TOP (solid shape): 282.36,44.35 282.04,44.02 282.04,43.12 281.98,43.06 281.85,43.06 281.81,43.1 281.81,44.16 282.11,44.46 282.11,44.99 282.13,45.02 282.36,45.02
+5V_RUN_PVDD_L on TOP (solid shape): 277.76,49.47 277.76,49.03 277.77,49.03 278.08,48.72 278.08,48.67 278.19,48.55 278.19,46.1 278.26,46.03 278.26,45.82 278.91,45.18 279.48,44.61 279.73,44.61 280.04,44.3 280.04,43.1 279.99,43.05 279.83,43.05 279.79,43.09 279.79,43.85 279.72,43.92 279.72,43.97 279.2,44.49 278.87,44.49 278.81,44.56 278.81,44.57 278.65,44.76 278.4,44.72 278.27,44.72 277.45,45.55 277.31,45.68 277.31,45.69 277.2,45.8 277.2,46.59 276.87,46.93 276.87,47.81 276.71,47.96 276.7,47.95 276.43,47.95 276.1,48.28 276.1,48.76 276,48.86 276,49.49 276.15,49.64 277.59,49.64
+5V_RUN_PVDD_L on IN2 (solid shape): outline of 81 points within 277.11,47.86 281.83,50.15
+5V_RUN_UZ47 on TOP (solid shape): outline of 97 points within 267.18,38.22 271.09,42.98
+5V_TBT_VBUS on BOTTOM (solid shape): 21.54,34.98 21.54,31.82 21.32,31.6 20.81,31.6 20.5,31.28 20.28,31.28 20.13,31.14 19.85,31.14 19.84,31.17 19.53,31.4 19.21,31.17 19.2,31.14 18.57,31.14 18.46,31.24 18.46,32.16 18.55,32.24 19.58,32.24 19.58,32.24 20.03,32.24 20.03,34.97 20.14,35.08 21.43,35.08
+5V_TBTA_VBUS_D on BOTTOM (solid shape): 25.37,32.51 25.37,31.96 25.01,31.6 22.28,31.6 22.2,31.68 22.2,32.67 22.36,32.83 25.05,32.83
+5V_USB_CHG_PWR on TOP (solid shape): 297.43,79.82 297.43,77 297.35,76.92 294.97,76.92 294.91,76.98 294.91,77.29 294.95,77.37 295.03,77.39 295.38,77.55 295.34,77.94 295.31,78 295.34,78.07 295.35,78.5 294.93,78.58 294.89,78.56 294.59,78.86 294.59,79.38 294.69,79.48 296.79,79.48 296.8,79.48 296.82,79.48 296.92,79.58 296.92,79.71 297.07,79.86 297.39,79.86
+5V_USB_CHG_PWR on BOTTOM (solid shape): 306.01,72.36 306.01,70.18 305.91,70.09 300.82,70.09 300.71,70.2 300.71,72.36 300.84,72.5 305.86,72.5
+5V_USB_CHG_PWR on IN1 (solid shape): 301.36,80.18 301.36,79.51 301.76,79.1 301.76,77.61 301.76,77.57 301.46,77.57 301.39,77.58 301.31,77.58 300.3,77.58 299.55,76.83 300.3,76.08 301.31,76.08 301.47,76.1 301.62,76.15 301.72,76.14 301.76,76.05 301.76,73.29 302.05,73 303.7,73 303.98,72.72 303.98,71.72 303.69,71.43 299.6,71.43 297.73,73.3 297.73,76.51 297.73,76.51 297.73,76.72 296.97,77.48 296.97,79.74 297.07,79.84 299.95,79.84 300.45,80.34 301.2,80.34
+13.2VB_BATT on BOTTOM (solid shape): 240.36,42.06 240.36,39.57 239.98,39.19 235,39.19 233.97,38.17 231.2,38.17 231.15,38.22 231.15,41.89 231.27,42.02 232.28,42.02 233.06,42.8 239.62,42.8
+13.2VB_PBATT_C on BOTTOM (solid shape): 240.27,38.53 240.27,37.12 239.66,36.51 239.66,35.62 239.59,35.55 237.94,35.55 237.62,35.24 237.62,34.41 237.34,34.13 233.53,34.13 233.43,34.22 233.43,36.32 233.44,36.32 233.44,37.28 235,38.85 239.96,38.85
+13.5VB on TOP (solid shape): 53.18,33.96 53.18,32.55 53.02,32.38 50.14,32.38 50.02,32.5 50.02,33.94 50.22,34.15 53,34.15
+13.5VB on TOP (solid shape): 58.64,54.08 58.64,52.01 58.49,51.86 55.31,51.86 55.15,52.02 55.15,54.08 55.29,54.23 58.5,54.23
+13.5VB on TOP (solid shape): 185.11,109.31 185.11,107.11 185.62,107.11 185.62,106.86 185.11,106.86 185.11,106.31 185.62,106.31 185.62,106.06 185.62,106.06 185.11,106.06 185.11,105.55 185.02,105.46 182.22,105.46 182.05,105.64 182.05,109.4 182.37,109.72 184.7,109.72
+13.5VB on TOP (solid shape): outline of 172 points within 57.4,80 69.48,87.05
+13.5VB on TOP (solid shape): outline of 99 points within 75.14,94.4 105.23,106.93
+13.5VB on BOTTOM (solid shape): 53.22,33.9 53.22,31.74 52.77,31.3 48.27,31.3 48.14,31.43 48.14,33.46 48.39,33.71 50.62,33.71 51.06,34.16 52.97,34.16
+13.5VB on BOTTOM (solid shape): 192.47,103.05 192.47,102.17 192.03,101.72 189.11,101.72 188.98,101.85 188.98,103.31 189.17,103.5 192.03,103.5
+13.5VB on BOTTOM (solid shape): 97.57,100.97 97.57,100.61 97.19,100.23 97.19,99.48 97.74,99.48 97.74,99.29 97.19,99.29 97.19,98.62 97.1,98.53 96,98.53 95.66,98.2 94.74,98.2 94.47,97.92 94.47,96.73 93.85,96.11 93.2,96.11 93.09,96.23 93.09,97.47 94.37,98.75 94.37,99.28 94.5,99.41 96.02,99.41 96.2,99.59 96.2,100.83 96.44,101.06 97.47,101.06
+13.5VB on BOTTOM (solid shape): outline of 116 points within 58.2,80.58 69.35,87.05
+13.5VB on BOTTOM (solid shape): outline of 235 points within 195.27,56.98 206.19,85.45
+13.5VB on BOTTOM (solid shape): outline of 3793 points within 53.47,32.54 226.86,72.94
+13.5VB on IN1 (solid shape): 53.35,40 53.35,32.06 52.77,31.49 49.92,31.49 47.19,34.22 47.19,39.68 47.89,40.38 52.97,40.38
+13.5VB on IN1 (solid shape): 199.4,85.72 200.79,85.72 201,85.51 201.24,84.11 201.24,82.54 200.86,82.16 198.86,82.16 197.81,83.21 197.81,85.78 198.19,86.16 198.95,86.16
+13.5VB on IN1 (solid shape): outline of 93 points within 182.63,101.72 194,109.59
+13.5VB on IN2 (solid shape): 58.64,54.08 58.64,52.01 58.49,51.86 55.31,51.86 55.15,52.02 55.15,54.08 55.29,54.23 58.5,54.23
+13.5VB on IN2 (solid shape): 199.4,85.72 200.79,85.72 201,85.51 201.24,84.11 201.24,82.54 200.86,82.16 199.71,82.16 198.99,82.89 198.99,84.22 197.72,85.5 197.72,85.69 198.19,86.16 198.95,86.16
+13.5VB on IN2 (solid shape): outline of 192 points within 182.63,101.72 194,109.59
+13.5VB on IN2 (solid shape): outline of 220 points within 57.6,80.38 67.91,87.12
+13.5VB on IN3 (solid shape): outline of 784 points within 182.63,82.32 201.12,109.59
+13.5VB on IN4 (solid shape): 58.64,54.08 58.64,52.01 58.49,51.86 55.31,51.86 55.15,52.02 55.15,54.08 55.29,54.23 58.5,54.23
+13.5VB on IN4 (solid shape): 194,103.37 194,102.67 193.05,101.72 189.95,101.72 189.74,101.93 189.74,103.58 189.85,103.69 193.68,103.69
+13.5VB on IN4 (solid shape): 199.4,85.72 200.79,85.72 201,85.51 201.24,84.11 201.24,82.54 200.86,82.16 199.71,82.16 199.04,82.83 199.04,84.2 197.71,85.53 197.71,85.69 198.19,86.16 198.95,86.16
+13.5VB on IN1: 67.19,70.67 61.63,65.11 61.63,44.19 53.76,36.32 49.35,36.32 47.78,37.88 47.78,42.56 51.5,46.28 51.5,56.57 51.85,56.91 51.85,63.96 54.3,66.41 54.3,68.76 55.31,69.78 55.95,69.78 56.39,70.22 56.39,72.83 55.44,73.78 55.44,79.5 57.82,81.88 57.82,86.26 59.06,87.5 66.43,87.5 67.19,86.73
+13.5VB on IN3: 67.19,70.67 61.63,65.11 61.63,62.83 59.21,60.41 59.21,52.61 58.49,51.88 54.92,51.88 54.66,52.14 54.66,61.45 54.23,61.88 53.65,62.46 53.4,62.71 53.4,64.08 54.97,65.64 54.97,69.43 55.31,69.78 55.95,69.78 56.39,70.22 56.39,72.83 55.86,73.36 55.86,74.58 55.44,75 55.44,79.5 57.82,81.88 57.82,86.26 59.06,87.5 66.43,87.5 67.19,86.73
+13.5VB on VCC: 65.41,83.31 65.41,89.42 72.63,96.64 83.85,96.64 84.36,96.13 89.46,96.13 89.54,96.05 89.54,94.22 89.17,93.85 82.66,93.85 82.15,94.35 78.77,94.35 67.72,83.31 ; 1 cut-out
+13.5VB_1.05VALWP on TOP (solid shape): 191.24,108.53 191.24,107.09 191.14,106.99 190.14,106.99 189.61,106.46 189.61,106.01 189.35,105.75 188.19,105.75 187.86,105.42 186.14,105.42 186.02,105.3 186.02,104.21 185.99,104.18 185.32,104.18 185.21,104.29 185.21,105.96 185.72,105.96 185.72,106.41 185.21,106.41 185.21,106.76 185.72,106.76 185.72,107.21 185.21,107.21 185.21,108.14 185.62,108.54 189.67,108.54 189.68,108.54 189.77,108.54 189.85,108.62 191.15,108.62
+13.5VB_1.05VALWP on BOTTOM (solid shape): 189.5,107.03 189.5,106.01 189.33,105.85 188.66,105.85 188.17,105.36 187.11,105.36 187.08,105.39 187.08,106.83 187.46,107.22 189.31,107.22
+13.5VB_3V on TOP (solid shape): 189.68,101.61 191.02,101.61 191.26,101.37 191.26,98.6 191.14,98.48 189.74,98.48 189.62,98.61 189.62,99.05 188.91,99.77 188.91,100.31 188.79,100.43 188.26,100.43 188.12,100.29 188.12,99.87 188.07,99.82 186.23,99.82 186.12,99.93 186.12,102.09 186.34,102.32 188.97,102.32
+13.5VB_3V on BOTTOM (solid shape): 195.23,101.76 195.23,100.62 195.12,100.51 193.31,100.51 192.23,99.43 188.73,99.43 188.35,99.82 186.32,99.82 186.06,100.07 186.06,100.81 186.72,101.47 189.36,101.47 189.43,101.4 189.43,100.9 190.89,100.9 190.89,101.47 191.93,101.47 192.35,101.89 195.1,101.89
+13.5VB_5V on TOP (solid shape): 45.51,27.03 45.51,26.17 45.87,25.81 46.6,25.81 46.96,25.45 48.7,25.45 49.12,25.03 49.12,22.71 47.93,21.51 47.01,21.51 46.87,21.65 46.87,23.12 46.67,23.31 45.99,23.31 45.56,23.75 43.99,23.75 43.79,23.95 43.79,26.15 43.86,26.23 43.86,27.05 43.91,27.11 45.43,27.11
+13.5VB_5V on BOTTOM (solid shape): outline of 259 points within 43.4,21.56 52.75,32.62
+13.5VB_5V on IN4: 45.07,32.58 45.86,32.58 45.96,32.48 45.96,32.05 50.88,27.13 50.88,26.5 49.98,25.61 49.98,23.72 49,22.74 46.53,22.74 44.38,24.89 44.38,31.9
+13.5VB_CPU on TOP (solid shape): outline of 139 points within 69.95,79.15 79.25,90.23
+13.5VB_CPU on BOTTOM (solid shape): outline of 109 points within 62.93,79.18 79.12,90.23
+13.5VB_CPU on IN1 (solid shape): 77.48,84.37 77.48,82.98 77.35,82.85 76.6,82.85 75.96,83.49 75.2,83.49 75.06,83.63 75.06,84.4 75.18,84.51 75.81,84.51 76.32,85.02 76.83,85.02
+13.5VB_CPU on IN1 (solid shape): 77.36,89.32 77.36,88.48 77.16,88.28 76.42,88.28 74.98,86.84 73.71,86.84 72.48,85.61 70.37,85.61 69.97,86.02 69.97,86.82 72.32,86.82 72.32,86.77 72.33,86.72 72.35,86.67 72.37,86.63 72.4,86.58 72.44,86.55 72.48,86.52 72.53,86.49 72.58,86.48 72.63,86.47 72.68,86.47 72.73,86.48 72.78,86.49 72.83,86.52 72.87,86.55 72.91,86.58 72.94,86.63 72.96,86.67 72.98,86.72 72.99,86.77 72.99,86.82 72.98,86.88 72.96,86.93 72.94,86.97 72.91,87.01 72.87,87.05 72.83,87.08 72.78,87.1 72.73,87.12 72.68,87.13 72.63,87.13 72.58,87.12 72.53,87.1 72.48,87.08 72.44,87.05 72.4,87.01 72.37,86.97 72.35,86.93 72.33,86.88 72.32,86.82 69.97,86.82 69.97,88.05 71.35,89.44 73.19,89.44 73.19,89.44 77.24,89.44
+13.5VB_CPU on IN2 (solid shape): 79.25,80.79 79.25,79.23 79.07,79.05 78.04,79.05 77.83,79.25 77.83,80.82 77.95,80.95 79.09,80.95
+13.5VB_CPU on IN2 (solid shape): 77.29,83.91 77.31,83.91 77.42,83.8 78.44,83.8 78.58,83.66 78.58,83.33 78.45,83.21 77.78,83.21 77.36,82.8 76.59,82.8 76.06,83.33 75.63,83.33 75.48,83.48 75.23,83.48 75.14,83.57 75.14,83.81 75.62,84.3 76.91,84.3
+13.5VB_CPU on IN2 (solid shape): 77.35,89.34 77.35,88.26 73.46,84.37 71.09,84.37 70.81,84.66 70.81,86.82 72.32,86.82 72.32,86.77 72.33,86.72 72.35,86.67 72.37,86.63 72.4,86.58 72.44,86.55 72.48,86.52 72.53,86.49 72.58,86.48 72.63,86.47 72.68,86.47 72.73,86.48 72.78,86.49 72.83,86.52 72.87,86.55 72.91,86.58 72.94,86.63 72.96,86.67 72.98,86.72 72.99,86.77 72.99,86.82 72.98,86.88 72.96,86.93 72.94,86.97 72.91,87.01 72.87,87.05 72.83,87.08 72.78,87.1 72.73,87.12 72.68,87.13 72.63,87.13 72.58,87.12 72.53,87.1 72.48,87.08 72.44,87.05 72.4,87.01 72.37,86.97 72.35,86.93 72.33,86.88 72.32,86.82 70.81,86.82 70.81,88.58 71.76,89.53 77.16,89.53
+13.5VB_CPU on IN3 (solid shape): 77.37,89.4 77.37,88.37 77.22,88.21 75.62,88.21 75.47,88.37 75.47,89.42 75.59,89.54 77.23,89.54
+13.5VB_CPU on IN3 (solid shape): 79.24,80.85 79.24,79.1 79.14,79 78,79 77.81,79.19 77.81,80.84 77.97,81 79.09,81
+13.5VB_CPU on IN3 (solid shape): 77.29,83.91 78.43,83.91 78.58,83.76 78.58,83.44 78.46,83.33 77.84,83.33 77.35,82.84 76.6,82.84 76.11,83.33 75.63,83.33 75.48,83.48 75.23,83.48 75.14,83.57 75.14,83.81 75.62,84.3 76.91,84.3
+13.5VB_CPU on IN3 (solid shape): 74.49,88.58 74.49,83.46 74.22,83.19 71.3,83.19 70.94,83.55 70.94,86.82 72.32,86.82 72.32,86.77 72.33,86.72 72.35,86.67 72.37,86.63 72.4,86.58 72.44,86.55 72.48,86.52 72.53,86.49 72.58,86.48 72.63,86.47 72.68,86.47 72.73,86.48 72.78,86.49 72.83,86.52 72.87,86.55 72.91,86.58 72.94,86.63 72.96,86.67 72.98,86.72 72.99,86.77 72.99,86.82 72.98,86.88 72.96,86.93 72.94,86.97 72.91,87.01 72.87,87.05 72.83,87.08 72.78,87.1 72.73,87.12 72.68,87.13 72.63,87.13 72.58,87.12 72.53,87.1 72.48,87.08 72.44,87.05 72.4,87.01 72.37,86.97 72.35,86.93 72.33,86.88 72.32,86.82 70.94,86.82 70.94,88.58 71.19,88.83 74.24,88.83
+13.5VB_DDR on TOP (solid shape): 221.67,28.77 221.67,26.27 221.2,25.79 219.94,25.79 219.63,26.09 218.38,26.09 218.11,26.36 218.11,26.84 217.96,26.99 217.53,26.99 217.43,27.1 217.43,27.53 217.6,27.7 219.53,27.7 219.72,27.51 219.91,27.51 220.37,27.05 221.05,27.05 221.18,27.17 221.18,28.76 221.24,28.82 221.62,28.82
+13.5VB_DDR on BOTTOM (solid shape): outline of 122 points within 214.76,26.08 219.64,32.95
+13.5VB_IR on TOP (solid shape): outline of 85 points within 100.36,107.5 106.37,111.4
+13.5VB_IR on BOTTOM (solid shape): 102.18,112.33 102.18,110.8 101.99,110.61 100.65,110.61 100.4,110.86 100.4,111.18 100.84,111.63 100.84,112.45 100.97,112.58 101.92,112.58
+13.5VB_VCCGT on TOP (solid shape): outline of 201 points within 69.79,69.74 76.59,80.38
+13.5VB_VCCGT on BOTTOM (solid shape): 73.56,74.97 73.56,74.59 73.68,74.47 74.39,74.47 74.98,73.88 75.89,73.88 75.95,73.82 75.95,72.98 75.66,72.68 75.66,69.94 75.65,69.93 74.51,69.93 74.5,71.44 74.49,71.46 73.48,71.46 73.37,71.57 73.37,72.09 72.46,73 72.46,74.97 72.57,75.09 73.44,75.09
+13.5VB_VCCGT on IN1 (solid shape): 75.66,74.06 75.66,70.05 75.51,69.89 74.43,69.89 72.51,71.81 72.51,74.95 72.73,75.17 74.56,75.17
+13.5VB_VCCGT on IN2 (solid shape): 75.69,71.59 75.69,69.98 75.54,69.84 74.66,69.84 74.51,69.98 74.51,71.62 74.66,71.77 75.51,71.77
+13.5VB_VCCGT on IN2 (solid shape): 74.1,74.62 74.37,74.62 75.23,73.76 75.23,73.4 74.25,72.42 72.78,72.42 72.5,72.7 72.5,74.98 72.73,75.22 73.51,75.22
+13.5VB_VCCGT on IN3: 74.73,82.77 70.86,82.77 70.4,82.31 70.4,70.41 70.91,69.9 75.48,69.9 75.65,70.08 75.65,77.99 74.94,78.7 74.94,82.55
+13.5VB_VCCSA on TOP (solid shape): 100.4,97.53 100.4,96.32 100.27,96.2 99.45,96.2 99.23,96.41 98.26,96.41 98.22,96.45 98.22,97.29 98.65,97.72 100.21,97.72
+13.5VB_VCCSA on BOTTOM (solid shape): 98.49,99.88 98.49,98.93 98.75,98.67 98.96,98.67 99.23,98.4 99.91,98.4 100.34,97.97 100.34,96.3 100.29,96.26 99.26,96.26 99.09,96.43 96.29,96.43 96.28,96.44 96.28,96.99 96.29,97 96.75,97 96.97,97.22 96.97,97.59 97.34,97.96 97.34,99.14 97.34,99.14 97.88,99.14 97.89,99.15 97.89,99.63 97.34,99.63 97.34,99.63 97.34,100.03 97.44,100.13 98.24,100.13
+13.5VB_VCHGR on BOTTOM (solid shape): 229.82,41.24 230.59,41.24 230.7,41.13 230.7,37.33 230.38,37.01 228.8,37.01 228.35,37.46 228.35,39.17 228.09,39.43 228.08,39.44 227.87,39.65 227.87,40.28 228.4,40.28 228.73,40.61 228.4,40.94 227.87,40.94 227.87,41.51 227.89,41.53 229.53,41.53
+19.5V_AC on BOTTOM (solid shape): 57.85,84.77 57.85,80 56.86,79 55.72,79 55.72,78.5 55.27,78.5 55.27,79.04 54.5,79.04 54.5,78.5 54.07,78.5 54.07,79 53.39,79 53.22,79.17 53.22,82.42 53.92,83.12 53.92,83.41 54.46,83.41 54.79,83.74 54.46,84.07 53.92,84.07 53.92,84.83 53.98,84.89 57.73,84.89
+19.5V_CHARGER on TOP (solid shape): 50.93,70.5 50.93,65.28 50.88,65.23 49.86,65.23 49.65,65.44 49.65,67.77 49.47,67.94 49.47,69.03 49.16,69.34 47.79,69.34 47.66,69.47 47.66,70.33 47.76,70.44 49.42,70.44 49.64,70.66 50.77,70.66
+19.5V_CHARGER on BOTTOM (solid shape): 53.94,78.85 53.94,78.32 53.96,78.3 55.88,78.3 55.89,78.31 55.89,78.85 55.89,78.85 56.78,78.85 56.9,78.73 56.9,75.37 56.65,75.11 53.7,75.11 52.17,73.58 52.17,71.7 51.73,71.26 51.37,71.26 50.93,70.82 50.93,64.35 50.84,64.25 49.68,64.25 49.66,64.26 49.66,68.69 49.48,68.87 48.78,68.87 48.52,69.12 47.77,69.12 47.64,69.25 47.64,71.08 47.72,71.17 48.73,71.17 49,71.44 49,74.75 49.06,74.81 49.85,74.81 50.84,75.79 50.84,78.49 51.2,78.85 53.94,78.85
+19.5V_CHARGER on IN1 (solid shape): 50.54,70.57 50.54,66.55 50.41,66.41 49.91,66.41 49.75,66.57 49.75,70.5 49.94,70.68 50.43,70.68
+19.5V_CHARGER on IN2: 48.88,66.2 48.69,66.38 48.69,69.08 48.42,69.36 47.81,69.36 47.65,69.52 47.65,70.83 47.86,71.04 48.45,71.04 49.29,71.88 49.29,75.81 51.22,77.74 53.05,77.74 53.22,77.57 53.22,75.31 52.94,75.03 52.45,75.03 52,74.58 51.85,74.43 51.85,71.53 50.94,70.62 50.94,66.31 50.83,66.2
+19.5V_DC_IN on TOP (solid shape): 59.18,88.78 59.18,88.13 58.93,87.88 58.05,87.88 57.85,87.69 57.85,85.59 57.73,85.46 56.78,85.46 56.71,85.53 56.71,85.78 56.71,85.78 56.52,85.97 56.52,86.57 56.46,86.63 55.66,86.63 55.57,86.73 55.57,87.55 55.63,87.62 56.56,87.62 57.91,88.97 59,88.97
+19.5V_DC_IN on BOTTOM (solid shape): 54.86,96.9 54.86,96.31 55.05,96.12 55.52,96.12 55.72,95.93 56.19,95.93 56.39,95.73 56.39,95.6 56.62,95.37 57.22,95.37 57.5,95.27 57.78,95.37 58.24,95.37 58.43,95.18 58.43,93.5 58.62,93.31 58.62,90.87 58.47,90.72 56.57,90.72 56.5,90.8 56.5,91.23 56.27,91.46 55.08,91.46 54.89,91.65 54.89,92.77 54.51,93.15 53.6,93.15 53.09,93.66 51.31,93.66 51.06,93.91 51.06,96.83 51.38,97.15 54.62,97.15
+19.5V_DC_IN_SS on BOTTOM (solid shape): 54.74,92.76 54.74,90.96 55.52,90.19 55.55,90.15 59.26,90.15 59.32,90.09 59.32,87.98 59.24,87.91 57.84,87.91 57.65,87.71 54.86,87.71 54.85,87.71 54.75,87.71 54.74,87.75 54.2,87.96 54.32,87.39 54.4,87.32 54.37,87.22 54.36,87.22 54.36,86.31 54.83,85.84 56.4,85.84 56.58,85.66 56.58,85.24 56.48,85.13 52.86,85.13 52.33,85.66 52.33,92.68 52.5,92.86 54.64,92.86
+19.5V_DCIN_JACK on BOTTOM (solid shape): 46.89,97.28 47.19,97.08 47.49,97.28 48.08,97.28 49.16,96.2 49.16,93.8 48.65,93.29 48.65,92.7 48.52,92.58 47.63,92.58 47.38,92.83 47.38,93.66 46.87,94.16 44.42,94.16 44.2,94.39 44.2,97.09 44.39,97.28
+19.5V_SDC_IN on BOTTOM (solid shape): 51.95,92.01 51.95,89.52 51.89,89.46 51.86,89.47 51.5,89.35 51.49,88.97 51.49,86.19 52.91,84.77 52.91,84.07 52.38,84.07 52.04,83.74 52.38,83.41 52.91,83.41 52.91,82.43 50.53,80.04 50.53,77.05 50.43,76.96 46.81,76.96 46.68,77.08 46.68,79.88 45.98,80.58 45.98,82.97 46.06,83.18 45.98,83.39 45.98,84.32 46.62,84.96 46.62,89.02 46.81,89.21 46.81,89.21 46.97,89.37 47.04,89.42 47.1,89.5 47.41,89.81 48.21,89.81 48.96,90.56 48.96,92.07 49.09,92.2 51.76,92.2
+19.5VB_WC_C on BOTTOM (solid shape): outline of 310 points within 42.11,38.03 47.82,46.67
+19.5VB_WC_SDC on BOTTOM (solid shape): 49.44,46.64 49.44,42.54 49.25,42.35 47.73,42.35 47.6,42.48 47.6,46.48 47.92,46.79 49.29,46.79
+20V_LDO_INPUT on BOTTOM (solid shape): 61.69,95.06 61.88,95.03 62.07,95.06 62.08,95.07 63.08,95.07 63.19,94.96 63.19,94.38 63.8,93.76 63.8,92.96 63.52,92.68 63.14,92.68 61.82,94 60.7,94 60.54,94.16 60.54,94.8 60.8,95.07 61.68,95.07
+20V_TBTA_VBUS on TOP (solid shape): 10.01,84.66 10.01,83.9 9.86,83.76 9.62,83.76 9.07,84.31 7.21,84.31 7.18,84.31 7.18,84.64 8.13,84.64 8.32,84.83 9.84,84.83
+20V_TBTA_VBUS on TOP (solid shape): 9.85,87.52 9.85,86.8 9.67,86.62 8.45,86.62 8.26,86.82 7.12,86.82 7.12,87.15 8.16,87.15 8.17,87.16 8.33,87.16 8.34,87.17 8.35,87.15 9.13,87.15 9.27,87.3 9.27,87.52 9.47,87.71 9.65,87.71
+20V_TBTA_VBUS on BOTTOM (solid shape): 10.29,87.5 10.29,86.67 10.23,86.61 8.26,86.61 8.07,86.8 8.07,87.12 8.2,87.24 8.57,87.24 9.06,87.74 10.05,87.74
+20V_TBTA_VBUS on BOTTOM (solid shape): 10.3,84.73 10.31,84.72 10.43,84.6 10.43,84.6 10.5,84.53 10.5,83.6 10.47,83.57 9.32,83.57 8.65,84.24 8.29,84.24 8.1,84.42 8.1,84.61 8.29,84.79 10.24,84.79
+20V_TBTA_VBUS on BOTTOM (solid shape): 41.98,88.89 41.98,88.7 42.3,88.39 42.87,88.39 43.25,88 43.25,85.97 43.21,85.93 39.9,85.93 39.63,85.66 39.63,84.96 39.57,84.89 38.04,84.89 37.92,85.02 37.92,88.51 38.39,88.99 41.19,88.99 41.28,89.08 41.79,89.08
+20V_TBTA_VBUS on BOTTOM (solid shape): 13.98,93.72 15.37,93.72 15.68,93.41 15.68,91.74 15.5,91.56 10.04,91.56 9.77,91.83 9.77,92.14 10.13,92.73 10.26,93.4 10.26,93.97 11.18,93.97 11.44,93.72 11.94,93.72 12.26,94.04 13.66,94.04
+20V_TBTA_VBUS on IN2: 7.94,82.46 7.44,82.96 7.02,82.96 7,82.98 6.96,83.05 6.98,83.12 7.03,83.32 6.95,83.51 6.93,83.58 6.96,83.65 6.75,84.2 6.5,83.67 6.53,83.59 6.5,83.52 6.4,83.33 6.45,83.12 6.46,83.02 6.37,82.96 5.9,82.96 5.57,83.29 4.39,83.29 3.69,83.99 3.69,90.53 4.97,91.81 5.09,91.81 5.1,91.81 5.73,91.73 6.36,91.81 6.37,91.81 7.33,91.81 7.38,91.76 8.01,91.76 8.06,91.82 8.09,91.81 9.43,92.16 10.01,93.41 10.01,94.1 11.75,94.1 11.76,94.1 12.27,94.1 13.8,92.57 22.88,92.57 22.9,92.55 28,92.55 30.44,94.98 31.41,94.98 31.66,94.74 31.66,91.46 30.63,90.44 17.38,90.44 14.81,87.87 14.74,87.87 13.87,87.79 13.69,86.93 13.62,86.67 13.65,86.41 13.66,86.38 13.02,85.75 13.02,85.54 9.95,82.46
+20V_TBTA_VBUS on IN3: 25.72,87.88 32.07,87.88 34.36,85.59 40.78,85.59 41.31,86.12 42.57,86.12 43,86.54 43,88.52 43.46,88.99 43.46,89.83 43.61,89.97 43.61,91.91 43.36,92.16 42.53,92.16 39.25,95.43 36.02,95.43 34.9,96.56 31.14,96.56 30.01,95.43 12.8,95.43 12.11,94.74 11.25,94.74 10.81,94.3 10.81,92.21 7.83,89.23 7.83,87.8 7.49,87.46 6.53,87.46 6.43,87.36 6.43,87.11 6.54,87 6.98,87 7.2,86.78 7.2,84.82 7.05,84.68 6.58,84.68 6.5,84.6 6.5,84.32 6.59,84.22 7.17,84.22 7.82,83.57 10.98,83.57 11.11,83.7 11.11,84.66 11.23,84.79 12.54,84.79 12.58,84.84 12.58,85.75 13.21,86.38 15.5,86.38 15.56,86.43 15.56,88.86 16.67,89.98 23.62,89.98
+20V_TBTA_VBUS_1 on TOP (solid shape): 45.23,88.31 46.98,88.31 47.12,88.17 47.12,86.98 46.95,86.8 46.63,86.8 46.32,87.1 45.54,87.1 45.4,86.97 45.4,86.67 45.28,86.54 44.87,86.54 44.69,86.37 44.3,86.37 44.24,86.43 42.03,86.43 41.63,86.03 40.96,86.03 40.59,85.65 40.59,85.59 40.01,85.59 39.76,85.85 39.76,86.99 39.95,87.18 40.66,87.18 40.73,87.15 40.76,87.09 40.81,86.95 40.91,86.84 41.13,86.79 41.33,86.89 41.4,86.99 41.42,87.11 41.42,87.13 41.65,87.36 41.67,87.36 41.9,87.46 41.99,87.69 42.98,87.69 43.03,87.74 43.03,87.83 43.18,87.98 43.74,87.98 43.92,88.15 44.59,88.15 44.75,88.31 45.23,88.31
+20V_TBTA_VBUS_1 on BOTTOM (solid shape): 35.4,61.22 35.4,60.86 34.9,60.37 33.21,60.37 33.15,60.43 33.15,60.65 33.24,60.73 34.07,60.73 34.68,61.34 35.27,61.34
+20V_TBTA_VBUS_1 on BOTTOM (solid shape): 21.02,29.78 25.09,29.78 25.36,29.5 25.36,28.84 25.15,28.63 24.64,28.63 23.44,27.43 19.93,27.43 18.56,28.8 18.56,30.62 18.66,30.72 20.08,30.72
+20V_TBTA_VBUS_1 on BOTTOM (solid shape): 29.85,63.95 29.85,61.72 30.36,61.21 30.36,60.89 30.3,60.83 30.11,60.83 29.98,60.7 29.98,60.45 29.85,60.32 29.6,60.32 29.53,60.38 29.53,60.7 29.41,60.83 29.22,60.83 29.09,60.95 29.09,61.14 28.39,61.84 28.39,63.53 28.21,63.71 28.21,64.33 28.31,64.43 29.37,64.43
+20V_TBTA_VBUS_1 on BOTTOM (solid shape): 45.51,88.04 45.51,86.85 45.33,86.67 44.95,86.67 44.6,86.32 44.58,86.32 44.58,86.3 44.52,86.24 44.52,84.77 44.19,84.44 43.43,84.44 43.19,84.19 42.55,84.19 42.32,83.96 42.32,83.22 42.18,83.08 40.23,83.08 40.14,83.18 40.14,83.88 39.82,84.19 39.82,85.53 40.01,85.72 40.99,85.72 41.07,85.69 41.1,85.61 41.43,85.26 41.76,85.61 41.78,85.69 41.86,85.72 43.19,85.72 43.38,85.91 43.38,88.05 43.58,88.25 43.83,88.25 43.83,88.46 45.09,88.46
+20V_TBTA_VBUS_1 on IN3: 44.47,84.16 43.21,84.16 42.94,84.44 42.94,86.2 43.19,86.45 43.19,87.91 43.84,88.57 45.29,88.57 45.55,88.31 45.55,85.25
+20V_TBTA_VBUS_1 on IN3: 34.84,63.46 35.49,62.81 35.49,57.02 31.08,52.62 31.08,46.94 28.68,44.54 28.68,40.4 27.88,39.6 27.88,37.4 26.99,36.51 26.99,30.92 24.64,28.57 19.07,28.57 18.56,29.08 18.56,33.34 21.72,36.51 21.72,47.78 23.09,49.14 23.09,54.32 25.09,56.32 25.15,56.32 25.66,56.83 25.66,58.67 26.99,60 26.99,62.62 27.81,63.44 27.82,63.44 27.82,66.92 29.47,68.57 37.93,68.57 39.25,69.9 39.25,70.48 40.77,72 42.11,72 42.23,71.88 42.23,67.56 39.88,65.21 35.76,65.21 35.44,65.53 32.33,65.53 32.11,65.31 32.11,64.43 33.11,63.44 34.81,63.44
+20V_VBUS_DC_SS on BOTTOM (solid shape): 45.35,83.81 45.35,82.92 45.6,82.67 45.6,80.38 46.23,79.75 46.23,76.19 46.11,76.07 46.11,74.86 45.98,74.73 44.2,74.73 43.69,75.24 43.69,75.24 43.18,75.75 43.18,79.14 42.94,79.38 41.94,79.38 41.25,80.07 40.71,80.07 40.53,80.25 40.53,82.48 40.57,82.53 43.46,82.53 43.69,82.76 43.69,83.69 43.88,83.88 45.28,83.88
+DV33_18 on TOP (solid shape): 295.33,65.48 295.4,65.33 295.55,65.25 295.55,64.74 295.7,64.59 295.94,64.59 296.04,64.48 296.04,64.17 295.98,64.11 295.59,64.11 295.08,64.61 295.08,65.18 294.83,65.43 294.05,65.43 293.99,65.49 293.99,65.58 294.05,65.65 295.16,65.65
+VCC_CORE on TOP (solid shape): 89.54,88.26 89.54,86.73 89.67,86.61 90.24,86.61 90.87,85.97 90.87,84.58 91.07,84.39 92.52,84.39 92.87,84.04 92.87,80.46 92.66,80.24 90.62,80.24 89.51,79.14 85.06,79.14 84.8,79.4 84.8,81.8 84.62,81.97 84.34,81.97 84.24,82.08 84.24,84.86 84.02,85.09 84.02,86.16 84.25,86.38 85.06,86.38 87.06,88.39 89.41,88.39
+VCC_CORE on TOP (solid shape): outline of 4585 points within 117.52,74.24 136.96,110.9
+VCC_CORE on BOTTOM (solid shape): 84.83,87.56 85.65,87.56 85.65,88.48 89.37,88.48 89.52,88.33 89.52,87.07 90.81,85.78 90.81,84.83 91.27,84.37 92.54,84.37 92.89,84.02 92.89,77.38 92.29,76.78 89.84,76.78 89.73,76.89 89.73,78.29 90.64,78.29 90.66,78.31 90.66,79.07 90.63,79.1 86.58,79.1 86.36,79.32 86.36,80.51 84.6,82.28 84.6,84.88 84.43,85.04 83.66,85.04 83.49,85.21 83.49,88.46 83.51,88.48 84.83,88.48
+VCC_CORE on BOTTOM (solid shape): outline of 192 points within 120.79,99.07 134.85,110.83
+VCC_CORE on BOTTOM (solid shape): outline of 1012 points within 120.38,84.47 128.61,86.97
+VCC_CORE on BOTTOM (solid shape): outline of 1134 points within 128.15,74.28 137.27,77.31
+VCC_CORE on BOTTOM (solid shape): outline of 1278 points within 128.16,84.47 137,88.92
+VCC_CORE on IN1 (solid shape): 92.76,82.98 92.76,80.45 92.58,80.27 90.65,80.27 89.53,79.15 86.31,79.15 86.06,79.4 86.06,83.42 86.2,83.56 92.18,83.56
+VCC_CORE on IN1 (solid shape): 89.54,88.23 89.54,86.74 89.67,86.61 90.25,86.61 90.88,85.98 90.88,84.51 90.74,84.37 86.21,84.37 86.08,84.5 86.08,85.31 86.26,85.5 87.09,85.5 87.3,85.7 87.3,86.45 87.78,86.94 87.78,88.19 87.93,88.34 89.43,88.34
+VCC_CORE on IN2: 94.79,71.27 90.05,76 88.46,76 86.11,78.35 86.11,87.44 88.3,89.62 94.84,89.62 97.8,86.67 101.1,86.67 103.32,88.89 103.32,89.59 103.64,89.91 108.53,89.91 109.1,89.34 135.2,89.34 135.58,88.96 135.71,88.96 135.71,88.32 136.91,87.12 136.91,75.37 135.9,74.35 127.96,74.35 126.18,76.13 122.05,76.13 117.19,71.27
+VCC_CORE on IN3: 135.9,74.35 136.91,75.37 136.91,87.12 135.71,88.32 135.71,88.96 137.29,90.54 137.29,91.62 136.53,92.39 105.26,92.39 100.85,87.97 98.04,87.97 95.75,90.27 90.73,90.27 90.28,89.82 88.44,89.82 86.11,87.49 86.11,67.3 86.73,66.68 88.92,66.68 89.86,65.74 89.86,64.85 89.95,64.76 104.65,64.76 114.24,74.35
+VCC_CORE on VCC: 84.2,72.62 82.81,74.01 82.81,93.34 89.39,93.34 90.06,94.01 90.06,95.89 90.31,96.13 108.06,96.13 114.41,102.48 134.52,102.48 135.01,102 135.01,92.98 135.66,92.32 136.68,92.32 136.92,92.09 136.94,92.01 136.94,73.97 126.44,73.97 123.83,76.57 96.26,76.57 92.31,72.62
+VCC_CORE on IN4: 97.61,86.54 101.1,86.54 102.24,87.68 110.88,87.68 112.08,86.48 120.28,86.48 120.78,86.99 129.04,86.99 129.1,86.93 129.55,87.37 129.55,88.51 130.24,89.21 136.09,89.21 136.47,88.83 136.47,86.16 136.91,85.72 136.91,82.48 135.75,81.32 93.93,81.32 92.55,79.94 85.93,79.94 84.92,80.96 84.92,89.35 85.49,89.92 89.77,89.92 90.23,89.47 94.68,89.47
+VCC_GT on TOP (solid shape): outline of 4907 points within 86.64,62.42 120.21,92.93
+VCC_GT on BOTTOM (solid shape): outline of 414 points within 84.73,67.24 108.54,89.39
+VCC_GT on BOTTOM (solid shape): outline of 2257 points within 108.23,79 120.36,90.45
+VCC_GT on IN1 (solid shape): outline of 133 points within 86.63,67.36 92.48,74.77
+VCC_SA on TOP (solid shape): 95.35,88.22 95.35,86.23 95.2,86.07 94.78,86.07 94.57,85.86 94.57,85.47 93.78,84.68 92.56,84.68 92.49,84.75 92.49,86.94 92.21,87.23 92.21,88.23 92.34,88.36 95.22,88.36
+VCC_SA on TOP (solid shape): 140.15,79.69 140.15,77.59 140.52,77.22 140.52,76.94 140.4,76.83 139.72,76.83 139.19,76.29 138.95,76.29 138.78,76.46 138.78,76.86 139.07,77.15 139.07,79.83 139.12,79.88 139.96,79.88
+VCC_SA on TOP (solid shape): outline of 98 points within 136.8,82.29 140.99,87.05
+VCC_SA on BOTTOM (solid shape): 92.63,89.23 93.44,89.23 93.44,90.15 94.8,90.15 95.43,89.52 95.43,86.3 95.21,86.08 94.86,86.08 94.66,85.88 94.66,84.92 94.5,84.77 92.53,84.77 92.47,84.82 92.47,86.72 91.64,87.56 91.64,90.14 91.64,90.15 92.63,90.15
+VCC_SA on BOTTOM (solid shape): outline of 208 points within 138.67,74.63 140.9,77.42
+VCC_SA on BOTTOM (solid shape): outline of 464 points within 136.92,84.49 140.66,87.01
+VCC_SA on IN1: 137.48,86.99 140.91,86.99 141.04,86.86 141.04,76.83 139.96,75.75 117.16,75.75 116.08,76.83 116.08,78.61 115.26,79.43 108.08,79.43 106.94,80.58 99,80.58 96.19,77.77 93.55,77.77 92.87,78.44 92.87,83.13 91.89,84.12 91.89,87.9 93.21,89.22 95.88,89.22 97.67,87.43 101.64,87.43 103.18,88.97 103.18,92.54 103.86,93.22 105.35,93.22 107.32,91.24 114.12,91.24 115,90.35 115,86.93 115.58,86.35 134.05,86.35 134.44,85.97 137.04,85.97 137.36,86.29 137.36,86.86
+VCC_SA on IN3: 137.36,86.54 139.9,86.54 139.96,86.61 139.96,92.01 139.77,92.2 137.48,92.2 137.29,92.01 137.29,86.61
