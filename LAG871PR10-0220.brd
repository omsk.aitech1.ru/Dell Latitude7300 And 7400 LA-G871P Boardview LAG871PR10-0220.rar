# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_IO2_R: length 30.5
  TOP w0.127: RC368.1 v1(162.84,60.94)
  IN2 w0.089: 147.76,66.66 147.76,67.68 147.53,67.91 147.53,68.7 146.19,70.04 146.19,70.35 145.39,71.14 145.39,74.12 v1(145.76,74.49)
  IN2 w0.122: 147.76,66.66 147.76,61.94 148.01,61.69 153.02,61.69 153.3,61.97 159.42,61.97 159.8,61.58 162.2,61.58 v1(162.84,60.94)
  BOTTOM w0.089: UC1.BY27 145.3,74.78 v1(145.76,74.49)
ESPI_IO3: length 235.2
  TOP w0.127: v1(162.28,58.86) 162.28,59.17 RC369.2 ; UE1.L5 280.99,80.59 281.08,80.59 v1(281.09,80.57) ; v2(291.89,72.73) 291.47,72.73 v1(291.29,72.91)
  IN1 w0.084: v1(281.09,80.57) 281.31,80.57 281.71,80.18 283.55,80.18 284.92,78.82 288.95,78.82 289.79,79.65 v1(291.69,79.65) ; v1(281.19,63.3) 283.03,63.3 283.28,63.05 283.28,61.87 283.96,61.2 285.37,61.2 285.62,60.94 286.83,60.94 288.86,62.98 288.86,66.15 291.35,68.64 291.92,68.64 292.75,69.47 292.75,72.02 291.86,72.91 v1(291.29,72.91)
  IN2 w0.122: v1(291.69,79.65) 291.15,79.11 291.15,78.07 292.06,77.16 292.06,74.43 291.29,73.66 v1(291.29,72.91) ; v1(162.28,58.86) 162.68,58.46 163.35,58.46 163.75,58.07 165.88,58.07 165.95,58.13 167.41,58.13 167.57,58.29 167.8,58.29 170.27,60.77 172.82,60.77 175.03,58.55 175.03,57.87 176.49,56.41 179.24,56.41 179.68,56.85 182.55,56.85 183.14,56.25 188.05,56.25 190.12,58.33 190.12,59.12 190.86,59.86 193.12,59.86 196.09,56.9 196.09,47.02 197.99,45.12 197.99,44.31 202.58,39.72 203.73,39.72 204.24,39.2 206.76,39.2 208.6,37.36 212.87,37.36 217.69,32.54 224.11,32.54 224.59,32.06 230.54,32.06 231.23,31.37 232.82,31.37 233.44,32 239.48,32 241.51,29.97 245.81,29.97 246.01,30.16 247.75,30.16 247.87,30.29 247.87,30.74 247.99,30.87 248.24,30.87 248.36,30.74 248.36,30.29 248.48,30.16 248.72,30.16 248.85,30.29 248.85,30.74 248.97,30.87 249.21,30.87 249.33,30.74 249.33,30.29 249.46,30.16 250.7,30.16 251.44,30.91 253.73,30.91 254.52,30.12 254.85,30.12 254.98,30.24 254.98,31.05 255.1,31.17 255.34,31.17 255.46,31.05 255.46,30.24 255.59,30.12 255.83,30.12 255.95,30.24 255.95,31.05 256.07,31.17 256.32,31.17 256.44,31.05 256.44,30.24 256.56,30.12 257.57,30.12 257.69,30.24 257.69,31.05 257.82,31.17 258.06,31.17 258.18,31.05 258.18,30.24 258.3,30.12 259.17,30.12 259.64,30.58 260.55,30.58 262.01,32.04 264.34,32.04 265.45,33.16 269.31,33.16 270.45,34.3 270.45,35.13 271.71,36.39 271.71,36.97 271.33,37.35 271.33,39.96 271.72,40.35 271.72,40.74 272.94,41.96 272.94,48.77 275.85,51.67 275.85,52.69 275.97,52.81 278.24,52.81 279.59,54.16 282.3,54.16 282.75,54.61 282.75,54.81 282.74,54.81 282.74,56.21 282.62,56.33 281.81,56.33 281.69,56.45 281.69,56.69 281.81,56.81 282.62,56.81 282.74,56.94 282.74,57.18 282.62,57.3 281.81,57.3 281.69,57.42 281.69,57.67 281.81,57.79 282.62,57.79 282.74,57.91 282.74,58.23 282.39,58.59 282.39,60.68 281.54,61.52 281.54,62.95 v1(281.19,63.3)
  BOTTOM w0.127: v1(291.69,79.65) 291.41,79.93 291.41,80.51 292.03,81.13 JESPI.6
ESPI_IO3_R: length 30.7
  TOP w0.127: v2(161.77,61.53) 162.02,61.27 v1(162.02,60.94) RC369.1
  IN2 w0.089: v1(144.8,74.41) 145.21,74 145.21,71.07 146.01,70.27 146.01,69.97 147.28,68.7 147.28,67.9 147.51,67.68 147.51,66.66
  IN2 w0.122: 147.51,66.66 147.51,61.84 147.91,61.44 153.13,61.44 153.4,61.72 159.31,61.72 159.7,61.33 161.62,61.33 v1(162.02,60.94)
  BOTTOM w0.089: UC1.BV27 144.33,74.72 v1(144.8,74.41)
ESPI_RESET#: length 255.4
  TOP w0.127: v1(280.22,81.44) 280.13,81.44 UE1.K6 ; RC833.1 177.62,59.83 v2(177.45,59.66) v1(177.45,58.84)
  IN1 w0.084: v1(294.06,72.78) 293.59,72.32 293.59,68.56 290.83,65.79 289.79,65.79 289.7,65.71 289.7,61.67 288.14,60.1 285.27,60.1 285.02,60.36 282.66,60.36 281.15,61.86 279.31,61.86 277.44,63.72 274.52,63.72 274,63.21 274,62.77 272.74,61.5 v1(272.43,61.5) ; v1(294.19,85.07) 293.5,84.37 291.98,84.37 291,83.39 291,82.68 290.46,82.14 289.45,82.14 287.56,80.25 284.38,80.25 283.82,80.81 282.23,80.81 282.15,80.9 282.15,81.55 281.89,81.81 280.58,81.81 v1(280.22,81.44)
  IN2 w0.089: 149.31,66.66 149.31,67.93 147.21,70.03 147.21,73.95 v1(146.67,74.49)
  IN2 w0.122: v1(294.19,85.07) 294.19,84.57 293.76,84.13 293.76,83.37 294.58,82.54 294.58,82.16 295.48,81.26 295.48,77.56 295.37,77.44 295.37,73.93 294.22,72.78 v1(294.06,72.78) ; v1(272.43,61.5) 272.28,61.35 272.09,61.35 271.03,60.29 271.03,57.13 271.61,56.55 271.61,54.96 269.89,53.25 269.89,53.08 269.65,52.84 269.65,51.73 268.7,50.78 268.7,47.71 269.63,46.78 269.63,45.65 269.26,45.27 269.26,43.25 263.84,37.83 261.16,37.83 260.52,37.19 256.52,37.19 255.89,36.56 253.9,36.56 253.71,36.37 252.96,36.37 252.95,36.38 247.43,36.38 243.78,32.73 241.93,32.73 239.76,34.9 218.51,34.9 217.14,36.27 211.93,41.49 208.06,41.49 206.15,43.39 203.79,43.39 200.93,46.25 200.93,55.55 196.68,59.81 196.68,60.8 194.96,62.52 192.29,62.52 191.89,62.11 189.5,62.11 187.03,59.64 187.03,59.12 186.68,58.78 183.94,58.78 183.48,59.24 180.6,59.24 180.31,59.53 179.18,59.53 178.38,58.73 177.56,58.73 v1(177.45,58.84) 177.28,59.01 177.28,60.42 176.34,61.36 175.41,61.36 173.89,62.87 173.75,63.02 169.24,63.02 167.79,61.57 166.61,61.57 164.94,63.23 160.46,63.23 160.09,63.6 151.96,63.6 151.5,64.06 149.85,64.06 149.31,64.6 149.31,66.66
  BOTTOM w0.089: v1(146.67,74.49) 146.29,74.73 UC1.CA27
  BOTTOM w0.127: v1(294.19,85.07) 295.4,85.07 296.68,83.79 296.68,82.35 296.46,82.13 JESPI.8
FB_1.05VALWP: length 5.3
  TOP w0.127: PR308.2 196.74,108.71 v2(197.11,108.34)
  TOP w0.254: PR306.2 195.27,108.72 194.84,108.72 194.61,108.5 193.88,108.5 PU301.14 ; PR306.2 196.09,108.72 PR308.2 ; PR306.2 195.28,107.83 195.39,107.72 PR311.1
FB_1.8VALW: length 5.2
  BOTTOM w0.127: v2(178.89,101.95) 178.89,102.33 179.73,103.18 PC503.2
  BOTTOM w0.254: PU501.6 181.4,104.16 181.76,103.8 PR506.1 180.98,103.16 PR501.2 180.16,103.15 PC503.2
FB_3V: length 1.3
  TOP w0.254: PC113.1 190.67,95.09 190.68,95.1 PU100.13
FB_5V: length 1.9
  TOP w0.254: PU102.13 44.44,30.69 44.05,31.08 PC127.1
FB_A_GT: length 6.6
  TOP w0.203: PU602.17 69.58,59.61 69.68,59.71 70.61,59.71 v2(71.3,60.4) 71.67,60.76 PR645.2
  TOP w0.254: PR645.2 73.23,60.76 PR650.1 PR648.2
FB_B_IA: length 4.7
  TOP w0.203: PU602.5 66.12,55.75 66.05,55.69 v2(66.05,55.37) PR623.2 66.05,53.11 66.03,53.08 PR621.2 66.04,52.69 PR622.2
FB_C_SA: length 6.2
  TOP w0.203: PR652.1 67.54,65.63 PR646.1 66.64,65.65 PR649.1 v2(66.55,64.48) 66.55,63.17 66.52,63.14 PU602.25
FB_DDR: length 7.3
  TOP w0.127: PR204.2 216.57,29.32 215.5,29.32 v2(215,28.82)
  TOP w0.254: PR204.2 PC208.2 217.7,27.93 PR206.1 219.35,28.11 219.58,28.34 219.94,28.34 220.25,28.65 PU200.16
FBS_1V_PRIM_CORE: length 4.6
  TOP w0.127: PR424.1 185.92,30.08 v2(185.76,30.25)
  TOP w0.254: PU402.5 184.41,29.39 184.6,29.59 184.96,29.59 185.29,29.25 PR423.1 PR424.1
FBS_1VS_VCCIO: length 2.4
  TOP w0.254: PR421.2 82.65,24.63 PR422.1 83.49,24.88 84.11,25.5 PU401.5
FCCM1_IA: length 1.3
  BOTTOM w0.254: PU610.2 78.64,87.03 79.04,86.64 PR659.2
FCCM2_IA: length 1.7
  BOTTOM w0.254: PU613.2 76.99,77.87 76.34,77.22 76.31,77.22 PR671.2
FCCM_A_GT: length 6.7
  TOP w0.203: PU602.21 68.12,61.84 68.87,62.59 v2(69.68,62.59) 69.72,62.59 v1(70.24,63.11)
  BOTTOM w0.203: PR662.1 71.84,64.71 v1(70.24,63.11)
FCCM_B_IA: length 41.6
  TOP w0.203: PU602.11 69.14,57.21 69.35,57.01 69.35,56.57 v1(69.54,56.38)
  IN2 w0.254: v1(69.54,56.38) 70.05,56.38 70.68,57.02 72.33,57.02 74.31,59 74.31,68.46 74.12,68.65 74.12,71.76 75.67,73.3 75.67,74.55 76.29,75.18 76.29,75.61 v1(75.43,76.47) 75.43,78.62 74.81,79.24 74.81,83.88 77.22,86.29 79.19,86.29 79.44,86.04 v1(79.44,85.72)
  BOTTOM w0.254: v1(75.43,76.47) 75.43,76.33 75.75,76.02 PR671.1 ; v1(79.44,85.72) 79.44,85.76 79.95,86.26 PR659.1
FCCM_C_SA: length 62.6
  TOP w0.203: v1(63.44,63.54) 63.75,63.54 v2(64.06,63.23) 64.92,62.38 PU602.29
  TOP w0.254: v1(92.3,91.28) 92.3,91.74 PR679.2
  IN3 w0.254: v1(92.3,91.28) 92.3,91.85 91.57,92.58 90.4,92.58 89.45,93.53 85.26,93.53 83.01,95.78 71.92,95.78 68.61,92.47 68.61,71.39 68.04,70.82 68.04,67.2 66.4,65.56 65.14,65.56 63.44,63.87 v1(63.44,63.54)
FCCM_GT: length 4
  BOTTOM w0.127: PR662.2 71.26,67.05 v2(70.81,66.59)
  BOTTOM w0.203: PR662.2 71.84,67.24 72.12,67.52 72.46,67.52 73.55,68.61 PU612.2
FCCM_SA: length 1.3
  TOP w0.254: PU614.7 92.47,93.32 92.47,93.31 PR679.1
FIVR_EN: length 3.6
  TOP w0.127: v2(62.34,93.1) 61.98,92.74 RC236.1 60.71,93.1 RC235.1 59.54,93.1 RC217.1
FIVR_EN_R: length 4.3
  TOP w0.127: v1(60.68,95.78) 61.13,95.33 v2(61.13,95.1) 60.85,94.82 RC132.1 59.7,94.82 59.49,94.62 RC126.2 RC217.2
  BOTTOM w0.127: JXDP1.45 v1(60.68,95.78)
FPR_DET#: length 69.3
  TOP w0.127: UE1.D9 275.02,84.24 v1(274.66,84.6) ; v1(280.04,99.36) 279.2,99.36 277.52,97.68 v2(277.52,96.56) 277.52,94.2 RE606.1
  IN1 w0.084: v1(309.21,101.41) 309.85,100.78 309.85,100.18 309.21,99.54 309.21,98.69 310.18,97.72 v1(310.18,97.31)
  IN3 w0.122: v1(274.66,84.6) 274.67,84.6 275.06,84.99 275.06,85.56 275.09,85.59 275.09,87.18 274.66,87.61 274.66,90.24 275.09,90.67 275.09,95.24 279.2,99.36 v1(280.04,99.36)
  IN4 w0.084: v1(280.04,99.36) 281.07,100.39 287.57,100.39 288.02,99.94 291.93,99.94 292.55,100.57 297.46,100.57 298.55,99.47 299.7,99.47 301.89,97.28 302.57,97.28 303.26,96.6 305.4,96.6 306.58,95.41 307.36,95.41 308.37,94.39 310.1,94.39 310.68,94.97 v1(310.69,94.97)
  BOTTOM w0.127: v1(310.69,94.97) DZ14.9 DZ14.1 310.69,96.8 v1(310.18,97.31) ; v1(309.21,101.41) 308.59,100.8 JFPBTN1.1
FPR_LOW_PWR_MODE#: length 63.7
  TOP w0.102: v1(280.77,89.2) 280.77,87.99 280.3,87.51 280.3,87.03 UE1.K12
  TOP w0.127: RE708.1 290.11,95.79 289.69,96.21 289.69,97.29 290.47,98.07 v2(290.47,99.54) 290.47,100.26 v1(290.59,100.39)
  IN1 w0.084: v1(310.57,103.76) 311.06,103.28 311.06,100.98 311.31,100.73 v1(311.31,98.41)
  IN3 w0.122: v1(280.77,89.2) 280.77,91.16 281.76,92.15 281.76,92.66 283.19,94.08 283.19,96.67 285.06,98.54 285.06,99.69 285.76,100.39 v1(290.59,100.39)
  IN4 w0.084: v1(290.59,100.39) 291.56,100.39 292.59,101.42 297.16,101.42 298.74,99.84 299.85,99.84 302.02,97.67 302.71,97.67 303.41,96.97 306.95,96.97 308.09,95.83 311.41,95.83 v1(312.19,95.05)
  BOTTOM w0.127: v1(311.31,98.41) 311.89,97.82 311.89,97.5 312.19,97.21 DZ14.4 DZ14.7 v1(312.19,95.05) ; JFPBTN1.11 308.45,103.3 308.9,102.85 309.66,102.85 v1(310.57,103.76)
FPR_PWR_EN#: length 47.6
  TOP w0.127: v1(282.7,86.15) 281.81,86.15 UE1.M11 ; RE704.1 289.04,95.79 289.46,96.21 v2(289.46,97.9) 289.46,98.85 v1(289.84,99.23)
  IN3 w0.122: v1(282.7,86.15) 283.09,86.53 283.43,86.53 283.51,86.44 283.54,86.44 283.55,86.43 283.88,86.43 283.88,86.44 283.93,86.44 284.86,87.37 284.86,90.89 285.06,91.09 285.06,93.15 287.47,95.56 287.47,97.15 288.99,98.67 289.28,98.67 v1(289.84,99.23)
  IN4 w0.084: v1(289.84,99.23) 290.09,99.48 296.44,99.48 297.35,98.56 297.35,97.56 301.06,93.85 309.45,93.85 310.45,92.85 v1(310.45,92.52)
  BOTTOM w0.127: RZ380.2 311.02,93.34 310.86,93.19 310.86,92.94 v1(310.45,92.52)
FPR_PWR_EN#_R: length 3.8
  BOTTOM w0.127: CZ200.1 310.28,94.36 ; 310.28,94.36 310.58,94.06 310.98,94.06 RZ380.1 311.14,94.02 311.4,93.77 311.4,92.94 v2(311.02,92.56) ; 310.28,94.36 310.25,94.39 309.64,94.39 309.41,94.63 QZ18.2
FPR_RST#: length 123.2
  TOP w0.127: v2(257.41,32.82) v1(257.41,32.13) 257.41,31.54 RZ1411.1
  IN1 w0.084: v1(312.69,94.76) 312.69,95.17 312.17,95.69 308.81,95.69 306.86,93.74 298.99,93.74 298.56,93.3 298.56,91.98 295.86,89.28 295.86,84.94 295.33,84.42 295.33,83.4 295.86,82.87 295.86,77.02 295.98,76.89 295.98,74.41 296.42,73.97 296.42,71.53 296.21,71.32 296.21,69.75 295.3,68.84 295.3,67.87 295.88,67.3 295.88,62.5 295.2,61.83 295.2,58.01 296.11,57.1 296.11,53.43 294.62,51.95 282.03,51.95 281.97,51.88 281.96,51.88 280.1,50.03 280.1,48.3 279.12,47.31 278.46,47.31 277.56,46.41 277.56,45.96 276.03,44.42 276.03,39.65 269.52,33.15 265.24,33.15 264.72,32.62 261.3,32.62 260.54,31.86 259.51,31.86 259.33,31.68 257.86,31.68 v1(257.41,32.13) ; v1(311.94,103.08) 312.08,102.94 312.08,98.58 v1(311.92,98.42)
  BOTTOM w0.127: JFPBTN1.12 312.16,103.3 v1(311.94,103.08) ; v1(312.69,94.76) DZ14.6 DZ14.5 312.69,97.28 312.27,97.7 RZ1392.2 312.27,97.81 311.92,98.16 v1(311.92,98.42)
FPR_RST#_USH: length 20.3
  TOP w0.127: RZ1411.2 258.67,31.1 v1(259.25,31.1) ; v2(274.24,32.61) 274.24,32.25 v1(273.47,31.48)
  IN4 w0.084: v1(259.25,31.1) 259.25,30.76 260.08,29.93 264.24,29.93 264.73,30.42 265.8,30.42 266.29,29.93 273.14,29.93 273.88,30.67 273.88,31.07 v1(273.47,31.48)
  BOTTOM w0.127: v1(273.47,31.48) 273.43,31.52 JUSH1.25
FPR_SCAN_INT#: length 123.9
  TOP w0.127: v1(281.05,83.76) 280.65,83.36 UE1.L8 ; v2(273.32,34.03) v1(272.48,34.03) 272.48,32.5 272.21,32.23 RZ114.1 ; RE709.1 289.25,84.69 v1(289.25,84.77) 289.25,85.16 289.69,85.6 290.51,85.6 291.89,84.22 295.38,84.22 v1(295.71,83.89)
  IN1 w0.084: v1(289.25,84.77) 289.25,84.55 288.66,83.95 286.65,83.95 286.55,83.85 286.18,83.85 285.93,83.6 284.31,83.6 284.1,83.39 282.67,83.39 282.49,83.57 281.24,83.57 v1(281.05,83.76) ; v1(308.86,95.17) 308.86,94.66 307.75,93.55 299.07,93.55 298.74,93.23 298.74,91.9 296.04,89.2 296.04,84.42 295.71,84.09 v1(295.71,83.89) 295.71,83.54 296.04,83.21 296.04,77.09 296.17,76.97 296.17,74.52 296.61,74.08 296.61,71.45 296.4,71.24 296.4,69.68 295.49,68.77 295.49,67.95 296.06,67.38 296.06,62.42 295.39,61.75 295.39,58.09 296.3,57.18 296.3,53.36 294.7,51.76 282.11,51.76 282.04,51.7 282.03,51.7 280.29,49.95 280.29,48.19 279.23,47.13 278.54,47.13 277.75,46.34 277.75,45.88 276.22,44.35 276.22,39.58 272.93,36.29 272.93,34.48 v1(272.48,34.03) ; v1(309.97,98.94) 310.22,99.18 310.22,103.03 v1(309.51,103.74)
  BOTTOM w0.127: JFPBTN1.15 308.95,104.3 v1(309.51,103.74) ; v1(308.86,95.17) 308.86,95.24 309.09,95.48 DZ15.7 DZ15.4 309.09,97.15 309.56,97.62 309.56,98.52 v1(309.97,98.94)
FPR_SCAN_INT#_R: length 10.8
  TOP w0.127: RZ114.2 271.7,33.41 v1(271.93,33.64)
  IN3 w0.122: v1(263.88,31.57) 264.31,31.57 265.31,32.57 269.56,32.57 270.64,33.64 v1(271.93,33.64)
  BOTTOM w0.127: v1(263.88,31.57) 263.93,31.62 JUSH1.6
FPR_SSO_EN#: length 69.1
  TOP w0.127: v1(290.98,87.32) 291.55,87.89 v2(291.55,89.52) 291.55,90.65 291.34,90.85 291.34,91.48 291.47,91.61 291.48,91.61 RE706.1 ; v1(278.62,84.56) UE1.H9
  IN1 w0.084: v1(310.56,104.53) 310.17,104.13 310.17,103.47 310.41,103.23 v1(310.41,98.5) ; v1(290.98,87.32) 290.65,86.99 290.65,85.91 290.28,85.54 286.1,85.54 285.76,85.21 285.76,84.9 285.02,84.16 284.17,84.16 283.49,84.83 282.58,84.83 281.7,85.71 280.86,85.71 280.68,85.53 280.68,85.3 280.35,84.97 279.03,84.97 v1(278.62,84.56)
  IN3 w0.122: v1(293.63,100.97) 292.55,99.89 292.55,95.37 293.03,94.89 293.03,89.53 291.66,88.15 291.66,87.45 291.54,87.32 290.98,87.32 v1(290.98,87.32)
  IN4 w0.084: v1(293.63,100.97) 297.31,100.97 298.63,99.66 299.78,99.66 301.97,97.47 302.65,97.47 303.33,96.78 306.88,96.78 308.04,95.61 309.52,95.61 309.99,95.14 v1(309.99,95.13)
  BOTTOM w0.127: v1(309.99,95.13) 309.59,95.53 DZ15.6 DZ15.5 309.59,97.17 309.78,97.36 309.78,97.87 v1(310.41,98.5) ; JFPBTN1.16 312.82,104.3 312.27,104.85 310.88,104.85 v1(310.56,104.53)
FPR_UEFI_MGMT#: length 61.8
  TOP w0.127: RE707.1 291.96,91 291.96,87.54 291.18,86.77 v1(291.02,86.77) ; v1(280.22,84.56) UE1.K9
  IN1 w0.084: v1(307.59,98.98) 308.16,99.55 308.16,102.41 v1(309.04,103.28) ; v1(280.22,84.56) 280.62,84.95 281.97,84.95 282.28,84.64 283.41,84.64 284.09,83.97 285.15,83.97 285.95,84.77 285.95,85.13 286.17,85.35 290.4,85.35 291.02,85.96 v1(291.02,86.77)
  IN3 w0.122: v1(293.71,100.11) 292.8,99.21 292.8,95.43 293.26,94.98 293.26,89.43 291.92,88.09 291.92,87.18 291.5,86.77 v1(291.02,86.77)
  IN4 w0.084: v1(293.71,100.11) 297.05,100.11 298.94,98.22 298.94,96.36 301.1,94.2 306.01,94.2 306.77,94.96 v1(306.97,94.96)
  BOTTOM w0.127: v1(306.97,94.96) 307.37,94.96 307.59,95.18 DZ15.9 DZ15.1 v1(307.59,98.98) ; v1(309.04,103.28) 308.52,103.8 JFPBTN1.13
GPIO003: length 15.6
  TOP w0.127: v1(285.77,83.23) 285.29,82.75 T390.1 ; v1(275.44,82.21) 275.47,82.21 UE1.E7
  IN4 w0.084: v1(275.44,82.21) 275.74,82.21 276.11,82.57 276.64,82.57 277.07,83 278.06,83 278.25,82.81 281.48,82.81 282.09,83.43 282.09,84.28 283.27,85.45 285.13,85.45 285.77,84.82 v1(285.77,83.23)
GPIO004: length 9.7
  TOP w0.127: UE1.D7 275.48,83.02 283.58,83.02 T391.1
GPP_A7: length 40.4
  TOP w0.127: v2(178.85,62.77) 178.45,62.37 v1(178.45,62.25) 178.45,61.67 178.44,61.67 RC841.1
  IN2 w0.102: 149.98,65.29 149.55,65.73 149.55,68 147.58,69.97 v1(147.58,71.31)
  IN2 w0.122: 149.98,65.29 151.11,65.29 152.35,64.05 160.28,64.05 160.65,63.68 165.25,63.68 166.8,62.14 167.57,62.14 168.9,63.47 174.32,63.47 174.45,63.34 174.58,63.21 175.16,63.21 175.51,62.86 175.51,62.22 175.91,61.82 178.02,61.82 v1(178.45,62.25)
  BOTTOM w0.089: UC1.CC32 v1(147.58,71.31)
GPP_A8: length 36.6
  TOP w0.127: v2(173.27,58.19) 172.9,58.56 v1(172.9,58.7) 172.9,58.71 172.17,59.44 RC849.1
  IN4 w0.076: v1(145.76,72.58) 146.29,72.05 146.29,71.14 146.36,71.07
  IN4 w0.102: v1(172.9,58.7) 172.36,58.16 169.81,58.16 168.2,59.76 158.78,59.76 154.23,64.31 153.4,64.31 151.73,65.97 151.38,65.97 148.31,69.04 147.54,69.04 146.78,69.8 146.78,70.65 146.36,71.07
  BOTTOM w0.089: UC1.BY30 145.3,72.83 v1(145.76,72.58)
GPP_A13: length 7.9
  TOP w0.127: T380.1 146.36,64.61 v1(145.84,64.1)
  BOTTOM w0.076: v1(145.84,64.1) 146.2,64.45 146.2,64.81 145.95,65.06 145.95,66.05 144.45,67.55 144.45,68.69 144.48,68.77 144.48,68.95 144.44,69.07 144.44,69.3 144.48,69.42 144.48,69.9 UC1.BV34
GPP_A15: length 1.6
  TOP w0.127: v1(145.75,71.31) 146.21,70.86 T381.1
  BOTTOM w0.089: UC1.BY32 145.3,71.53 v1(145.75,71.31)
GPP_B22: length 28.2
  TOP w0.127: RC46.2 166.27,60.7 v1(166.27,60.97) 166.27,61.19 v2(165.96,61.5)
  IN4 w0.076: v1(146.67,72.58) 147.21,72.04 147.21,71.13 147.27,71.07
  IN4 w0.102: v1(166.27,60.97) 165.26,59.96 158.95,59.96 154.42,64.5 153.47,64.5 151.81,66.16 151.46,66.16 149.89,67.73 149.89,67.91 148.07,69.73 147.92,69.73 147.6,70.04 147.6,70.74 147.27,71.07
  BOTTOM w0.089: UC1.CA30 146.29,72.79 v1(146.67,72.58)
GPP_B23: length 11.1
  TOP w0.127: v2(149.07,63.33) 149.29,63.56 150.1,63.56 v1(150.49,63.17) 150.94,63.62 RC317.1
  BOTTOM w0.076: UC1.CC34 147.68,69.87 147.68,68.93 147.81,68.69 147.81,68.31 147.63,68.14 147.63,67.79 149.44,65.98 149.44,64.26 149.54,64.16
  BOTTOM w0.102: 149.54,64.16 150.49,63.22 v1(150.49,63.17)
GPP_C2: length 13.5
  IN1 w0.102: v1(150.86,81.62) 150.86,81.24 151.13,80.96 151.7,80.96 152.26,80.41 155.5,80.41 156.03,79.88 160.47,79.88 v1(160.92,80.32)
  BOTTOM w0.089: v1(150.86,81.62) UC1.CJ15
  BOTTOM w0.127: RC266.1 162.24,80 161.92,80.32 v1(160.92,80.32)
GPP_C5: length 20.6
  TOP w0.127: RC397.1 RC277.1 v2(166.34,81.08) 166.06,81.08 v1(165.87,81.27)
  IN4 w0.102: v1(165.87,81.27) 165.71,81.12 161.95,81.12 160.01,83.06 157.23,83.06 157.16,82.99 154.89,82.99 154.24,82.34 152.05,82.34 151.72,82.02 149.98,82.02 v1(149.59,81.62)
  BOTTOM w0.089: v1(149.59,81.62) UC1.CG15
GPP_D12: length 9.9
  BOTTOM w0.076: 155.93,78.31 155.91,78.34 155.04,78.34 154.82,78.12 154.75,78.05 154.29,78.05 154.1,78.24 153.83,78.24 153.61,78.12 UC1.CP22
  BOTTOM w0.102: 155.93,78.31 157.73,78.31 159.08,76.96 v2(160.27,76.96) 161.99,76.96 162.19,77.15
  BOTTOM w0.127: RC847.1 162.19,77.15
GPP_H17: length 12.8
  IN2 w0.122: v1(163.7,74.99) 163.19,75.5 161.99,75.5 161.8,75.3 156.79,75.3 156.19,74.71 v1(156.19,74.42)
  BOTTOM w0.076: v1(156.19,74.42) 156.19,74.98 156.03,75.14 154.64,75.14 154.58,75.2 153.93,75.2 arc(153.82,75.22) 153.72,75.28 153.55,75.46 UC1.CP26
  BOTTOM w0.127: RC101.2 163.7,75.44 v1(163.7,74.99)
GPP_H21: length 25.1
  TOP w0.127: v1(148.95,75.4) v2(148.5,75.84)
  IN1 w0.084: v1(170,74.99) 169.24,74.23 166.29,74.23 166.18,74.34 158.53,74.34 157.55,75.32 154.49,75.32 154.04,75.76 152.21,75.76 152.02,75.94 149.3,75.94 148.95,75.6 v1(148.95,75.4)
  BOTTOM w0.089: UC1.CF25 v1(148.95,75.4)
  BOTTOM w0.127: v1(170,74.99) RC444.2 RC443.1
GPP_H23: length 15.1
  IN2 w0.102: v1(163.14,74.99) 162.85,75.28 162.08,75.28 161.79,74.99 156.85,74.99 156.75,74.88 v1(156.75,74.46)
  BOTTOM w0.076: UC1.CM26 152.34,75.71 154.09,75.71 154.3,75.5 154.76,75.5 154.93,75.32 156.52,75.32
  BOTTOM w0.127: RC537.1 163.47,76.57 RC446.2 163.14,76.25 v1(163.14,74.99) ; v1(156.75,74.46) 156.75,75.09 156.52,75.32
GPS_DISABLE#: length 27.4
  TOP w0.127: v1(277.61,61.02) 277.49,61.02 277.09,60.62 v2(277.09,60.52) 277.09,60.1 276.85,59.85 274.77,59.85 DZ6.1 ; v1(278.58,80.55) 278.22,80.91 UE1.H5 ; RE12.1 279.67,72.99 v1(279.78,73.09)
  IN2 w0.122: v1(277.61,61.02) 278.75,62.16 278.75,65.25 278.51,65.49 278.51,65.86 278.14,66.23 278.14,68.15 279.22,69.23 279.22,72.51 279.78,73.07 v1(279.78,73.09) 279.77,73.09 279.77,73.1 279.77,73.48 279.64,73.61 279.64,77.26 278.73,78.16 278.68,78.16 278.15,78.69 278.15,80.26 278.44,80.55 v1(278.58,80.55)
GPS_DISABLE#_R: length 4
  TOP w0.127: v1(273.63,63.11) 274.28,62.46 DZ6.2 275.32,62.05 v2(275.55,61.82)
  BOTTOM w0.127: v1(273.63,63.11) 273.63,63.43 273.43,63.63 JNGFF2.26
H_CATERR#: length 17.6
  BOTTOM w0.076: UC1.AA4 121.21,89.45 121.49,89.73 121.49,90.04 121.64,90.38 121.64,90.63 121.6,90.73 121.6,90.95 121.64,91.05 121.64,91.39 121.49,91.54 121.49,93.7 121.47,93.72 121.47,93.82 ; 119.64,99.82 119.64,99.8
  BOTTOM w0.114: 121.47,93.82 121.47,95.89
  BOTTOM w0.127: 121.47,95.89 v2(121.16,96.19) 120.33,97.03 120.33,98.75 119.64,99.43 119.64,99.8 ; 119.64,99.82 119.64,101.02 119.04,101.62 119.04,103.08 118.94,103.18 118.94,105.28 RC219.2
H_CPU_SVIDALRT#: length 14.7
  BOTTOM w0.076: 120.85,93.66 121.1,93.4 121.1,91.61 120.96,91.47 120.96,91.02 120.97,91 120.97,90.98 121.09,90.86 121.28,90.86 121.44,90.7 121.47,90.61 121.47,90.42 121.25,89.91 UC1.AA3
  BOTTOM w0.127: 120.85,93.66 120.85,95.56 119.7,96.7 119.7,98.36 118.75,99.31 118.75,100.63 v2(118.34,101.03) 117.44,101.94 RC155.1
H_CPUPWRGD: length 7.5
  BOTTOM w0.076: RC77.2 129.98,96.31 v2(129.29,97) ; 130.12,92.44 130.12,90.79 UC1.AR2
  BOTTOM w0.114: 130.12,92.44 130.01,92.54 130.01,94.08 129.81,94.28 129.81,95.08 CC300.1
  BOTTOM w0.127: CC300.1 RC77.2
H_CPUPWRGD_R: length 1.2
  BOTTOM w0.102: RC77.1 130.24,98.05 T355.1
H_THERMTRIP#: length 274.2
  TOP w0.127: RC559.1 137.14,99.49 136.45,98.8 v1(136.45,98.34) ; v2(201.24,35.59) 200.7,36.13 v1(200.7,36.13) ; v1(94.56,29.85) 94.56,28.9 RD27.2 94.04,28.03 93.48,27.46 RD14.2 ; v1(193,70.64) 191.78,71.86 191.78,74.48 193.79,76.49 v1(193.79,78.38)
  IN1 w0.084: v1(200.7,36.13) 200.34,36.48 200.34,38.43 200.24,38.54 200.24,41.28 197.41,44.12 195.98,44.12 193.51,46.58 190.58,46.58 181.28,55.89 v1(180.77,55.89) ; v1(193.79,78.38) 193.79,79.77 188.16,85.4 185.87,85.4 181.62,89.65 181.62,90.99 180.18,92.43 180.18,94.97 178.6,96.55 175.17,96.55 v1(173.96,97.75) 172.95,98.77 172.95,102.64 169.9,105.69 164.63,105.69 159.11,111.21 155.85,111.21 155.77,111.12 v1(155.77,110.37)
  IN2 w0.122: v1(94.56,29.85) 95.38,29.85 96.77,31.24 120.63,31.24 123.66,34.27 125.72,34.27 126.12,34.66 129.81,34.66 132.62,31.86 163.51,31.86 166.12,29.24 170.26,29.24 173.99,25.52 175.14,25.52 177.89,28.26 180.16,28.26 181.12,29.22 182.7,29.22 183.85,30.37 191.3,30.37 192.01,31.09 199.06,31.09 199.78,31.81 199.78,32.32 201.24,33.78 201.24,35.8 200.92,36.12 200.7,36.12 v1(200.7,36.13)
  IN4 w0.084: v1(155.77,110.37) 155.13,110.37 154.85,110.1 153.84,110.1 152.84,109.09 142.71,109.09 138.37,104.75 138.37,103.44 137.79,102.85 137.79,101.46 136.45,100.12 v1(136.45,98.34)
  BOTTOM w0.127: QE4.3 174.51,98.3 v1(173.96,97.75) ; v1(193,70.64) 193.78,70.64 193.91,70.51 193.91,65.63 190.44,62.16 186,62.16 184.28,60.45 184.28,59.4 v1(180.77,55.89)
H_THERMTRIP#_R: length 12.2
  TOP w0.127: RC218.2 136.54,99.88 RC559.2 136.01,99.87 135.67,99.52 v2(135.67,99.36) 135.67,98.94 v1(135.86,98.75)
  IN2 w0.122: v1(135.86,98.75) 135.93,98.83 137.43,98.83 138.05,98.21 v1(138.05,93.65)
  BOTTOM w0.076: v1(138.05,93.65) 138.25,93.45 138.25,91.21 UC1.BJ1
H_VCCST_PWRGD_XDP: length 4.1
  TOP w0.127: v1(62.48,95.78) 62.5,95.8 CC307.1 62.5,96.52 62.83,96.85 RC124.2 RC123.2 62.65,98.02 62.27,97.64 v2(61.99,97.64)
  BOTTOM w0.127: JXDP1.39 v1(62.48,95.78)
HDA_BIT_CLK: length 22.6
  TOP w0.127: RC93.2 147.48,54.17 v1(147.48,54.47)
  IN2 w0.089: v1(142.21,65.79) 142.3,65.79 142.5,65.59 142.5,64.46 142.64,64.32 142.64,61.28 141.88,60.52 141.88,59.42
  IN2 w0.122: v1(147.48,54.47) 146.53,53.52 143.2,53.52 141.88,54.84 141.88,59.42
  BOTTOM w0.076: 140.87,66.47 140.87,67.18 141.12,67.43 141.12,68.46 UC1.BN37
  BOTTOM w0.102: 140.87,66.47 141.54,65.79 v1(142.21,65.79)
HDA_BIT_CLK_R: length 156.4
  TOP w0.127: UA1.14 279.52,37.85 279.36,38.01 278.9,38.01 278.54,37.65 277.1,37.65 276.73,37.28 RA17.1 276.73,36.88 276.42,36.57 v1(275.02,36.57) ; v1(182.23,53.82) 181.73,53.32 181.73,52.04 181.5,51.81 180.67,51.81 179.95,51.1 174.29,51.1 173.76,51.63 v2(172.87,51.63) 167.66,51.63 167.07,51.05 156.67,51.05 154.55,48.93 151.96,48.93 151.51,49.38 150.75,49.38 149.73,50.4 149.47,50.4 149.12,50.75 149.12,51.73 148.71,52.14 CC27.1 148.59,52.14 RC93.1
  IN1 w0.084: v1(210.05,35.8) 210.34,35.8 211.56,34.58 216.66,34.58 219.51,31.73 224.87,31.73 228.63,27.97 230.05,27.97 234.18,32.1 249.65,32.1 250.95,30.8 256.28,30.8 256.91,30.18 259.64,30.18 261.52,32.06 264.95,32.06 265.48,32.59 270.83,32.59 271.14,32.9 272.4,32.9 273.5,33.99 273.5,34.21 274.72,35.43 275.04,35.43 275.41,35.79 275.41,36.49 275.32,36.57 v1(275.02,36.57)
  IN4 w0.084: v1(210.05,35.8) 210.05,36.16 209.24,36.97 207.67,36.97 204.68,39.96 204.68,40.5 200.08,45.11 192.04,45.11 186.55,50.6 186.55,50.95 183.68,53.82 v1(182.23,53.82)
HDA_RST#: length 25
  TOP w0.127: v2(143.1,52.94) CC331.1 RC560.2 144.32,52.07 144.72,51.67 v1(144.72,50.97)
  IN2 w0.102: v1(142,63.67) 141.15,62.83
  IN2 w0.122: 141.15,62.83 141.15,54.54 v1(144.72,50.97)
  BOTTOM w0.076: 140.65,65.73 140.23,66.15 140.23,67.63 140.06,67.8 140.06,68.12 140.26,68.31 140.26,68.69 140.15,68.89 140.15,69.18 140.15,69.19 UC1.BL35
  BOTTOM w0.102: 140.65,65.73 140.65,65.02 v1(142,63.67)
HDA_RST#_R: length 156.1
  TOP w0.127: RC560.1 144.11,50.7 144.26,50.55 145.48,50.55 145.66,50.73 146.69,50.73 147.47,49.95 147.47,49.81 148.16,49.12 148.96,49.12 150.03,48.05 150.91,48.05 151.43,47.54 155.5,47.54 157.04,49.08 v2(180.98,49.08) 181.49,49.08 183.32,50.91 v1(183.32,52.64) ; v1(273.34,43.46) 272.83,43.46 272.36,43.94 RA50.1
  IN1 w0.084: v1(208.73,36.12) 209.32,36.12 209.84,36.63 210.68,36.63 211.9,35.41 216.61,35.41 219.74,32.29 230.02,32.29 231.63,33.9 238.78,33.9 240.02,32.67 251.68,32.67 251.89,32.88 252.58,32.88 253.23,32.23 256.33,32.23 257.02,32.92 259.3,32.92 259.71,32.51 260.32,32.51 261.48,33.66 262.93,33.66 263.83,34.56 266.95,34.56 267.34,34.95 268.49,34.95 269.73,36.19 271.72,36.19 273.2,37.68 273.2,43.33 v1(273.34,43.46)
  IN4 w0.084: v1(183.32,52.64) 184.56,51.39 184.56,49.92 190.02,44.46 194.85,44.46 196.45,42.85 201.41,42.85 203.47,40.79 203.47,39.85 203.69,39.64 203.87,39.64 207.19,36.32 208.54,36.32 v1(208.73,36.12)
HDA_SDIN0: length 175.4
  TOP w0.127: v1(145.06,51.86) CC332.1 ; v1(273.56,36.25) 273.56,35.87 274.07,35.36 RA9.1
  IN1 w0.084: v1(208.31,35.49) 208.63,35.49 209.07,35.93 209.4,35.93 209.92,36.45 210.61,36.45 211.83,35.23 216.54,35.23 219.66,32.1 230.1,32.1 231.71,33.71 238.71,33.71 239.94,32.49 251.76,32.49 251.97,32.7 252.5,32.7 254.03,31.17 256.04,31.17 256.08,31.21 257.78,31.21 258.26,30.72 259.66,30.72 261.38,32.44 264.8,32.44 265.32,32.96 270.28,32.96 270.59,33.27 272.25,33.27 273.12,34.14 273.12,35.81 v1(273.56,36.25)
  IN2 w0.102: 142.44,61.36 142.44,63.95 v1(142.2,64.19)
  IN2 w0.122: 142.44,61.36 141.38,60.3 141.38,54.64 144.15,51.86 v1(145.06,51.86) 145.2,52 149.62,52 v1(150.16,51.46)
  IN4 w0.084: v1(208.31,35.49) 207.85,35.95 207.03,35.95 205.33,37.64 203.44,37.64 202.83,38.26 202.83,40.91 201.26,42.48 196.3,42.48 194.69,44.09 189.87,44.09 184.19,49.77 184.19,50.98 182.58,52.58 182.23,52.58 181.22,53.6 180.16,53.6 179.94,53.38 179.94,52.9 179.62,52.58 179.31,52.58 176.09,52.58 175.56,53.11 173.93,53.11 168.5,47.68 155.93,47.68 153.38,50.23 151.39,50.23 v1(150.16,51.46)
  BOTTOM w0.076: 140.89,65.75 140.42,66.21 140.42,67.4 140.8,67.78 140.8,68.14 140.62,68.31 140.62,68.69 140.73,68.89 140.73,69.52 UC1.BN35
  BOTTOM w0.102: 140.89,65.75 140.89,65.16 141.86,64.19 v1(142.2,64.19)
HDA_SDIN0_R: length 5.9
  TOP w0.127: UA1.16 280.32,37 279.83,36.51 277.81,36.51 v2(277.5,36.19) 276.91,35.6 275.72,35.6 RA9.2
HDA_SDOUT: length 28.2
  TOP w0.127: RC562.2 147.26,52.14 146.91,52.5 RC187.1 CC333.1 RC561.2 145.83,52.07 145.28,51.52 v1(145.28,50.97) ; v1(142.11,64.74) 142.39,64.74 v2(142.68,64.46)
  IN2 w0.089: 140.93,59.42 140.93,63.95 141.72,64.74 v1(142.11,64.74)
  IN2 w0.122: 140.93,59.42 140.93,54.21 144.56,50.58 144.89,50.58 v1(145.28,50.97)
  BOTTOM w0.076: UC1.BN36 141.05,69.13 140.78,68.65 140.78,68.38 140.96,68.21 140.96,67.57 140.68,67.29 140.68,66.27 141.11,65.84
  BOTTOM w0.102: v1(142.11,64.74) 141.57,64.74 141.19,65.13 141.19,65.77 141.11,65.84
HDA_SDOUT_R: length 162.6
  TOP w0.127: UA1.17 280.72,36.98 280.02,36.28 278.03,36.28 277.25,35.49 277.25,34.98 277.36,34.87 277.36,34.21 277.25,34.09 277.25,33.59 v1(277.56,33.27) ; RC561.1 146.62,51.16 147.73,50.05 147.73,49.92 148.27,49.38 149.04,49.38 149.04,49.38 149.25,49.38 150.32,48.31 151.14,48.31 151.54,47.92 154.97,47.92 156.69,49.64 167.1,49.64 167.5,50.03 v2(171.71,50.03) 181.69,50.03 182.74,51.09 182.74,52.7 183.23,53.19 v1(183.29,53.19)
  IN1 w0.084: v1(277.56,33.27) 277.56,30.81 276.13,29.38 266.68,29.38 265.99,28.69 264.59,28.69 264.19,29.08 262.71,29.08 261.95,28.32 255.49,28.32 254.85,28.96 254.17,28.96 253.53,28.32 240.47,28.32 237.37,31.42 234.16,31.42 230.24,27.51 228.43,27.51 224.39,31.55 219.3,31.55 216.73,34.11 210.87,34.11 v1(209.59,35.39)
  IN4 w0.084: v1(209.59,35.39) 209.59,35.97 209.05,36.51 207.48,36.51 204.22,39.77 204.22,40.31 201.49,43.04 196.53,43.04 194.92,44.64 190.1,44.64 184.74,50 184.74,51.73 v1(183.29,53.19)
HDA_SYNC: length 23.8
  TOP w0.127: RC92.2 148.04,54.44 v1(148.04,54.48) 148.04,55.08 v2(148.09,55.14)
  IN2 w0.089: 142.38,59.42 142.38,60.64 142.82,61.08 142.82,64.49 142.68,64.62 142.68,66.12 142.5,66.3 141.86,66.3 v1(141.5,66.66)
  IN2 w0.122: v1(148.04,54.48) 147.65,54.86 144.88,54.86 144.57,55.17 142.89,55.17 142.38,55.68 142.38,59.42
  BOTTOM w0.076: UC1.BN34 141.31,70.23 141.31,69.75 141.26,69.65 141.26,69.65 141.26,69.37 141.3,69.28 141.3,69.09 141.25,68.97 141.25,68.75 141.3,68.63 141.3,66.86
  BOTTOM w0.102: 141.3,66.86 141.5,66.66 v1(141.5,66.66)
HDA_SYNC_R: length 154.3
  TOP w0.127: UA1.15 279.92,36.98 279.67,36.74 277.49,36.74 276.75,36 v1(275.02,36) ; RC92.1 148.8,52.94 149.74,52 149.74,51.11 150.95,49.9 151.7,49.9 152.17,49.44 154.2,49.44 156.32,51.56 166.5,51.56 167.14,52.19 167.86,52.19 168.88,53.21 v2(171.14,53.21) 175.77,53.21 177.37,51.61 179.53,51.61 180.82,52.9 180.82,53.17 v1(181.62,53.96)
  IN1 w0.084: v1(275.02,36) 273.31,34.28 273.31,34.07 272.32,33.09 270.66,33.09 270.35,32.78 265.4,32.78 264.87,32.25 261.45,32.25 259.67,30.47 257.03,30.47 256.51,30.99 253.95,30.99 252.42,32.51 252.04,32.51 251.83,32.3 239.86,32.3 238.7,33.46 231.71,33.46 230.17,31.92 219.58,31.92 216.46,35.04 211.75,35.04 210.53,36.26 209.99,36.26 209.48,35.75 209.16,35.75 209.02,35.61 v1(209.02,35.35)
  IN4 w0.084: v1(209.02,35.35) 208.97,35.35 208.19,36.13 207.11,36.13 204.71,38.53 203.23,38.53 203.01,38.75 203.01,40.99 201.34,42.67 196.37,42.67 194.77,44.27 189.94,44.27 184.37,49.84 184.37,51.05 182.6,52.83 182.25,52.83 181.62,53.46 v1(181.62,53.96)
HDD_DET#: length 17
  BOTTOM w0.076: UC1.CN8 153,86.5 153.49,86.5 153.79,86.34 154.17,86.34 154.37,86.54 157.82,86.54 157.82,86.54
  BOTTOM w0.102: 167.01,87.5 166.57,87.5 165.95,86.88 v2(161.11,86.88) 159.48,86.88 159.21,86.62 158.4,86.62 158.33,86.54 157.82,86.54
  BOTTOM w0.127: 167.01,87.5 RC520.1 RC765.2
HDD_DEVSLP: length 7.6
  TOP w0.127: v1(159.66,87.47) 159.66,87.47 T417.1
  BOTTOM w0.076: 157.75,86.73 154.33,86.73 154.1,86.5 153.83,86.5 153.5,86.68 153.35,86.76 UC1.CP8
  BOTTOM w0.102: 157.75,86.73 158.22,86.73 158.34,86.85 159.04,86.85 v1(159.66,87.47)
HDMI_CEC: length 10
  TOP w0.127: JHDMI1.13 11.92,66.25 12.39,65.78 12.39,59.62 13.33,58.68 v2(13.75,58.68) RV19.1
HDMI_CLKN: length 3.9
  TOP w0.114: v1(18.34,59.5) 18.11,59.28 16.91,59.28 RV17.1
  BOTTOM w0.114: RV63.1 17.44,59.65 LV12.1 17.65,59.49 17.78,59.36 18.14,59.36 18.28,59.5 v1(18.34,59.5) 18.54,59.3 18.84,59.3 CV38.1
HDMI_CLKP: length 4
  TOP w0.114: v1(18.34,58.92) 18.23,59.03 16.89,59.03 RV16.1
  BOTTOM w0.114: CV37.1 18.61,59.03 18.45,59.03 v1(18.34,58.92) 18.14,59.11 17.78,59.11 LV12.2 17.45,58.78 RV62.1
HDMI_CTRL_CLK: length 20.4
  IN1 w0.084: JHDMI1.15 12.06,67.25 12.28,67.03 12.28,59.45 13.19,58.54 13.19,55.54 12.83,55.18 9.59,55.18 8.9,54.48 8.9,54.28 v1(8.93,54.25)
  BOTTOM w0.127: v1(8.93,54.25) 8.93,54.19 9.33,53.79 QV3.6 8.4,53.08 RV22.1
HDMI_CTRL_DATA: length 21.4
  IN1 w0.084: JHDMI1.16 12.96,67.75 12.45,67.24 12.45,60.13 13.66,58.92 13.66,55.3 12.83,54.48 10.82,54.48 v1(10.63,54.29)
  BOTTOM w0.127: v1(10.63,54.29) QV3.3 9.99,55.62 8.39,55.62 v2(8.14,55.38) 8.02,55.25 RV23.1
HDMI_HPD: length 8.9
  TOP w0.127: RV21.1 17.01,67.7 16.74,67.43 QV5.1 16.11,67.49 v2(16.11,69.09) 16.11,69.3 15.04,70.36 13.99,70.36 13.28,69.65 12.71,69.65 12.3,69.25 JHDMI1.19
HDMI_L_CLKN: length 9.5
  BOTTOM w0.114: RV63.2 16.52,59.65 LV12.4 16.23,59.49 16,59.25 15.7,59.25 RV35.1 15.1,59.22 14.92,59.22 14.64,59.49 14.64,63.6 14.29,63.96 14.29,64.97 14,65.26 13.6,65.26 13.15,65.72 JHDMI1.12
HDMI_L_CLKP: length 9.4
  BOTTOM w0.114: RV62.2 16.51,58.78 LV12.3 16.17,58.94 16.1,59.01 15.8,59.01 RV35.2 15.07,58.97 14.81,58.97 14.4,59.39 14.4,63.5 14.04,63.86 14.04,64.87 13.89,65.02 13.42,65.02 JHDMI1.10
HDMI_L_TX_N0: length 12.2
  BOTTOM w0.114: JHDMI1.9 11.98,63.87 12.28,63.87 12.57,63.58 12.57,59.51 13.71,58.37 13.71,56.71 14.81,55.61 15.09,55.61 RV32.1 15.72,55.62 15.98,55.62 16.14,55.78 LV9.4 16.47,55.93 RV61.2
HDMI_L_TX_N1: length 8.1
  BOTTOM w0.114: RV59.2 16.46,57.72 LV6.4 16.21,57.56 16.04,57.39 15.74,57.39 15.41,57.73 RV29.1 15.33,57.73 15.06,57.46 14.75,57.46 14.54,57.67 14.54,58.61 13.98,59.18 13.98,62.02 13.71,62.29 13.61,62.29 JHDMI1.6
HDMI_L_TX_N2: length 11.8
  IN4 w0.094: JHDMI1.3 11.99,60.86 12.23,60.86 12.49,60.6 12.49,59.9 13.69,58.7 13.69,53.87 13.94,53.62 14.43,53.62 v1(14.64,53.84)
  BOTTOM w0.114: RV57.2 16.49,53.99 LV3.4 16.17,53.83 16.04,53.71 15.75,53.71 15.45,54 RV26.1 15.34,54 15,53.65 14.83,53.65 v1(14.64,53.84)
HDMI_L_TX_P0: length 12.2
  BOTTOM w0.114: JHDMI1.7 11.97,63.62 12.18,63.62 12.33,63.47 12.33,59.41 13.47,58.27 13.47,56.61 v4(14.26,55.81) 14.71,55.37 15.06,55.37 RV32.2 15.76,55.37 15.99,55.37 16.13,55.23 LV9.3 16.48,55.07 RV60.2
HDMI_L_TX_P1: length 8.1
  BOTTOM w0.114: JHDMI1.4 13.44,62.04 13.61,62.04 13.73,61.92 13.73,59.07 14.29,58.51 14.29,57.57 14.65,57.22 15.01,57.22 RV29.2 15.73,57.14 16.01,57.14 16.15,57.01 LV6.3 16.47,56.84 RV58.2
HDMI_L_TX_P2: length 11.9
  IN4 w0.094: JHDMI1.1 11.6,60.29 11.94,60.64 12.13,60.64 12.26,60.51 12.26,59.81 13.47,58.6 13.47,53.78 13.85,53.4 14.51,53.4 v1(14.63,53.28)
  BOTTOM w0.114: v1(14.63,53.28) 14.76,53.41 15.08,53.41 15.4,53.09 RV26.2 15.46,53.09 15.83,53.46 16,53.46 16.17,53.28 LV3.3 16.5,53.12 RV56.2
HDMI_OB: length 9.2
  TOP w0.127: QV4.1 v2(14.97,61.33)
  TOP w0.508: RV10.2 RV11.2 RV14.2 RV15.2 15.65,56.65 15.63,56.67 RV12.2 RV13.2 15.67,57.72 RV16.2 RV17.2 15.67,59.7 15.93,59.96 15.93,61.1 QV4.1
HDMI_TX_N0: length 3.8
  TOP w0.114: v1(18.16,55.81) 17.91,55.56 16.9,55.56 RV15.1
  BOTTOM w0.114: CV36.2 18.75,55.59 18.38,55.59 v1(18.16,55.81) 17.97,55.62 17.72,55.62 LV9.1 17.42,55.93 RV61.1
HDMI_TX_N1: length 3.9
  TOP w0.114: v1(18.18,57.57) 17.95,57.33 16.9,57.33 RV13.1
  BOTTOM w0.114: RV59.1 17.39,57.72 LV6.1 17.72,57.39 18,57.39 v1(18.18,57.57) 18.4,57.35 18.72,57.35 CV34.2
HDMI_TX_N2: length 3.8
  TOP w0.114: v1(18.18,53.85) 17.96,53.63 16.85,53.63 RV11.1
  BOTTOM w0.114: CV32.2 18.8,53.65 18.38,53.65 v1(18.18,53.85) 17.98,53.65 17.76,53.65 LV3.1 17.42,53.99 RV57.1
HDMI_TX_P0: length 3.8
  TOP w0.114: v1(18.16,55.22) 18.04,55.34 18.01,55.31 16.86,55.31 RV14.1
  BOTTOM w0.114: RV60.1 LV9.2 17.71,55.37 18.01,55.37 v1(18.16,55.22) 18.28,55.34 18.6,55.34 CV35.2
HDMI_TX_P1: length 3.8
  TOP w0.114: v1(18.18,56.99) 18.07,57.11 18.05,57.09 16.83,57.09 RV12.1
  BOTTOM w0.114: CV33.2 18.64,57.11 18.3,57.11 v1(18.18,56.99) 18.03,57.14 17.69,57.14 LV6.2 RV58.1
HDMI_TX_P2: length 3.8
  TOP w0.114: RV10.1 16.9,53.39 18.07,53.39 v1(18.18,53.27)
  BOTTOM w0.114: CV31.2 18.57,53.41 18.32,53.41 v1(18.18,53.27) 18.05,53.41 17.7,53.41 LV3.2 17.42,53.12 RV56.1
HOST_DEBUG_TX: length 36.8
  TOP w0.127: UE1.G11 277.03,86.14 v1(277.03,86.15) ; RE306.2 293.31,96.22 RE73.2 293.83,96.63 v1(294.01,96.45)
  IN4 w0.084: v1(294.01,96.45) 293.25,96.45 292.04,97.66 291.54,97.66 291.17,97.29 291.17,96.57 289.91,95.32 287.22,95.32 286.96,95.06 279.03,95.06 276.58,92.61 276.58,90 276.74,89.85 276.74,87.43 276.58,87.28 276.58,86.6 v1(277.03,86.15)
  BOTTOM w0.127: JDEG1.8 296.46,91.09 296.61,91.24 296.61,92.51 296.3,92.83 295.79,92.83 295.34,93.28 295.34,95.12 v2(295.01,95.45) v1(294.01,96.45)
HOST_SD_WP#: length 173.3
  TOP w0.127: v1(179.68,62.17) 179.41,62.17 179.26,62.02 RC292.1 ; v1(155.61,65.53) 155.61,65.01 v2(155.97,64.65) ; QR1.2 287.23,52.29 286.82,52.7 v1(286.58,52.7)
  IN1 w0.084: v1(179.68,62.17) 179.7,62.18 179.7,62.53 179.84,62.67 181.17,62.67 181.31,62.53 181.31,62.1 181.53,61.88 181.87,61.88 182.28,62.29 183.64,62.29 184.54,61.38 184.54,59.46 188.59,55.41 189.36,55.41 190.89,53.88 191.68,53.88 193.72,51.84 197.94,51.84 213.34,36.44 216.51,36.44 219.73,33.22 229.63,33.22 230.97,34.55 239.05,34.55 240.29,33.32 251.41,33.32 251.62,33.53 252.85,33.53 253.4,32.98 255.85,32.98 256.76,33.89 257.33,33.89 257.55,34.11 261.54,34.11 261.79,33.85 262.86,33.85 263.75,34.74 266.87,34.74 267.27,35.14 268.24,35.14 268.41,35.14 269.65,36.38 271.54,36.38 272.96,37.8 272.96,43.61 273.18,43.83 274.04,43.83 275.39,45.18 275.99,45.18 276.99,46.17 276.99,46.65 278.4,48.07 278.98,48.07 279.53,48.62 279.53,50.22 279.54,50.23 279.54,50.34 281.9,52.7 v1(286.58,52.7)
  IN2 w0.122: v1(155.61,65.53) 156.42,64.72 160.56,64.72 160.93,64.35 166.03,64.35 166.47,63.92 174.51,63.92 174.76,63.66 175.35,63.66 176.33,62.68 178.57,62.68 179.09,62.17 v1(179.68,62.17)
  BOTTOM w0.076: UC1.CH35 150.22,69.52 150.22,68.89 150.32,68.71 150.32,68.3 150.15,68.14 150.15,67.83 150.43,67.54 150.47,67.54
  BOTTOM w0.125: 150.47,67.54 151.1,66.91 151.84,66.91 152.15,66.61 152.15,65.66 152.28,65.54 155.61,65.54 v1(155.61,65.53)
HP_OUT_L: length 16.2
  TOP w0.203: 285.44,38.86 285.04,38.86 284.86,39.04 UA1.27
  TOP w0.381: CA43.1 285.02,45.63 v1(285.06,45.59) ; v1(288.47,37.83) RA7.1 CA74.1 286.47,37.83 v2(285.57,38.73) 285.44,38.86
  IN2 w0.381: v1(285.06,45.59) 285.72,46.25 286.33,46.25 286.71,45.87 286.71,42.28 288.47,40.52 v1(288.47,37.83)
HP_OUT_R: length 18.6
  TOP w0.127: v1(289.57,36.71) v2(290.34,36.71)
  TOP w0.203: 285.22,38.26 285.13,38.26 284.74,38.64 UA1.26
  TOP w0.381: 285.22,38.26 285.93,37.55 285.93,37.45 286.1,37.28 287.02,37.28 287.1,37.2 287.1,37.2 CA73.1 RA8.1 v1(289.57,36.71) ; v1(285.88,45.59) 286.21,45.92 CA44.1
  IN2 w0.381: v1(285.88,45.59) 286.07,45.4 286.07,41.97 287.79,40.25 287.79,37.56 288.14,37.2 289.07,37.2 v1(289.57,36.71)
HV_GATE1_A: length 4.3
  TOP w0.127: v2(35.35,60.55) 35.35,60.17 v1(35.19,60) 35.1,60 34.69,59.59 34.39,59.59 34.23,59.75 RT64.1
  BOTTOM w0.076: UT5.B9 33.52,59.74 34.23,59.74 34.41,59.56 34.54,59.56
  BOTTOM w0.127: v1(35.19,60) 34.74,59.56 34.54,59.56
HV_GATE2_A: length 1.4
  TOP w0.127: v1(34.54,60) 34.15,60.38 RT65.1
  BOTTOM w0.127: UT5.A9 33.78,60 v1(34.54,60)
HW_ACAVIN_NB: length 452.9
  TOP w0.127: v2(36.95,54.05) PR746.1 ; UE1.N6 284.26,81.76 v1(284.36,81.86)
  TOP w0.203: 50.73,91.78 50.73,92.08 50.64,92.17 50.64,93.56 50.97,93.89 50.97,94.08 51.5,94.61 52.14,94.61 52.88,95.35 52.88,96.28 52.94,96.41 52.94,97.12 52.16,97.9 52.16,98.37 51.83,98.7 50.82,98.7 50.35,99.17 50.35,103.42 49.38,104.39 46.42,104.39 v1(46.17,104.64)
  TOP w0.254: PR25.2 66.1,91.07 v1(66.62,90.54) ; 50.73,91.78 50.73,91.37 50.96,91.14 52.15,91.14 52.38,91.37 PR42.1 52.69,91.98 54.37,91.98 PR41.1 54.56,92.02 54.98,91.6 55.53,91.6 v1(56,91.13) ; v1(52.79,79.18) 52.81,79.16 52.81,79.09 52.33,78.61 51.54,78.61 49.67,76.73 PR805.2 49.58,78.17 49.25,78.51 47.05,78.51 46.4,77.86 45.62,77.86 44.98,77.21 ; PR746.1 36.95,52.99 37.37,52.58 37.37,52.57 37.62,52.32 v1(38.23,52.32) ; v1(45.37,63.53) 45.48,63.53 46.03,62.99 47.28,62.99 48.08,63.79 PR737.1 ; PU800.1 45.2,76.99 44.98,77.21 ; 44.98,77.21 43.74,77.21 43.48,76.95 PC805.1 43.48,75.63 42.97,75.11 42.45,75.11 42.23,74.9 PR806.2 ; PR844.1 PR845.1 40.72,104.39 40.47,104.64 v1(40.47,104.83) ; v1(37.09,86.29) 37.09,85.97 37.98,85.08 39.38,85.08 39.68,84.78 PR835.1
  IN1 w0.254: v1(66.62,90.54) 64.9,90.54 63.43,92.02 60.76,92.02 59.95,92.83 58.49,92.83 57.6,91.94 56.44,91.94 56,91.5 v1(56,91.13)
  IN2 w0.254: v1(33.33,102.03) 33.33,101.1 33.85,100.58 33.85,99.56 36.2,97.21 36.2,96.07 36.39,95.88 36.39,86.99 v1(37.09,86.29) ; v1(46.17,104.64) 46.17,104.45 45.73,104.01 44.9,104.01 44.27,104.64 40.66,104.64 v1(40.47,104.83)
  IN3 w0.122: v1(38.23,52.32) 38.23,51.81 39.66,50.38 40.62,50.38 41.31,51.08 41.31,51.39 42.59,52.67 43.34,52.67 44.22,51.79 49.03,51.79 49.39,51.43 49.39,49.25 53.09,45.55 58.43,45.55 58.77,45.22 59.87,45.22 60.27,45.62 67.8,45.62 67.91,45.73 83.87,45.73 84.14,46 93.34,46 95.41,48.06 138.15,48.06 142.08,44.13 153.63,44.13 154.96,45.47 200.24,45.47 201.57,44.13 205.13,44.13 207.88,41.38 210.46,41.38 215.11,36.73 220.1,36.73 221.77,35.06 224.93,35.06 225.21,34.78 237.1,34.78 237.52,34.36 245.16,34.36 245.81,35.02 250.23,35.02 250.96,35.74 253.3,35.74 253.69,36.14 256.41,36.14 257.36,37.09 259.74,37.09 261.31,38.67 262.52,38.67 264.61,40.76 267.5,40.76 268.3,41.56 268.83,41.56 269.34,42.06 271.02,42.06 272.72,43.76 272.72,47.26 272.93,47.47 272.93,48.96 275.11,51.13 275.49,51.13 275.81,51.45 275.81,52.26 276.23,52.68 277.08,52.68 278.34,53.94 280.24,53.94 281.13,54.83 281.13,56.61 282.08,57.55 282.08,58.44 281.9,58.61 281.9,60.83 280.68,62.06 280.68,64.89 281.04,65.25 281.04,67.74 282.08,68.78 282.08,71.06 282.57,71.55 283.4,71.55 283.68,71.82 283.68,73.45 283.84,73.61 283.84,74.81 283.51,75.14 283.51,76.37 284.36,77.22 284.36,81.86 v1(284.36,81.86)
  IN3 w0.254: v1(33.33,102.03) 35.11,103.8 39.25,103.8 39.5,104.06 39.5,104.58 39.82,104.9 40.33,104.9 40.39,104.83 v1(40.47,104.83) ; v1(56,91.13) 56,87.75 54.24,85.99 54.24,83.05 53.37,82.19 53.37,79.77 v1(52.79,79.18) ; v1(38.23,52.32) 38.49,52.57 40.46,52.57 41.85,53.97 41.85,56.31 44.2,58.66 44.2,61.36 44.81,61.97 44.81,63.14 45.21,63.53 v1(45.37,63.53)
  IN4 w0.254: v1(52.79,79.18) 52.81,79.16 52.81,79.09 51.17,77.45 51.17,75.99 49.03,73.84 49.03,73.48 48.61,73.06 47.94,73.06 46.11,71.23 46.11,65.69 46.62,65.18 46.62,64 45.99,63.38 45.52,63.38 v1(45.37,63.53)
I2C1_SCK_TP: length 128.8
  IN1 w0.084: v1(150.86,83.7) 151.23,84.08 151.62,84.08 152.33,83.37 152.61,83.37 153.22,82.76 156.39,82.76 156.94,82.2 162.09,82.2 162.53,82.64 166.09,82.64 166.95,81.78 174.99,81.78 175.84,80.92 175.84,80.71 176.71,79.84 176.71,77.39 176.2,76.88 176.2,75.81 180.14,71.87 182,71.87 193.18,60.7 195.51,60.7 196.17,60.04 198.37,60.04 216.33,42.08 219.97,42.08 222.38,39.68 228.23,39.68 228.95,40.39 242.49,40.39 243.49,41.4 244.86,41.4 245.86,40.4 v1(245.86,40.32)
  BOTTOM w0.076: UC1.CJ12 v1(150.86,83.7)
  BOTTOM w0.127: v1(245.86,40.32) 245.79,40.24 245.79,37.74 247.1,36.43 249.45,36.43 249.73,36.7 251.5,36.7 RZ21.2 252.22,36.6 252.29,36.52 RZ29.1
I2C1_SCK_TP_R: length 18.1
  TOP w0.127: v1(254.55,33.87) 254.55,33.36 255.4,32.51 255.4,28.31 254.9,27.81 v3(253.89,27.81) 252.75,27.81 252.58,27.64 249.62,27.64 249.31,27.96 RZ347.1
  BOTTOM w0.127: RZ29.2 253.18,36.28 253.18,35.73 RZ117.2 253.27,35.61 253.52,35.36 253.82,35.36 254.55,34.63 v1(254.55,33.87) 254.55,33.68 254.08,33.21 JKBTP1.19
I2C1_SDA_TP: length 128.8
  IN1 w0.084: v1(245.3,40.32) 245.26,40.27 242.99,40.27 242.83,40.12 228.94,40.12 228.31,39.49 222.3,39.49 219.9,41.9 216.25,41.9 198.3,59.85 196.09,59.85 195.43,60.51 193.1,60.51 181.93,71.69 180.07,71.69 176.02,75.73 176.02,77.01 176.53,77.52 176.53,79.76 175.65,80.63 175.65,80.85 174.91,81.59 166.87,81.59 166.01,82.45 162.6,82.45 162.18,82.03 156.87,82.03 156.31,82.59 153.15,82.59 152.54,83.19 152.26,83.19 151.75,83.7 v1(151.49,83.7)
  BOTTOM w0.089: UC1.CK12 v1(151.49,83.7)
  BOTTOM w0.127: RZ26.1 251.66,33.98 RZ20.2 251.08,34.04 250.49,34.63 250.49,36.15 250.16,36.48 249.82,36.48 249.55,36.2 247.01,36.2 245.56,37.65 245.56,40.06 v1(245.3,40.32)
I2C1_SDA_TP_R: length 9.1
  TOP w0.127: v1(253.99,33.87) 253.99,33.54 254.72,32.81 v3(254.72,32.57) 255.12,32.16 255.12,29.92 RZ346.1
  BOTTOM w0.127: JKBTP1.18 253.58,33.29 253.99,33.7 v1(253.99,33.87) 253.99,34.64 253.75,34.87 RZ116.2 252.94,34.54 RZ26.2
I2C2_SCL_ALS: length 1.7
  TOP w0.127: v1(149.4,73.22) 149.82,73.63 T389.1
  BOTTOM w0.089: v1(149.4,73.22) 149.37,73.24 UC1.CF29
I2C2_SDA_ALS: length 1.8
  TOP w0.127: v1(149.4,74.49) 149.01,74.49 149.01,74.49 T388.1
  BOTTOM w0.089: UC1.CF27 v1(149.4,74.49)
I2C3_ANT_SCL: length 156
  TOP w0.127: RC513.1 167.98,66.15 v1(167.6,66.53) ; v1(108.53,111.2) 108.53,109.95 108.27,109.7 RC549.1 107.91,109.32 v2(108.57,108.67)
  IN2 w0.076: v1(150.31,73.85) 150.69,73.47 150.69,73.01 151.11,72.6 152.18,72.6 153.64,71.14 154.99,71.14 155.35,70.77
  IN2 w0.102: 155.35,70.77 156.44,69.69 156.81,69.69 157.22,69.29 157.22,68.91 158.48,67.65 160.66,67.65 161.21,67.09 161.21,67.09 161.68,66.63 162.23,66.26 162.84,66 163.22,65.93 163.4,65.87 165.49,65.87 166.39,66.77 167.36,66.77 v1(167.6,66.53)
  IN2 w0.122: v1(108.53,111.2) 109.31,111.98 136.2,111.98 137.46,110.72 141.13,110.72 141.6,110.25 145.6,110.25 147.14,108.71 153.49,108.71 153.94,109.16 156.42,109.16 158.52,111.26 164.27,111.26 170.21,105.33 170.21,101.86 v1(170.55,101.52)
  IN3 w0.122: v1(170.55,101.52) 170.55,100.99 171.32,100.23 171.4,100.23 171.86,99.76 171.86,96.6 170.85,95.59 170.85,93.21 172.71,91.35 172.71,89.23 173.33,88.61 173.33,88.27 172.94,87.88 172.94,85.53 172.56,85.15 172.56,83.77 172.36,83.57 167.11,83.57 166.34,82.8 164.52,82.8 162.56,80.85 162.56,77.08 162.3,76.82 162.3,75.11 162.11,74.91 162.11,72.74 160.16,70.79 160.16,70.39 159.46,69.69 157.7,69.69 157.34,69.32 157.34,68.81 158.72,67.43 160.83,67.43 163.02,65.24 165.01,65.24 166.63,66.86 167.27,66.86 v1(167.6,66.53)
  BOTTOM w0.089: UC1.CH28 v1(150.31,73.85)
I2C3_ANT_SCL_R: length 5.2
  TOP w0.127: v2(107.18,113.32) 108.08,113.32 v1(108.53,112.87) 108.07,112.41 108.07,110.73 107.91,110.57 RC549.2
  BOTTOM w0.127: JASA1.3 v1(108.53,112.87)
I2C3_ANT_SDA: length 157.3
  TOP w0.127: v2(107.17,108.62) 107.33,108.78 RC548.1 107.09,109.7 106.94,109.85 106.94,110.81 v1(107.33,111.2) ; v1(167.7,67.14) 167.81,67.04 RC512.1
  IN2 w0.076: v1(150.31,74.49) 150.87,73.93 150.87,73.07 151.18,72.76 152.25,72.76 153.71,71.3 155.11,71.3 155.45,70.96
  IN2 w0.102: v1(167.7,67.14) 167.54,66.98 166.3,66.98 165.4,66.08 163.43,66.08 163.27,66.12 162.9,66.2 162.64,66.31 162.33,66.44 161.81,66.78 161.36,67.23 161.36,67.23 160.74,67.85 158.56,67.85 157.42,68.99 157.42,69.37 156.9,69.89 156.52,69.89 155.45,70.96
  IN2 w0.122: v1(107.33,111.2) 108.33,112.2 136.29,112.2 137.55,110.94 141.22,110.94 141.69,110.47 145.69,110.47 147.23,108.93 153.39,108.93 153.89,109.43 156.37,109.43 158.42,111.49 164.37,111.49 170.55,105.31 170.55,102.1 170.95,101.7 170.95,101.15 v1(170.99,101.11)
  IN3 w0.122: v1(170.99,101.11) 170.99,100.95 172.08,99.86 172.08,96.5 171.08,95.5 171.08,94.1 171.66,93.51 171.66,92.72 172.94,91.44 172.94,89.32 173.55,88.7 173.55,88.18 173.16,87.79 173.16,85.44 172.78,85.06 172.78,83.68 172.45,83.35 167.2,83.35 166.43,82.58 164.61,82.58 162.79,80.76 162.79,76.99 162.53,76.73 162.53,75.02 162.33,74.82 162.33,72.64 160.38,70.69 160.38,70.3 159.55,69.47 157.8,69.47 157.56,69.23 157.56,68.91 158.81,67.65 160.92,67.65 163.11,65.46 164.92,65.46 166.59,67.14 v1(167.7,67.14)
  BOTTOM w0.089: UC1.CH27 v1(150.31,74.49)
I2C3_ANT_SDA_R: length 3.9
  TOP w0.127: RC548.2 107.33,110.49 107.8,110.97 107.8,111.63 v2(107.42,112.01) 107.42,112.56 v1(107.73,112.87)
  BOTTOM w0.127: JASA1.2 v1(107.73,112.87)
I_ADP: length 325.1
  TOP w0.127: v1(272.99,86.18) UE1.B11
  TOP w0.254: v1(48.16,47.12) 47.85,47.12 v2(47.56,47.41) 47.21,47.76 PR743.2
  IN1 w0.084: v1(288.8,87.46) 286.73,87.46 286.26,87 284.07,87 283.85,87.22 283.52,87.22 283.47,87.16 279.8,87.16 279.59,87.37 279.27,87.37 279.1,87.21 277.35,87.21 277.16,87.41 276.85,87.41 276.61,87.17 276.61,86.73 276.45,86.58 273.43,86.58 273.04,86.18 v1(272.99,86.18)
  IN3 w0.122: v1(288.8,87.46) 287.38,87.46 285.56,85.65 285.56,84.3 287.79,82.07 288.75,82.07 290.25,80.57 290.25,80.19 289.37,79.31 285.16,79.31 284.81,78.96 284.81,75.23 285.45,74.59 285.45,74 285.4,73.95 285.4,71.2 283.72,69.53 283.72,68.24 284.34,67.62 284.34,65.06 284.11,64.83 283.49,64.83 283.36,64.71 283.36,61.44 284.68,60.13 284.68,59.42 284.33,59.07 284.33,57.17 283.09,55.93 283.09,54.35 282.85,54.11 282.05,54.11 280.74,52.81 278.79,52.81 277.63,51.64 277.63,51.51 276.13,50.01 275.58,50.01 274.05,48.49 274.05,48.05 274.41,47.69 274.41,46.32 275.01,45.71 275.01,44.89 274.6,44.48 274.6,43.06 273.32,41.79 272.33,41.79 269.47,38.93 267.52,38.93 267.08,39.37 265.26,39.37 263.24,37.36 261.72,37.36 260.05,35.7 259.26,35.7 258.51,34.94 256.8,34.94 256.12,34.26 253.44,34.26 252.19,33.01 246.31,33.01 243.91,30.61 241.07,30.61 238.98,32.7 237.6,32.7 236.76,33.54 232.07,33.54 231.22,32.7 225.71,32.7 225.02,33.38 220.94,33.38 218.71,35.62 214.45,35.62 209.8,40.26 207.42,40.26 204.66,43.02 140.79,43.02 137.18,46.63 95.55,46.63 93.54,44.61 68.38,44.61 67.87,44.1 58.31,44.1 58.16,44.25 49.86,44.25 48.16,45.95 v1(48.16,47.12)
I_BATT: length 281.6
  TOP w0.127: v2(48.72,46.59) 48.96,46.83 v1(48.96,47.75) ; v1(275.82,67.17) 276.7,68.05 RE64.2
  TOP w0.254: PR729.2 48.86,47.85 v1(48.96,47.75)
  IN1 w0.084: v1(275.82,67.17) 276.04,67.17 276.38,66.84 281.4,66.84 281.72,66.52 v1(282.72,66.52)
  IN3 w0.122: v1(48.96,47.75) 49.16,47.75 52.43,44.47 58.25,44.47 58.4,44.32 67.77,44.32 68.28,44.83 93.44,44.83 95.46,46.85 137.27,46.85 140.88,43.24 154,43.24 154.64,43.88 200.56,43.88 201.2,43.24 204.75,43.24 207.51,40.49 209.96,40.49 214.61,35.84 218.81,35.84 220.68,33.97 224.76,33.97 225.76,32.96 231.17,32.96 231.97,33.76 236.85,33.76 237.69,32.92 239.24,32.92 240.23,31.93 244.92,31.93 246.31,33.32 252.18,33.32 253.35,34.49 256.02,34.49 256.7,35.17 258.42,35.17 259.23,35.98 260.02,35.98 260.86,36.83 261.62,37.59 263.15,37.59 265.33,39.77 269.99,39.77 272.23,42.01 273.23,42.01 274.18,42.96 274.18,47.6 273.83,47.95 273.83,48.58 275.48,50.24 275.91,50.24 278.7,53.03 280.6,53.03 281.9,54.33 282.63,54.33 282.87,54.57 282.87,56.03 284.1,57.26 284.1,59.17 284.45,59.52 284.45,59.93 283.14,61.25 283.14,62.19 282.99,62.34 282.99,64.87 282.25,65.61 282.25,66.05 v1(282.72,66.52)
