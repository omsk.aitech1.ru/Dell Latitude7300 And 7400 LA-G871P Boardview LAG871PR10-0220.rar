# Allegro board LAG871PR10-0220.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 269.58,33.22 269.66,33.18 269.68,33.09 269.68,33.04 269.68,32.05 269.83,31.82 270.11,31.87 270.18,31.9 270.25,31.87 270.53,31.82 270.68,32.05 270.68,33.04 270.68,33.09 270.7,33.18 270.78,33.22 271.58,33.22 271.66,33.18 271.68,33.09 271.68,33.04 271.68,32.05 271.7,31.95 271.76,31.86 271.76,31.52 271.73,31.51 271.57,31.22 271.73,30.93 271.76,30.92 271.76,30.3 271.6,30.13 268.47,30.13 268.47,30.13 267.75,30.13 267.51,30.37 267.51,30.57 267.53,30.6 267.57,30.79 267.67,30.87 267.76,30.91 267.76,31.06 267.8,31.14 267.88,31.16 267.94,31.16 268,31.17 268.07,31.16 268.11,31.1 268.45,30.89 268.75,31.16 268.79,31.23 268.87,31.25 269.23,31.43 269.14,31.83 269.12,31.86 269.13,31.9 269.17,31.97 269.18,32.05 269.18,33.04 269.18,33.09 269.2,33.18 269.28,33.22
GND on BOTTOM (solid shape): 312.65,104.23 312.66,104.19 312.65,104.09 312.57,104.05 311.64,104.05 311.64,104.05 311.26,103.76 311.57,103.4 311.66,103.34 311.66,103.24 311.64,102.95 311.85,102.76 311.92,102.69 311.89,102.59 311.48,102.18 309.51,102.18 309.03,102.28 308.98,101.79 309,101.72 308.97,101.65 308.89,101.51 308.88,101.35 308.89,101.33 308.82,101.26 308.71,101.24 308.65,101.33 308.62,101.45 308.55,101.55 308.65,101.8 308.55,102.05 308.65,102.3 308.55,102.55 308.59,102.61 308.63,102.68 308.7,102.74 308.8,102.72 308.83,102.68 309.73,102.68 310.49,103.44 310.51,103.44 310.88,103.66 310.72,104.06 310.67,104.15 310.72,104.24 310.86,104.39 310.88,104.59 310.88,104.61 310.95,104.68 312.21,104.68
GND on BOTTOM (solid shape): 111.12,86.79 111.29,87 111.37,86.74 111.33,86.71 111.25,86.26 111.26,86.22 111.28,86.18 111.28,86.15 111.28,86.1 111.36,85.98 111.52,85.96 111.61,86.05 111.62,86.09 111.78,86.21 111.92,86.07 112,85.92 112.17,85.9 112.23,85.91 112.29,85.9 112.36,85.89 112.53,86.05 112.54,86.09 112.69,86.21 112.84,86.09 112.95,85.96 113.12,85.96 113.2,85.99 113.29,85.98 113.36,85.97 113.46,86.05 113.47,86.1 113.73,86.16 113.59,85.9 113.49,85.82 113.5,85.75 113.5,85.7 113.49,85.64 113.39,85.51 113.24,85.46 113.21,85.46 113.1,85.5 113.02,85.58 112.99,85.62 112.52,85.62 112.48,85.54 112.24,85.38 112,85.54 111.96,85.62 111.66,85.62 111.63,85.58 111.51,85.47 111.35,85.45 111.32,85.46 111.24,85.5 111.18,85.58 111.16,85.6 111.15,85.64 111.14,85.72 111.16,85.8 111.19,85.87 111.11,86 111.07,86.01 110.98,86.13 111.02,86.26 111.05,86.29 111.14,86.75
GND on BOTTOM (solid shape): outline of 149 points within 57.42,65.15 84.58,85.46
GND on BOTTOM (solid shape): 130.91,71.64 130.91,70.76 130.8,70.65 130.74,70.52 130.76,70.39 130.77,70.37 130.55,69.91 130.55,68.97 130.46,68.81 130.37,68.76 130.28,68.81 130.2,68.95 130.2,69.89 129.97,70.37 129.86,70.71 129.53,70.55 129.46,70.49 129.36,70.51 129.25,70.62 128.66,70.62 128.22,70.48 128.66,70.35 128.78,70.35 128.86,70.31 128.88,70.23 128.87,70.16 128.89,70.05 128.67,69.95 128.65,69.99 128.41,70.09 128.25,69.88 128.25,69.81 128.14,69.71 127.69,70.16 127.71,70.2 127.79,70.53 127.66,70.84 127.64,70.93 127.69,71 127.77,71.05 127.85,70.97 128.77,70.97 128.92,71.12 129,71.15 129.07,71.11 129.43,70.97 129.7,71.24 129.7,71.25 129.75,71.29 129.77,71.29 129.96,71.35 130.05,71.52 130.09,71.59 130.17,71.61 130.2,71.64 130.23,71.63 130.39,71.66 130.53,71.77 130.78,71.77
GND on BOTTOM (solid shape): 152.4,86.92 152.43,86.72 152.61,86.63 152.67,86.63 152.94,86.36 153.46,86.36 153.68,86.24 153.73,86.17 153.69,86.08 153.56,86 152.35,86 152.04,85.7 152.02,85.7 151.81,85.61 151.77,85.37 151.79,85.34 151.73,85.29 151.64,85.26 151.57,85.32 151.2,85.42 151.18,85.04 151.21,84.98 151.19,84.92 151.14,84.78 151.15,84.63 151.14,84.54 151.06,84.5 150.65,84.5 150.57,84.54 150.56,84.63 150.54,84.89 150.35,85.07 150.29,85.11 150.28,85.18 150.28,85.29 150.22,85.39 150.22,85.65 150.28,85.7 150.32,85.75 150.37,85.8 150.44,85.8 150.57,85.78 150.69,85.8 150.76,85.8 150.82,85.75 151.02,85.63 151.23,85.74 151.29,85.78 151.36,85.78 151.78,85.92 151.73,86.36 151.7,86.43 151.73,86.51 151.76,86.54 151.79,86.58 151.85,86.62 151.92,86.62 152.15,86.66 152.24,86.87 152.24,86.89 152.32,86.98 152.4,86.98
GND on BOTTOM (solid shape): outline of 84 points within 145.19,77.47 149.36,80.93
GND on BOTTOM (solid shape): 148.56,87.72 148.71,87.68 148.86,87.71 148.93,87.72 148.99,87.68 149.18,87.58 149.38,87.68 149.44,87.72 149.5,87.71 149.64,87.68 149.79,87.71 149.85,87.72 149.91,87.68 150,87.6 150.12,87.58 150.2,87.54 150.22,87.46 150.22,87.45 150.2,87.41 150.16,87.4 149.99,87.38 149.88,87.24 149.83,87.19 149.75,87.18 149.59,87.19 149.44,87.14 149.04,86.92 149.01,86.96 148.65,87.11 148.38,86.84 148.34,86.78 148.27,86.76 148.25,86.76 148.18,86.78 148.14,86.84 147.8,87.12 147.45,86.84 147.41,86.78 147.31,86.77 147.3,86.8 147.07,87.14 146.67,87.14 146.33,86.96 146.29,87.03 146.26,87.05 146.25,87.09 146.26,87.12 146.33,87.23 146.36,87.35 146.38,87.38 146.41,87.39 146.51,87.4 146.59,87.43 146.77,87.52 147.05,87.65 147.09,87.67 147.12,87.68 147.15,87.66 147.35,87.58 147.53,87.68 147.59,87.72 147.66,87.71 147.8,87.68 147.94,87.71 148.01,87.72 148.06,87.68 148.26,87.58 148.46,87.68 148.47,87.69 148.54,87.73
GND on BOTTOM (solid shape): 17.85,35.68 17.85,34.09 17.82,34.07 14.46,34.07 14.17,33.78 13.34,33.78 13.33,33.79 12.78,33.92 12.37,34.29 8.58,34.29 8.58,34.28 8.45,34.16 8.45,21.05 8.97,20.54 8.96,20.51 10.27,18.43 12.2,19.96 12.2,20.01 13.34,20.01 13.34,20.01 13.63,19.97 13.92,20.01 13.92,20.01 14.56,20.01 14.68,19.89 14.68,19.55 14.64,19.47 14.01,19.28 13.78,18.75 13.78,15.05 13.54,14.49 12.98,14.25 11.18,14.25 10.62,14.49 10.38,15.05 10.38,15.95 9.74,17.51 8.18,18.15 2.4,18.15 2.1,18.21 1.84,18.39 1.22,19.01 1.04,19.27 0.98,19.57 0.98,31.65 1.07,31.86 1.28,31.95 2.23,31.95 3.08,32.3 3.43,33.15 3.43,34.45 3.52,34.66 3.73,34.75 12.65,34.75 12.66,34.71 13.44,34.26 14.02,34.95 14.02,36.21 17.32,36.21
GND on BOTTOM (solid shape): outline of 95 points within 113.89,87.64 116.97,90.58
GND on BOTTOM (solid shape): outline of 84 points within 299.6,47.75 317.3,77.99
GND on BOTTOM (solid shape): outline of 114 points within 116.67,87 122.09,87.72
GND on BOTTOM (solid shape): outline of 104 points within 29.22,78.26 31.51,82.21
GND on BOTTOM (solid shape): outline of 94 points within 274.36,37.2 283.57,46.5
GND on BOTTOM (solid shape): outline of 118 points within 24.69,78.36 30.4,80.86
GND on BOTTOM (solid shape): outline of 350 points within 117.73,74.16 123.13,77.28
GND on BOTTOM (solid shape): outline of 114 points within 282.47,54.9 289.41,62.31
GND on BOTTOM (solid shape): outline of 141 points within 150.54,70.54 153.28,75.53
GND on BOTTOM (solid shape): outline of 428 points within 221.11,23.92 236.42,39.34
GND on BOTTOM (solid shape): outline of 408 points within 244.77,28.8 260.52,39.83
GND on BOTTOM (solid shape): outline of 492 points within 278.09,54.57 284.01,61
GND on BOTTOM (solid shape): outline of 131 points within 55.24,106.69 75.03,110.54
GND on BOTTOM (solid shape): outline of 518 points within 122.7,72.03 126.33,77.31
GND on BOTTOM (solid shape): outline of 203 points within 18.98,21.29 35.02,24.21
GND on BOTTOM (solid shape): outline of 194 points within 149.48,87.94 157.32,94.19
GND on BOTTOM (solid shape): outline of 1280 points within 261.75,90.25 291.43,98.45
GND on BOTTOM (solid shape): outline of 179 points within 34.37,0.2 316.48,31.61
GND on BOTTOM (solid shape): outline of 1400 points within 124.92,86.98 137.36,92.71
GND on BOTTOM (solid shape): outline of 355 points within 0.2,47.03 316.48,114.1
GND on BOTTOM (solid shape): outline of 2132 points within 53.45,99.99 151.15,114.1
GND on BOTTOM (solid shape): outline of 2037 points within 108.69,67.85 118.1,84.39
GND on BOTTOM (solid shape): outline of 2088 points within 16.4,72.72 31.52,88.07
GND on BOTTOM (solid shape): outline of 5096 points within 125.93,67.85 153.73,87.72
GND on BOTTOM (solid shape): outline of 8805 points within 56.71,28.51 122.59,42.27
GND on BOTTOM (solid shape): outline of 9011 points within 134.08,28.7 199.73,41.84
GND on BOTTOM (solid shape): outline of 16894 points within 252.86,42.81 316.48,113.65
GND on IN1 (solid shape): 53.82,70.6 53.82,67.79 53.7,67.67 52.74,67.67 52.7,67.62 52.7,66.49 52.54,66.34 51.37,66.34 51.21,66.49 51.21,70.6 51.36,70.75 53.68,70.75
GND on IN1 (solid shape): 53.55,75.83 53.55,72.18 53.43,72.07 49.18,72.07 48.68,71.57 47.83,71.57 47.51,71.88 47.51,75.24 49.41,75.24 49.41,75.19 49.42,75.14 49.43,75.09 49.46,75.04 49.49,75 49.52,74.96 49.57,74.93 49.61,74.91 49.66,74.89 49.71,74.89 49.77,74.89 49.82,74.89 49.87,74.91 49.91,74.93 49.95,74.96 49.99,75 50.02,75.04 50.05,75.09 50.06,75.14 50.07,75.19 50.07,75.24 50.06,75.29 50.05,75.34 50.02,75.39 49.99,75.43 49.95,75.47 49.91,75.5 49.87,75.52 49.82,75.54 49.77,75.55 49.71,75.55 49.66,75.54 49.61,75.52 49.57,75.5 49.52,75.47 49.49,75.43 49.46,75.39 49.43,75.34 49.42,75.29 49.41,75.24 47.51,75.24 47.51,75.82 47.69,76 53.38,76
GND on IN1 (solid shape): 74.54,93.73 74.83,93.55 75.13,93.73 75.14,93.76 81.47,93.76 81.56,93.71 81.56,93.61 81.53,93.53 81.53,93.43 81.55,93.28 81.63,93.16 81.62,93.14 81.61,93.11 81.54,93 81.53,92.86 81.86,92.5 82.19,92.86 82.17,93 82.11,93.11 82.09,93.14 82.08,93.16 82.17,93.28 82.19,93.43 82.18,93.53 82.15,93.61 82.16,93.71 82.24,93.76 83.06,93.76 84.19,92.62 84.19,90.08 83.08,88.97 79.35,88.97 78.67,89.65 75.65,89.65 75.64,89.65 73.26,89.65 73.15,89.54 69.99,89.54 69.76,89.77 69.76,92.84 70.68,93.76 74.53,93.76
GND on IN1 (solid shape): 303.44,76.43 304.04,75.73 304.81,76.23 313.73,76.23 313.94,76.14 314.03,75.93 314.03,74.63 314.38,73.78 315.23,73.43 315.73,73.43 315.94,73.34 316.03,73.13 316.03,67.78 316.32,67 317.23,66.5 317.3,66.3 317.3,52.21 317.21,52.01 317,51.92 316.75,51.92 315.9,51.57 315.55,50.71 315.55,49.55 315.46,49.34 315.25,49.25 315.23,49.25 314.38,48.9 314.03,48.05 314.03,47.75 313.89,47.75 313.89,47.75 311.92,47.75 310.84,48.83 310.84,52.44 311.41,53.02 314.08,53.02 314.9,52.19 315.99,52.19 316.36,52.33 316.75,52.38 316.84,52.38 316.84,64.38 316.65,64.57 315.66,64.57 315.22,65.02 315.22,66.92 314.14,68 312.43,68 310.58,69.84 310.58,71.37 308.68,73.27 308.68,75.52 308.43,75.77 305.09,75.77 304.28,75.28 303.37,75.56 302.46,75.56 301.76,76.26 300.04,76.26 299.98,76.32 299.98,77.15 300.3,77.46 302.65,77.46 302.98,77.8 302.98,77.99 303.44,77.99
GND on IN1 (solid shape): 17.88,35.67 17.88,34.12 17.55,33.79 13.42,33.79 12.83,33.9 12.37,34.29 8.58,34.29 8.58,34.28 8.45,34.16 8.45,18.82 8.71,18.56 10.24,17.63 10.84,15.95 10.84,15.05 10.94,14.81 11.18,14.71 12.98,14.71 13.22,14.81 13.32,15.05 13.32,18.75 13.73,19.64 14.68,19.89 14.68,19.42 14.06,19.31 13.78,18.75 13.78,15.05 13.54,14.49 12.98,14.25 11.18,14.25 10.62,14.49 10.38,15.05 10.38,15.95 9.74,17.51 8.18,18.15 2.4,18.15 2.1,18.21 1.84,18.39 1.22,19.01 1.04,19.27 0.98,19.57 0.98,31.65 1.07,31.86 1.28,31.95 2.23,31.95 3.08,32.3 3.43,33.15 3.43,34.45 3.52,34.66 3.73,34.75 12.65,34.75 13.42,34.25 14.02,34.95 14.02,36.21 17.34,36.21
GND on IN1 (solid shape): outline of 641 points within 71.19,67.27 83.73,85.49
GND on IN1 (solid shape): outline of 170 points within 34.37,0.2 316.48,31.61
GND on IN1 (solid shape): outline of 329 points within 0.2,47.03 316.48,114.1
GND on IN2 (solid shape): 68.09,80.07 68.09,76.35 67.86,76.12 60,76.12 59.59,76.52 57.26,76.52 57.08,76.7 57.08,79.49 57.84,80.25 67.91,80.25
GND on IN2 (solid shape): 303.44,76.43 304.04,75.73 304.81,76.23 313.73,76.23 313.94,76.14 314.03,75.93 314.03,74.63 314.38,73.78 315.23,73.43 315.73,73.43 315.94,73.34 316.03,73.13 316.03,67.78 316.32,67 317.23,66.5 317.3,66.3 317.3,52.21 317.21,52.01 317,51.92 316.75,51.92 315.9,51.57 315.55,50.71 315.55,49.55 315.46,49.34 315.25,49.25 315.23,49.25 314.38,48.9 314.03,48.05 314.03,47.75 313.89,47.75 313.89,47.75 311.92,47.75 310.84,48.83 310.84,52.44 311.41,53.02 314.08,53.02 314.9,52.19 315.99,52.19 316.36,52.33 316.75,52.38 316.84,52.38 316.84,64.38 316.65,64.57 315.66,64.57 315.22,65.02 315.22,66.92 314.14,68 312.43,68 310.58,69.84 310.58,71.37 308.68,73.27 308.68,75.52 308.43,75.77 305.09,75.77 304.28,75.28 303.37,75.56 300.49,75.56 299.6,76.45 299.6,77.72 299.85,77.97 302.98,77.97 302.98,77.99 303.44,77.99
GND on IN2 (solid shape): 17.88,35.67 17.88,34.12 17.57,33.8 13.5,33.8 12.86,33.88 12.37,34.29 8.58,34.29 8.58,34.28 8.45,34.16 8.45,18.82 8.71,18.56 10.24,17.63 10.84,15.95 10.84,15.05 10.94,14.81 11.18,14.71 12.98,14.71 13.22,14.81 13.32,15.05 13.32,18.75 13.73,19.64 14.68,19.89 14.68,19.42 14.06,19.31 13.78,18.75 13.78,15.05 13.54,14.49 12.98,14.25 11.18,14.25 10.62,14.49 10.38,15.05 10.38,15.95 9.74,17.51 8.18,18.15 2.4,18.15 2.1,18.21 1.84,18.39 1.22,19.01 1.04,19.27 0.98,19.57 0.98,31.65 1.07,31.86 1.28,31.95 2.23,31.95 3.08,32.3 3.43,33.15 3.43,34.45 3.52,34.66 3.73,34.75 12.65,34.75 13.42,34.25 14.02,34.95 14.02,36.21 17.34,36.21
GND on IN2 (solid shape): outline of 502 points within 70.77,66.16 83.85,94
GND on IN2 (solid shape): outline of 170 points within 34.37,0.2 316.48,31.61
GND on IN2 (solid shape): outline of 337 points within 0.2,47.03 316.48,114.1
GND on IN3 (solid shape): 303.44,76.43 304.04,75.73 304.81,76.23 313.73,76.23 313.94,76.14 314.03,75.93 314.03,74.63 314.38,73.78 315.23,73.43 315.73,73.43 315.94,73.34 316.03,73.13 316.03,67.78 316.32,67 317.23,66.5 317.3,66.3 317.3,52.21 317.21,52.01 317,51.92 316.75,51.92 315.9,51.57 315.55,50.71 315.55,49.55 315.46,49.34 315.25,49.25 315.23,49.25 314.38,48.9 314.03,48.05 314.03,47.75 313.89,47.75 313.89,47.75 311.92,47.75 310.84,48.83 310.84,52.44 311.41,53.02 314.08,53.02 314.9,52.19 315.99,52.19 316.36,52.33 316.75,52.38 316.84,52.38 316.84,64.38 316.65,64.57 315.66,64.57 315.22,65.02 315.22,66.92 314.14,68 312.43,68 310.58,69.84 310.58,71.37 308.68,73.27 308.68,75.52 308.43,75.77 305.09,75.77 304.28,75.28 303.37,75.56 300.49,75.56 299.66,76.38 299.66,77.59 300.04,77.97 302.98,77.97 302.98,77.99 303.44,77.99
GND on IN3 (solid shape): 17.85,35.68 17.85,34.73 16.9,33.78 13.56,33.78 13.53,33.81 12.88,33.88 12.37,34.29 8.58,34.29 8.58,34.28 8.45,34.16 8.45,18.82 8.71,18.56 10.24,17.63 10.84,15.95 10.84,15.05 10.94,14.81 11.18,14.71 12.98,14.71 13.22,14.81 13.32,15.05 13.32,18.75 13.73,19.64 14.68,19.89 14.68,19.42 14.06,19.31 13.78,18.75 13.78,15.05 13.54,14.49 12.98,14.25 11.18,14.25 10.62,14.49 10.38,15.05 10.38,15.95 9.74,17.51 8.18,18.15 2.4,18.15 2.1,18.21 1.84,18.39 1.22,19.01 1.04,19.27 0.98,19.57 0.98,31.65 1.07,31.86 1.28,31.95 2.23,31.95 3.08,32.3 3.43,33.15 3.43,34.45 3.52,34.66 3.73,34.75 12.65,34.75 13.42,34.25 14.02,34.95 14.02,36.21 17.32,36.21
GND on IN3 (solid shape): outline of 470 points within 47.05,64.05 55.58,74.73
GND on IN3 (solid shape): outline of 699 points within 71.11,66.62 83.45,94.47
GND on IN3 (solid shape): outline of 170 points within 34.37,0.2 316.48,31.61
GND on IN3 (solid shape): outline of 331 points within 0.2,47.03 316.48,114.1
GND on IN4 (solid shape): 34.3,76.39 34.41,76.41 34.47,76.32 34.49,76.22 34.53,76.13 34.55,76.06 34.51,75.99 34.37,75.76 34.46,75.5 34.48,75.43 34.46,75.37 34.55,74.85 35.02,75.07 35.03,75.11 35.44,75.11 35.5,75.05 35.5,74.77 35.47,74.7 35.38,74.67 35.04,74.5 35.09,74.12 35.11,74.05 35.09,73.99 35.04,73.93 35.01,73.86 34.95,73.79 34.86,73.8 34.64,73.86 34.43,73.75 34.32,73.72 34.25,73.82 34.25,76.34
GND on IN4 (solid shape): 303.44,76.43 304.04,75.73 304.81,76.23 313.73,76.23 313.94,76.14 314.03,75.93 314.03,74.63 314.38,73.78 315.23,73.43 315.73,73.43 315.94,73.34 316.03,73.13 316.03,67.78 316.32,67 317.23,66.5 317.3,66.3 317.3,52.21 317.21,52.01 317,51.92 316.75,51.92 315.9,51.57 315.55,50.71 315.55,49.55 315.46,49.34 315.25,49.25 315.23,49.25 314.38,48.9 314.03,48.05 314.03,47.75 313.89,47.75 313.89,47.75 311.92,47.75 310.84,48.83 310.84,52.44 311.41,53.02 314.08,53.02 314.9,52.19 315.99,52.19 316.36,52.33 316.75,52.38 316.84,52.38 316.84,64.38 316.65,64.57 315.66,64.57 315.22,65.02 315.22,66.92 314.14,68 312.43,68 310.58,69.84 310.58,71.37 308.68,73.27 308.68,75.52 308.43,75.77 305.09,75.77 304.28,75.28 303.37,75.56 300.49,75.56 299.6,76.45 299.6,77.72 299.85,77.97 302.98,77.97 302.98,77.99 303.44,77.99
GND on IN4 (solid shape): 17.85,35.68 17.85,34.09 17.53,33.78 13.5,33.78 13.47,33.8 12.85,33.89 12.37,34.29 8.58,34.29 8.58,34.28 8.45,34.16 8.45,18.82 8.71,18.56 10.24,17.63 10.84,15.95 10.84,15.05 10.94,14.81 11.18,14.71 12.98,14.71 13.22,14.81 13.32,15.05 13.32,18.75 13.73,19.64 14.68,19.89 14.68,19.42 14.06,19.31 13.78,18.75 13.78,15.05 13.54,14.49 12.98,14.25 11.18,14.25 10.62,14.49 10.38,15.05 10.38,15.95 9.74,17.51 8.18,18.15 2.4,18.15 2.1,18.21 1.84,18.39 1.22,19.01 1.04,19.27 0.98,19.57 0.98,31.65 1.07,31.86 1.28,31.95 2.23,31.95 3.08,32.3 3.43,33.15 3.43,34.45 3.52,34.66 3.73,34.75 12.65,34.75 13.42,34.25 14.02,34.95 14.02,36.21 17.32,36.21
GND on IN4 (solid shape): outline of 332 points within 24.95,67.05 34.22,70.22
GND on IN4 (solid shape): outline of 1010 points within 5.59,71.18 22.4,91.18
GND on IN4 (solid shape): outline of 1188 points within 70.26,77.88 83.84,93.8
GND on IN4 (solid shape): outline of 170 points within 34.37,0.2 316.48,31.61
GND on IN4 (solid shape): outline of 329 points within 0.2,47.03 316.48,114.1
GND on GND1: outline of 367 points within 0.2,0.2 317.3,114.1
GND on IN1: 26.43,91.27 25.19,92.51 25.19,95.2 24.84,95.54 18.12,95.54 16.46,93.88 14.15,93.88 13.15,94.88 11.21,94.88 10.05,93.72 10.05,92.88 8.92,91.75 8.13,91.75 8.13,91.75 4.6,91.75 3.59,90.75 3.09,90.75 2.82,91.02 2.82,92.07 2.95,92.21 7.67,92.21 7.66,92.22 7.66,95.52 7.36,95.82 7.36,96.16 7.65,96.45 28.83,96.45 29.68,96.8 30.03,97.65 30.03,108.65 30.27,109.21 30.83,109.45 33.23,109.45 33.83,109.61 34.56,110.34 34.96,110.45 44.82,110.45 45.03,110.24 45.03,108.78 43.11,106.86 41.6,106.86 40.51,105.77 37.36,105.77 36.72,105.14 35.61,105.14 35.1,105.64 34.81,105.64 31.53,102.37 31.29,102.37 31.29,98.48 31.62,98.16 31.62,94.5 29.94,92.81 29.93,92.81 29.76,92.64 27.16,92.64 26.86,92.34 26.86,91.68 27.05,91.49 27.05,91.32 27,91.27
GND on IN1: 45.22,17.88 44.72,18.38 44.72,24.31 46.38,25.97 46.38,27.07 46.2,27.24 42.59,27.24 42.48,27.35 42.48,27.64 42.25,27.87 40.47,27.87 40.37,27.97 40.37,28.29 40.13,28.53 39.86,28.53 39.67,28.72 39.67,30.03 39.74,30.1 42.66,30.1 44.31,28.44 46.6,28.44 47.69,27.36 52.15,27.36 52.68,26.83 52.68,26.2 51.4,25.58 50.88,24.25 50.88,22.34 50.51,22.23 50.19,22 48.28,20.09 48.02,19.7 47.93,19.24 47.93,17.88
GND on IN1: 10.44,80.66 11.4,79.7 13.33,79.7 14.47,78.57 14.47,73.74 15.44,72.77 15.81,72.77 17.79,70.79 18.92,70.79 19.03,70.9 19.03,77.71 17.71,79.03 17.71,85.28 16.68,86.32 16.68,89.23 14.49,91.42 10.08,91.42 7.88,89.22 6.73,89.22 6.44,88.94 5.64,88.94 5.53,88.83 5.53,83.05 5.89,82.7 6.51,82.7 6.79,82.42 7.94,82.42 9.7,80.66
GND on IN1: 298.27,95.16 296.24,97.19 296.24,102.04 295.96,102.31 295.96,107.94 295.43,108.46 295.43,109.82 295.56,109.95 305.37,109.95 305.78,109.83 306.51,109.07 307.13,108.9 308.89,108.9 309.05,108.74 309.05,105.39 306.79,103.14 306.79,100.33 306.37,99.91 306.37,98.21 305,96.84 302.87,96.84 301.2,95.16
GND on GND2: outline of 367 points within 0.2,0.2 317.3,114.1
GND on IN2: 48.62,74.61 48.12,74.61 47.07,73.57 47.07,71.73 47.34,71.46 48.47,71.46 48.84,71.83 48.84,74.39
GND on IN2: 45.22,17.88 44.72,18.38 44.72,23.24 43.84,24.12 43.84,27.04 43.67,27.21 42.43,27.21 42.2,27.45 42.2,27.68 42.01,27.87 40.47,27.87 40.37,27.97 40.37,28.29 40.52,28.44 46.6,28.44 47.69,27.36 52.15,27.36 52.68,26.83 52.68,26.2 51.4,25.58 50.88,24.25 50.88,22.34 50.51,22.23 50.19,22 48.28,20.09 48.02,19.7 47.93,19.24 47.93,17.88
GND on IN2: 52.65,74.74 55.18,74.74 56.22,73.69 56.22,72.72 56.65,72.28 56.65,66.59 53.72,63.65 51.7,63.65 51.23,64.12 51.23,70.51 52.24,71.52 52.24,74.33
GND on IN3: 12.39,28.68 17,28.68 18.43,27.25 34.47,27.25 35.83,25.89 35.83,22.34 34.82,21.33 34.18,21.33 33.7,21.81 15,21.81 11.91,24.91 11.91,28.2
GND on VCC: 58.28,82.8 67.93,82.8 78.98,93.85 81.94,93.85 82.3,93.49 82.3,73.8 83.99,72.12 92.16,72.12 92.16,66.51 91.3,65.64 79.99,65.64 65.34,50.99 64.95,50.99 64.26,51.68 61.6,51.68 57.16,47.24 44.85,47.24 44.71,47.38 44.71,49.19 44.32,49.57 44.32,68.84
GND on VCC: 75.04,27.68 71.49,31.24 55.89,31.24 55.89,40.81 80.2,65.13 91.51,65.13 92.67,66.3 92.67,72.27 96.47,76.06 123.62,76.06 126.23,73.46 136.94,73.46 136.94,70.86 137.57,70.22 138.46,70.22 141.44,67.24 141.44,66.5 144.94,63.01 144.94,59.39 150.17,54.16 151.31,54.16 153.85,51.62 178.78,51.62 186.21,44.19 201.7,44.19 204.1,41.8 204.1,35.41 200.79,32.1 200.79,30.92 164.64,30.92 164.07,31.49 146.08,31.49 142.27,27.68
GND on VCC: 304.66,46.98 304.4,47.24 300.64,47.24 300.49,47.09 300.49,71.73 299.35,72.87 299.35,93.23 300.34,94.23 316.48,94.23 316.48,92.83 316.24,92.27 315.68,92.03 315.23,92.03 314.38,91.68 314.03,90.83 314.03,90.53 313.94,90.32 313.73,90.23 304.81,90.23 304.04,90.73 303.44,90.03 303.44,76.43 304.04,75.73 304.81,76.23 313.73,76.23 313.94,76.14 314.03,75.93 314.03,74.63 314.38,73.78 315.23,73.43 315.73,73.43 315.94,73.34 316.03,73.13 316.03,67.78 316.32,67 317.23,66.5 317.3,66.3 317.3,52.21 317.21,52.01 317,51.92 316.75,51.92 315.9,51.57 315.55,50.71 315.55,49.55 315.46,49.34 315.25,49.25 314.39,48.91 314.03,48.05 314.03,47.75 305.84,47.75 305.08,46.98
GND on VCC: outline of 96 points within 0.2,14.25 36.07,96.45
GND on IN4: 48.26,21.58 47.19,20.5 47.19,20.25 46.93,20 46.93,15.55 46.74,15.36 37.22,15.36 36.84,15.74 36.84,18.6 36.95,18.72 36.99,18.69 37.45,18.72 37.43,19.18 37.43,19.26 37.54,19.5 37.43,19.74 37.43,19.81 37.45,19.82 37.55,20.06 37.45,20.3 37.43,20.31 37.43,20.38 37.54,20.62 37.43,20.86 37.43,20.89 36.74,21.58 36.74,24.47 37.41,25.14 38.87,25.14 39.5,25.77 39.5,28.21 39.74,28.45 44.06,28.45 44.25,28.25 44.25,24.91 46.51,22.65 48.08,22.65 48.26,22.47
GND on IN4: 56.65,73.43 56.65,67.92 52.39,63.65 47.92,63.65 47.67,63.9 47.67,66.95 46.91,67.72 46.91,69.43 47.19,69.71 47.21,69.71 47.52,70.22 46.93,70.11 46.92,70.1 46.58,69.76 46.47,69.73 46.41,69.83 46.41,70.74 50.34,74.67 55.41,74.67
GND on GND3: outline of 369 points within 0.2,0.2 317.3,114.1 ; 1 cut-out
GNDA on TOP (solid shape): 292.87,35.11 292.87,33.46 292.67,33.26 291.98,33.26 291.98,33.76 291.6,33.76 291.6,33.26 291.23,33.26 291.03,33.46 291.03,35.11 291.22,35.3 292.68,35.3
GNDA on GND1: 301.48,32.12 300.74,32.87 300.74,34.26 299.96,35.05 298.67,35.05 296.58,33.01 289.33,33.01 289.08,32.76 284.46,32.76 283.98,33.25 283.98,34.41 282.81,34.41 282.71,34.52 282.71,35.66 282.56,35.81 282.38,35.81 281.82,36.37 281.82,37.79 281.94,37.9 283.59,37.9 283.85,38.17 283.85,42.72 283.59,42.98 282.32,42.98 282.26,43.04 282.26,43.95 282.84,44.52 282.84,46.67 282.96,46.8 282.96,49.85 283.01,49.9 283.67,49.9 283.85,49.73 283.85,49.55 284,49.4 286.03,49.4 286.29,49.14 287.43,49.14 287.66,48.91 287.66,43.45 288.83,42.28 293.99,42.28 298.31,46.6 299.11,46.6 299.37,46.35 300.47,46.35 300.85,46.73 304.19,46.73 304.45,46.48 305.29,46.48 306.05,47.24 314.03,47.24 314.38,46.39 315.23,46.05 316.18,46.05 316.39,45.96 316.48,45.75 316.48,42.6 316.39,42.39 316.18,42.3 303.61,42.3 302.91,41.7 303.41,40.93 303.41,35.47 302.91,34.7 303.61,34.1 316.18,34.1 316.39,34.01 316.48,33.8 316.48,32.12
GNDA on GND2: 301.48,32.12 300.74,32.87 300.74,34.26 299.96,35.05 298.67,35.05 296.58,33.01 289.33,33.01 289.08,32.76 284.46,32.76 283.98,33.25 283.98,34.41 282.81,34.41 282.71,34.52 282.71,35.66 282.56,35.81 282.38,35.81 281.82,36.37 281.82,37.79 281.94,37.9 283.59,37.9 283.85,38.17 283.85,42.72 283.59,42.98 282.32,42.98 282.26,43.04 282.26,43.95 282.84,44.52 282.84,46.67 282.96,46.8 282.96,49.85 283.01,49.9 283.67,49.9 283.85,49.73 283.85,49.55 284,49.4 286.03,49.4 286.29,49.14 287.43,49.14 287.66,48.91 287.66,43.45 288.83,42.28 293.99,42.28 298.31,46.6 299.11,46.6 299.37,46.35 300.47,46.35 300.85,46.73 304.19,46.73 304.45,46.48 305.29,46.48 306.05,47.24 314.03,47.24 314.38,46.39 315.23,46.05 316.18,46.05 316.39,45.96 316.48,45.75 316.48,42.6 316.39,42.39 316.18,42.3 303.61,42.3 302.91,41.7 303.41,40.93 303.41,35.47 302.91,34.7 303.61,34.1 316.18,34.1 316.39,34.01 316.48,33.8 316.48,32.12
GNDA on VCC: outline of 92 points within 281.82,32.1 316.48,49.9
GNDA on GND3: 301.48,32.12 300.74,32.87 300.74,34.26 299.96,35.05 298.67,35.05 296.58,33.01 289.33,33.01 289.08,32.76 284.46,32.76 283.98,33.25 283.98,34.41 282.81,34.41 282.71,34.52 282.71,35.66 282.56,35.81 282.38,35.81 281.82,36.37 281.82,37.79 281.94,37.9 283.59,37.9 283.85,38.17 283.85,42.72 283.59,42.98 282.32,42.98 282.26,43.04 282.26,43.95 282.84,44.52 282.84,46.67 282.96,46.8 282.96,49.85 283.01,49.9 283.67,49.9 283.85,49.73 283.85,49.55 284,49.4 286.03,49.4 286.29,49.14 287.43,49.14 287.66,48.91 287.66,43.45 288.83,42.28 293.99,42.28 298.31,46.6 299.11,46.6 299.37,46.35 300.47,46.35 300.85,46.73 304.19,46.73 304.45,46.48 305.29,46.48 306.05,47.24 314.03,47.24 314.38,46.39 315.23,46.05 316.18,46.05 316.39,45.96 316.48,45.75 316.48,42.6 316.39,42.39 316.18,42.3 303.61,42.3 302.91,41.7 303.41,40.93 303.41,35.47 302.91,34.7 303.61,34.1 316.18,34.1 316.39,34.01 316.48,33.8 316.48,32.12
VCC1_IA on TOP (solid shape): 78.55,87.45 78.55,86.21 78.91,85.84 78.91,85.65 78.82,85.57 78.72,85.57 78.67,85.56 78.63,85.55 78.57,85.56 78.16,85.56 78.15,85.57 77.97,85.57 77.93,85.54 77.9,85.52 77.86,85.5 77.68,85.5 77.52,85.67 77.52,87.35 77.7,87.53 78.46,87.53
VCC1_IA on BOTTOM (solid shape): 78.31,87.94 78.31,87.33 78.35,87.29 78.35,86.91 78.64,86.62 78.64,86.13 78.86,85.91 78.86,85.64 78.79,85.57 78.67,85.57 78.62,85.54 78.53,85.53 78.46,85.5 78.2,85.5 78.05,85.54 77.89,85.5 77.68,85.5 77.56,85.62 77.56,85.8 77.84,86.09 77.84,86.62 77.98,86.76 77.98,87.96 78.05,88.03 78.22,88.03
VCC2_IA on BOTTOM (solid shape): 75.48,78.82 75.48,78.33 75.55,78.26 76.35,78.26 76.47,78.39 76.69,78.39 76.82,78.52 77.58,78.52 77.65,78.45 77.65,78.26 77.58,78.2 76.82,78.2 76.44,77.82 76.44,77.68 76.24,77.48 76.24,77.45 76.21,77.45 75.55,77.45 75.29,77.7 75.29,77.95 75.08,78.16 74.49,78.16 74.43,78.23 74.43,78.86 74.49,78.92 75.38,78.92
VCC_1.05VALWP on TOP (solid shape): 193.43,111.14 193.43,109.19 193.34,109.1 192.75,109.1 192.66,109.18 192.66,111.22 192.77,111.33 193.24,111.33
VCC_GT on BOTTOM (solid shape): 74.17,69.21 74.17,69.02 74.1,68.94 73.57,68.94 72.35,67.72 72.03,67.72 71.83,67.52 70.58,67.52 70.52,67.58 70.52,68.49 70.67,68.63 71.68,68.63 71.93,68.89 72.92,68.89 72.98,68.95 72.99,68.95 73.06,69.02 73.27,69.02 73.53,69.27 74.11,69.27
VCCHDA on IN4: 152.41,77.4 151.96,77.84 148.65,77.84 148.55,77.94 148.55,77.95 148.48,78.05 148.39,78.11 148.36,78.14 148.26,78.16 148.15,78.15 147.68,78.15 147.59,78.16 147.5,78.15 146.07,78.15 145.99,78.13 145.93,78.09 145.9,78.07 145.86,78.08 145.78,78.13 145.69,78.15 145.68,78.16 145.52,78.14 145.39,78.05 145.32,78.02 144.99,78.16 144.67,78.02 144.34,78.16 144.02,78.02 143.69,78.16 143.37,78.02 143.04,78.16 142.72,78.02 142.64,78.05 142.55,78.12 142.44,78.15 142.42,78.16 142.18,78.39 142.18,78.92 142.42,79.16 142.46,79.13 148.22,79.13 148.45,79.37 148.7,79.37 148.94,79.26 149.17,79.37 149.32,79.37 149.59,79.23 149.85,79.37 149.96,79.37 150.22,79.23 150.48,79.37 150.62,79.37 150.86,79.26 151.09,79.37 151.23,79.37 151.49,79.23 151.75,79.37 155.14,79.37 155.52,78.99 165.87,78.99 166.25,78.61 166.25,78.29 165.8,77.84 154.95,77.84 154.5,77.4
VDDP_CHG on TOP (solid shape): 53.05,57.99 53.05,57.47 52.58,57 52.58,56.33 52.47,56.22 51.61,56.22 51.38,56.45 51.22,56.45 50.97,56.56 50.72,56.45 50.23,56.45 50.03,56.24 50.03,56.15 49.42,55.54 49.42,55.21 49.36,55.15 48.59,55.15 48.52,55.22 48.52,55.3 48.58,55.37 48.77,55.37 48.85,55.37 49.53,56.05 49.53,56.38 50.43,57.27 50.84,57.27 51.19,57.62 52.03,57.62 52.45,58.04 53,58.04
VIN_1.8VALW on BOTTOM (solid shape): 184.09,106.67 184.54,106.67 184.79,106.42 184.79,105.47 184.98,105.28 185.4,105.28 185.59,105.09 185.59,104.5 185.55,104.46 184.28,104.46 184.03,104.72 182.12,104.72 182,104.84 182,105.87 181.76,106.1 181.11,106.1 180.85,106.36 180.85,106.78 181.06,106.99 183.78,106.99
VIN_1V_PRIM_CORE on TOP (solid shape): 176.66,28.51 176.66,28 176.85,27.81 178.89,27.81 179.01,27.93 182.44,27.93 182.57,27.81 182.57,26.47 182.38,26.28 181.22,26.28 181.13,26.37 181.13,26.65 180.99,26.79 179.07,26.79 178.56,26.28 176.92,26.28 176.66,26.03 176.66,25.46 176.47,25.27 175.77,25.27 175.71,25.33 175.71,26.85 176,27.15 176,28.52 176.12,28.63 176.54,28.63
VIN_1VS_VCCIO on TOP (solid shape): 91.64,29.33 91.64,26.54 91.57,26.47 91,26.47 90.81,26.66 90.81,26.88 90.65,27.04 86.05,27.04 85.92,27.17 85.92,28.31 86.36,28.75 87.12,28.75 87.3,28.57 89.88,28.57 90.71,29.39 91.57,29.39
VIN_2.5V_MEM on TOP (solid shape): 124.21,28.96 124.21,27.74 124.66,27.3 124.66,26.54 124.4,26.28 123.58,26.28 123.39,26.47 123.39,26.98 123.01,27.36 122.75,27.36 122.69,27.43 122.69,29.01 122.75,29.08 124.1,29.08
+BL_PWR_SRC on TOP (solid shape): 65.61,111.51 65.61,109.86 66.12,109.35 66.12,107.11 66.81,106.42 66.81,103.68 67.43,103.05 68.69,103.05 69.02,102.72 69.02,102.33 69.33,102.02 69.83,102.02 70.83,101.02 70.83,99.56 70.65,99.38 68.48,99.38 68.32,99.55 68.32,100.86 67.97,101.2 64.79,101.2 64.7,101.29 64.7,105.17 64.78,105.25 64.86,105.67 64.49,105.88 64.41,105.91 64.38,105.98 64.38,108.22 64.04,108.56 64.04,108.56 63.99,108.61 63.99,109.99 63.87,110.1 63.51,110.1 63.31,110.3 63.31,111.21 63.8,111.69 65.43,111.69
+BL_PWR_SRC on BOTTOM (solid shape): 90.19,101.87 90.19,100.55 89.98,100.34 87.24,100.34 86.73,99.84 86.73,98.33 86.57,98.17 83.86,98.17 83.54,98.49 83.54,101.27 84.35,102.08 89.98,102.08
+BL_PWR_SRC on BOTTOM (solid shape): 64.78,111.61 64.78,110.9 65.05,110.63 65.05,109.99 64.96,109.89 63.45,109.89 63.34,110 63.34,110.66 63.67,110.99 63.67,111.6 63.74,111.67 64.72,111.67
+BL_PWR_SRC on IN3 (solid shape): 70.84,101.79 70.84,100.37 70.16,99.69 68.4,99.69 68.14,99.94 68.14,101.78 68.46,102.1 70.53,102.1
+BL_PWR_SRC on IN3 (solid shape): 83.77,99.56 86.11,99.56 86.3,99.37 86.3,98.75 86.18,98.63 82.11,98.63 81.97,98.77 81.97,99.63 82.12,99.78 83.56,99.78
+BL_PWR_SRC_P on BOTTOM (solid shape): 92.78,101.77 92.78,96.27 92.61,96.1 91.2,96.1 91.06,96.25 91.06,100.01 90.7,100.36 90.7,101.81 90.86,101.97 92.57,101.97
+EDP_VDD on BOTTOM (solid shape): 104.74,100.98 105.67,100.98 106.13,100.53 106.74,100.53 107,100.26 107,99.99 107.5,99.5 107.77,99.5 107.83,99.43 107.83,98.41 107.72,98.3 106.17,98.3 105.67,98.8 104.19,98.8 103.56,99.42 103.56,100.63 103.91,100.99 104.56,100.99 104.56,101.57 104.74,101.57
+LCDVDD on TOP (solid shape): 86.38,104.95 86.38,104.94 86.51,104.81 86.51,103.47 86.38,103.34 86.38,102.12 86.24,101.97 85.4,101.97 83.99,103.38 83.99,105.07 84.31,105.39 85.93,105.39
+LCDVDD on TOP (solid shape): 75.17,111.49 75.17,110.98 75.06,110.86 69.57,110.86 69.27,110.57 69.27,110.27 68.87,109.87 68.87,109.18 68.78,109.09 68.17,109.09 68.1,109.17 68.1,109.76 67.7,110.16 67.7,110.22 67.69,110.26 67.69,110.82 68.44,111.57 75.09,111.57
+LCDVDD on BOTTOM (solid shape): 89.12,103.79 88.07,102.74 84.4,102.74 84.04,103.1 84.04,104.35 84.27,104.58 87.38,104.58 87.77,104.96 89.12,104.96
+LCDVDD on BOTTOM (solid shape): 108.1,104.51 108.1,100.94 107.96,100.8 106.05,100.8 105.73,101.11 104.9,101.11 104.9,101.7 104.41,101.7 104.41,101.11 104.01,101.11 103.59,101.54 102.15,101.54 102.01,101.68 102.01,104.56 102.32,104.86 107.74,104.86
+LCDVDD on BOTTOM (solid shape): 69.55,111.6 69.55,110.85 69.27,110.57 69.27,109.99 69.23,109.95 67.9,109.95 67.75,110.11 67.75,110.27 67.69,110.33 67.69,110.52 67.81,110.65 68.49,110.65 68.9,111.07 68.9,111.63 68.97,111.69 69.46,111.69
+LCDVDD on IN3 (solid shape): 86.11,104.58 86.11,103.51 85.94,103.33 83.6,103.33 83.37,103.57 83.37,105.15 83.53,105.32 85.38,105.32
+LCDVDD on IN3 (solid shape): 69.62,110.54 69.64,110.43 69.57,110.36 69.31,109.95 69.75,109.73 69.84,109.72 69.89,109.64 69.89,108.61 69.72,108.45 68.11,108.45 67.69,108.87 67.69,110.12 67.7,110.19 67.69,110.26 67.69,110.55 67.86,110.72 69.43,110.72
+RREF on TOP (solid shape): 291.09,64.89 291.09,64.1 291.01,64.03 290.03,64.03 289.28,63.27 289.28,61.95 289.22,61.88 288.72,61.88 288.68,61.93 288.68,63.51 289.89,64.73 290.71,64.73 290.92,64.93 291.04,64.93
+RTC_CELL_PCH on TOP (solid shape): 273.34,68.07 273.34,67.49 273.39,67.44 273.98,67.44 274.04,67.37 274.04,66.94 274,66.9 273.14,66.9 272.99,66.74 272.33,66.74 272.26,66.82 272.26,68.04 272.34,68.12 273.29,68.12
+RTC_CELL_PCH on IN3 (solid shape): 142.12,77.62 142.13,77.6 142.17,77.56 142.21,77.53 142.26,77.5 142.31,77.48 142.36,77.47 142.42,77.47 142.47,77.48 142.52,77.5 142.55,77.51 142.6,77.45 142.6,76.62 142.44,76.45 142.39,76.46 142.35,76.45 142.32,76.45 141.81,76.45 141.78,76.45 141.74,76.46 141.7,76.45 141.67,76.45 140.86,76.45 140.78,76.53 140.78,76.99 141.41,76.99 141.41,76.94 141.42,76.89 141.43,76.84 141.46,76.79 141.49,76.75 141.53,76.71 141.57,76.68 141.61,76.66 141.66,76.64 141.71,76.63 141.77,76.63 141.82,76.64 141.87,76.66 141.91,76.68 141.96,76.71 141.99,76.75 142.02,76.79 142.05,76.84 142.06,76.89 142.07,76.94 142.07,76.99 142.06,77.04 142.05,77.09 142.02,77.14 141.99,77.18 141.96,77.22 141.91,77.25 141.87,77.27 141.82,77.29 141.77,77.29 141.71,77.29 141.66,77.29 141.61,77.27 141.57,77.25 141.53,77.22 141.49,77.18 141.46,77.14 141.43,77.09 141.42,77.04 141.41,76.99 140.78,76.99 140.78,77.51 140.89,77.62
+RTC_CELL_VBAT on TOP (solid shape): 270.64,75.3 270.64,74.54 270.39,74.29 269.69,74.29 269.61,74.2 268.79,74.2 268.72,74.28 268.72,74.7 269.44,75.43 270.52,75.43
+SDREG2 on TOP (solid shape): 295.95,69.37 295.95,68.62 295.91,68.61 295.84,68.59 295.77,68.56 295.64,68.39 295.64,68.17 295.64,68.17 295.64,68.12 295.56,68.05 295.02,68.05 294.81,67.84 294.04,67.84 293.99,67.89 293.99,68.08 295.3,69.39 295.92,69.39
+TBT_SVR_IND on BOTTOM (solid shape): 21.5,93.14 21.5,89.66 22.07,89.08 22.07,87.64 22.11,87.6 22.11,85.03 22.76,84.38 22.76,84.14 22.76,84.14 22.76,83.97 22.93,83.81 22.93,82.98 23.19,82.72 23.19,82.36 23.13,82.3 22.99,82.27 22.94,82.23 22.86,82.15 22.86,81.99 22.81,81.94 22.59,81.94 22.51,82.01 22.51,82.19 22.43,82.27 22.43,82.72 22.15,83 22.15,83.38 21,84.54 21,87.76 20.21,88.54 20.21,89.85 19.88,90.18 19.17,90.18 19.11,90.24 19.11,93.95 19.12,93.96 20.67,93.96
+TS_PWR on TOP (solid shape): 78.02,110.56 78.02,109.32 76.29,107.59 76.29,106.86 76.18,106.74 75.13,106.74 75,106.87 75,108.05 76.89,109.93 76.89,110.6 76.98,110.69 77.89,110.69
+TS_PWR on TOP (solid shape): 57.54,111.48 57.54,110.61 57.22,110.3 56.9,110.3 56.67,110.06 55.96,110.06 55.26,110.76 55.18,110.76 54.4,110.76 54.2,110.96 54.2,111.37 54.27,111.44 54.78,111.44 54.92,111.58 57.43,111.58
+TS_PWR on BOTTOM (solid shape): 57.54,111.69 57.54,110.54 57.12,110.12 56.38,110.12 56.38,110.13 55.85,110.13 55.69,110.28 55.69,110.48 56.27,111.06 56.27,111.66 56.4,111.78 57.45,111.78
+TS_PWR on IN3 (solid shape): 76.84,107.5 76.84,105.71 76.68,105.55 74.76,105.55 74.71,105.59 74.71,106.74 74.8,106.96 74.72,107.19 74.71,107.2 74.71,107.29 75.2,107.78 76.56,107.78
+TS_PWR on IN3 (solid shape): 57.1,110.74 57.1,110.05 57.03,109.84 57.1,109.63 57.1,108.71 56.79,108.39 55.58,108.39 55.42,108.55 55.42,110.35 55.43,110.42 55.42,110.48 55.42,110.72 55.59,110.89 56.96,110.89
+TS_PWR_QV8 on TOP (solid shape): 79.29,110.58 79.29,109.28 78.27,108.27 78.07,108.27 77.94,108.4 77.94,109.08 78.25,109.38 78.25,110.55 78.37,110.68 79.2,110.68
+USB_EX2_PWR on BOTTOM (solid shape): 26.32,42.44 27,42.44 27.22,42.22 27.22,39.58 27.05,39.41 26.05,39.41 25.89,39.52 25.69,39.51 25.6,39.52 25.56,39.59 25.18,39.88 24.9,39.5 24.88,39.42 24.8,39.38 21.96,39.38 21.71,39.64 21.71,42.1 21.89,42.28 24.18,42.28 24.23,42.29 24.63,42.69 26.08,42.69
+USB_EX2_PWR on IN2: 20.59,38.6 19.61,39.57 19.61,41.81 17.55,43.87 16.26,43.87 15.75,44.38 15.75,46.16 16.71,47.11 17.47,47.11 17.85,47.49 25.72,47.49 27.34,45.87 27.34,40.73 27.12,40.51 24.58,40.51 22.67,38.6
+UZ12_TPM on TOP (solid shape): 180.16,84.89 180.16,83.62 179.97,83.43 178.82,83.43 178.76,83.5 178.76,84.83 178.89,84.96 180.09,84.96
+VHDMI_VCC on TOP (solid shape): 13.72,68.95 15.44,68.95 15.56,68.83 15.56,68.57 14.64,67.65 14.64,59.97 14.1,59.43 13.28,59.43 12.96,59.75 12.96,59.94 13.21,60.19 13.47,60.19 13.79,60.51 13.79,67.94 13.4,68.32 12.9,68.32 12.71,68.51 12.71,68.95 12.96,69.21 13.47,69.21
+VHDMI_VCC on BOTTOM (solid shape): 21.41,48.19 21.41,48 21.6,47.81 22.57,47.81 22.78,47.6 22.78,46.68 22.64,46.54 20.2,46.54 20.06,46.68 20.06,48.17 20.15,48.27 21.33,48.27
+VHDMI_VCC on IN2: 19.23,47.68 15.31,51.6 15.31,56.3 13.85,57.76 13.83,57.76 12.07,59.52 12.07,68.86 12.47,69.26 13.79,69.26 14.42,68.63 14.42,60.98 15.07,60.33 17.79,57.61 17.79,52.91 18.74,51.96 18.74,51.96 20.35,50.35 21.41,50.35 21.91,49.84 21.91,47.81 21.79,47.68
BL_PWR_SRC_ON on BOTTOM (solid shape): 96.06,101.12 96.06,99.68 95.93,99.55 94.16,99.55 93.95,99.34 93.95,98.55 93.81,98.41 93.23,98.41 93.11,98.54 93.11,99.91 93.73,100.53 94.18,100.53 94.51,100.86 94.51,101.07 94.66,101.22 95.97,101.22
BOOT1_CHG on TOP (solid shape): 47.25,57.08 47.25,55.49 47.19,55.43 47.06,55.43 47,55.49 47,56.83 46.68,57.14 45.41,57.14 45.35,57.21 45.35,57.97 45.41,58.03 46.3,58.03
BOOT2_CHG on TOP (solid shape): 51.76,54.54 51.76,53.91 51.63,53.78 50.24,53.78 50,53.54 48.58,53.54 48.53,53.59 48.53,53.71 48.58,53.77 49.84,53.77 50.71,54.64 51.66,54.64
BS_DDR on TOP (solid shape): 219.1,32.18 219.1,32.01 220.2,30.91 220.77,30.91 221.04,30.64 221.04,30.36 220.98,30.3 220,30.3 219.07,31.22 218.98,31.22 218.98,31.23 218.41,31.23 218.33,31.31 218.33,32.18 218.4,32.25 219.03,32.25
BS_DDR_R on TOP (solid shape): 217.66,32.19 217.66,31.3 217.67,31.3 217.67,29.67 217.56,29.57 216.97,29.57 216.85,29.68 216.85,31.81 216.86,31.81 216.86,32.12 216.99,32.25 217.6,32.25
BST1_CHG_R on TOP (solid shape): 44.77,59.18 44.77,57.21 44.65,57.08 43.95,57.08 43.88,57.14 43.88,59.11 44.01,59.24 44.71,59.24
BST1_IA on BOTTOM (solid shape): 77.29,87.94 77.29,87.34 77.2,87.25 77.2,87.02 76.74,86.56 76.74,86.1 76.69,86.05 75.85,86.05 75.8,86.09 75.8,86.71 75.83,86.73 75.99,86.73 76.33,87.07 76.34,87.07 76.39,87.12 76.71,87.12 76.97,87.38 76.97,87.93 77.07,88.02 77.21,88.02
BST1_IA_R on BOTTOM (solid shape): 76.85,85.33 76.85,84.71 76.78,84.64 74.62,84.64 74.56,84.7 74.56,85.34 74.62,85.4 76.78,85.4
BST2_CHG_R on TOP (solid shape): 53.24,55.86 53.24,53.94 53.12,53.82 52.16,53.82 52.05,53.93 52.05,54.76 52.4,55.11 52.4,55.87 52.47,55.94 53.15,55.94
BST2_IA on BOTTOM (solid shape): 76.38,80.11 76.38,79.72 76.57,79.53 77.58,79.53 77.65,79.47 77.65,79.28 77.58,79.22 75.68,79.22 75.55,79.34 75.55,80.11 75.64,80.19 76.29,80.19
BST2_IA_R on BOTTOM (solid shape): 75.04,81.26 75.04,79.22 74.98,79.15 74.32,79.15 74.26,79.22 74.26,81.24 74.34,81.32 74.99,81.32
BST_1.05VALWP on TOP (solid shape): 190.25,109.09 191.14,109.09 191.2,109.02 191.2,108.9 191.12,108.81 189.85,108.81 189.74,108.71 189.05,108.71 189,108.75 189,109.62 189.05,109.66 189.68,109.66
BST_1.05VALWP_R on TOP (solid shape): 188.31,109.62 188.31,108.76 188.26,108.71 186.58,108.71 186.47,108.82 186.47,109.54 186.58,109.66 188.28,109.66
BST_3V on TOP (solid shape): 192.16,101.03 192.16,100.46 192.15,100.45 192.15,99.02 191.65,98.52 191.51,98.52 191.45,98.58 191.45,101.06 191.49,101.09 192.09,101.09
BST_3V_R on TOP (solid shape): 194.63,100.9 194.63,100.07 194.51,99.94 193,99.94 192.94,100 192.94,100.99 193.04,101.09 194.44,101.09
BST_5V on TOP (solid shape): 43.68,27.04 43.68,25.06 43.56,24.94 42.7,24.94 42.65,24.99 42.65,25.62 42.72,25.68 43.05,25.68 43.41,26.05 43.41,27.03 43.49,27.11 43.62,27.11
BST_5V_R on TOP (solid shape): 42.61,24.64 42.61,24.33 42.69,24.26 43.59,24.26 43.63,24.22 43.63,23.6 43.59,23.56 42.64,23.56 42.49,23.71 42.49,23.85 42.34,24.01 41.75,24.01 41.71,24.05 41.71,24.64 41.79,24.72 42.53,24.72
BST_GT on BOTTOM (solid shape): 72.9,70.78 72.9,70.48 73.09,70.29 74.09,70.29 74.17,70.21 74.17,70 74.08,69.9 72.16,69.9 72.08,69.98 72.08,70.73 72.18,70.83 72.86,70.83
BST_GT_R on BOTTOM (solid shape): 71.57,71.98 71.57,69.96 71.48,69.87 70.71,69.87 70.62,69.96 70.62,71.94 70.72,72.04 71.51,72.04
BST_SA on TOP (solid shape): 93.54,97.93 93.54,97.15 93.25,96.86 92.81,96.86 92.62,96.67 92.62,95.99 92.57,95.94 92.4,95.94 92.34,96.01 92.34,97.3 93.05,98.01 93.46,98.01
DCIN_CHG on TOP (solid shape): 44.46,60.45 44.46,59.56 44.33,59.43 43.88,59.43 43.25,58.8 43.24,58.79 43.07,58.58 43.19,58.34 43.19,57.91 42.55,57.27 42.17,57.27 42.04,57.14 41,57.14 40.94,57.21 40.94,57.97 41.06,58.1 41.98,58.1 42.63,58.75 42.63,60.27 42.87,60.51 44.39,60.51
INT_SPK_L+ on TOP (solid shape): 281.75,46.67 281.75,45.89 281.99,45.65 281.99,44.5 281.65,44.16 281.65,43.1 281.58,43.03 281.45,43.03 281.37,43.12 281.37,44.27 281.53,44.43 281.53,45.58 281.09,46.02 281.09,46.67 281.14,46.71 281.7,46.71
INT_SPK_L+ on BOTTOM (solid shape): 303.4,23.32 303.4,21.58 304.27,20.7 304.27,20.36 304.14,20.22 303.22,20.22 302.12,21.32 302.12,23.2 302.37,23.44 303.28,23.44
INT_SPK_L+ on IN4 (solid shape): 303.35,23.43 303.35,22.41 303.16,22.22 301.82,22.22 301.5,22.54 301.5,23.04 301.95,23.49 303.28,23.49
INT_SPK_L+ on IN4 (solid shape): 282.58,46.5 282.58,44.7 282.42,44.54 281.65,44.54 281.53,44.65 281.53,45.54 281.56,45.56 281.56,46.47 281.69,46.6 282.48,46.6
INT_SPK_L- on TOP (solid shape): 280.87,46.67 280.87,46.06 281.41,45.52 281.41,44.47 281.24,44.31 281.24,43.09 281.18,43.03 281.05,43.03 280.98,43.11 280.98,44.66 280.96,44.68 280.96,45.27 280.23,45.99 280.23,46.67 280.3,46.73 280.8,46.73
INT_SPK_L- on BOTTOM (solid shape): 302.55,25.01 302.55,24.11 302.4,23.96 302.12,23.96 301.49,23.32 301.49,22.97 301.49,20.55 301.29,20.35 301.29,20.35 300.56,20.35 300.39,20.52 300.39,23.73 301.77,25.11 302.45,25.11
INT_SPK_L- on IN4 (solid shape): 302.58,24.95 302.58,24.16 302.46,24.03 301.28,24.03 300.81,24.5 300.81,24.89 301.15,25.24 302.3,25.24
INT_SPK_L- on IN4 (solid shape): 281.4,46.17 281.4,44.65 281.28,44.54 280.97,44.54 280.84,44.67 280.84,45.3 280.23,45.9 280.23,46.22 280.75,46.74 280.83,46.74
INT_SPK_R+ on TOP (solid shape): 279.15,46.67 279.15,45.98 279.42,45.71 279.42,45.59 280.44,44.56 280.44,43.1 280.38,43.03 280.26,43.03 280.2,43.09 280.2,44.3 279.75,44.75 279.55,44.75 278.45,45.84 278.45,46.67 278.52,46.73 279.09,46.73
INT_SPK_R+ on BOTTOM (solid shape): 299.84,23.44 299.84,20.18 299.81,20.14 298.98,20.14 298.65,20.46 298.65,22.34 298.64,22.35 298.64,22.74 298.35,23.02 298.35,23.65 298.44,23.74 299.54,23.74
INT_SPK_R+ on IN2 (solid shape): 279.91,45.08 279.91,44.82 279.72,44.63 278.52,44.63 278.39,44.76 278.39,45.4 278.77,45.78 279.22,45.78
INT_SPK_R+ on IN2 (solid shape): 299.91,24.89 299.91,23.34 299.55,22.98 298.49,22.98 298.36,23.12 298.36,24.11 298.92,24.67 298.92,25.01 299.79,25.01
INT_SPK_R- on TOP (solid shape): 280.04,46.67 280.04,45.95 280.84,45.15 280.84,43.1 280.78,43.04 280.66,43.04 280.6,43.1 280.6,44.47 280.6,44.62 279.64,45.58 279.64,45.71 279.34,46.01 279.34,46.67 279.41,46.73 279.98,46.73
INT_SPK_R- on BOTTOM (solid shape): 297.84,23.53 297.84,23.07 297.69,22.92 297.33,22.92 297.19,22.78 297.19,20.65 296.89,20.36 296.24,20.36 296.07,20.52 296.07,23.41 296.35,23.68 297.69,23.68
INT_SPK_R- on IN2 (solid shape): 297.85,24.92 297.85,23.14 297.69,22.98 296.91,22.98 296.81,23.08 296.81,24.7 297.12,25.01 297.76,25.01
INT_SPK_R- on IN2 (solid shape): 280.16,46.74 280.16,46.62 280.74,46.03 280.74,45.02 280.55,44.82 280.42,44.82 279.41,45.84 279.41,46.98 279.91,46.98
INT_SPKR_L+ on BOTTOM (solid shape): 302.24,10.38 302.24,7.34 302.06,7.16 301.14,7.16 300.98,7.32 300.98,9.62 301.84,10.49 302.14,10.49
INT_SPKR_L+ on BOTTOM (solid shape): 304.23,19.75 304.23,19.1 303.73,18.6 303.73,17.12 303.66,17.05 302.66,17.05 302.56,17.15 302.56,18.89 303.54,19.87 304.11,19.87
INT_SPKR_L- on BOTTOM (solid shape): 300.91,10.37 300.91,10.03 300.67,9.78 300.67,7.41 300.39,7.14 299.94,7.14 299.62,7.45 299.62,10.25 299.84,10.46 300.83,10.46
INT_SPKR_L- on BOTTOM (solid shape): 301.82,19.68 301.82,19.17 302.08,18.92 302.08,17.35 301.99,17.27 301.09,17.27 301,17.36 301,18.92 300.49,19.42 300.49,19.93 300.55,20 301.5,20
INT_SPKR_R+ on BOTTOM (solid shape): 299.3,10.28 299.3,9.06 299.38,8.97 299.38,7.4 299.11,7.12 298.65,7.12 298.34,7.44 298.34,9.06 298.17,9.23 298.17,10.3 298.32,10.45 299.13,10.45
INT_SPKR_R+ on BOTTOM (solid shape): 299.85,19.71 299.85,19.23 299.41,18.79 299.41,17.48 299.33,17.41 298.4,17.41 298.27,17.54 298.27,18.98 298.65,19.36 298.65,19.55 298.85,19.76 299.81,19.76
INT_SPKR_R- on BOTTOM (solid shape): 297.74,19.07 297.74,17.6 297.58,17.45 296.8,17.45 296.54,17.7 296.54,18.8 296.14,19.2 296.14,19.92 296.22,20 296.81,20
INT_SPKR_R- on BOTTOM (solid shape): 297.9,10.22 297.9,9.19 298.03,9.05 298.03,7.36 297.82,7.15 297.37,7.15 297.06,7.46 297.06,8.9 296.7,9.26 296.7,10.36 296.81,10.47 297.64,10.47
LDO_3V on TOP (solid shape): 192.98,96.83 192.98,96.48 193.27,96.2 193.87,96.2 194,96.07 194,95.5 193.81,95.31 193.81,93.96 193.7,93.85 192.89,93.85 192.78,93.97 192.78,95.32 192.09,96.01 192.09,96.13 191.75,96.47 191.75,97.01 191.85,97.11 192.7,97.11
LG1_CHG on TOP (solid shape): 49.4,56.33 49.4,56.07 48.84,55.51 48.46,55.51 48.41,55.45 48.28,55.45 48.22,55.51 48.22,56.3 48.27,56.35 48.84,56.35 48.92,56.43 49.3,56.43
LG1_CHG on BOTTOM (solid shape): 55.3,67.36 55.3,66.63 55.01,66.34 53.19,66.34 53.1,66.43 53.1,67 53.17,67.06 53.9,67.06 54.34,67.5 55.16,67.5
LG1_CHG on IN1 (solid shape): 55.28,67.55 55.28,67.05 55.13,66.89 54.81,66.89 54.13,66.21 53.86,66.21 53.36,66.7 53.36,66.97 54.21,67.81 55.02,67.81
LG1_CHG on IN1 (solid shape): 50.56,57.3 50.56,57.1 48.97,55.51 48.64,55.51 48.52,55.63 48.52,56.13 49.22,56.83 49.22,57.24 49.82,57.85 50.01,57.85
LG2_CHG on TOP (solid shape): 50.49,56 50.49,55.85 49.74,55.09 49.71,55.09 49.36,54.74 48.59,54.74 48.53,54.8 48.53,54.91 48.58,54.96 49.32,54.96 49.54,55.18 49.54,55.51 50.13,56.11 50.39,56.11
LG2_CHG on BOTTOM (solid shape): 61.83,78.29 61.83,76.42 60.48,75.08 58.3,75.08 58.01,75.37 58.01,76.31 58.25,76.56 59.36,76.56 61.15,78.35 61.77,78.35
LG2_CHG on IN4 (solid shape): 59,76.2 59,75.32 58.84,75.16 58.67,75.16 58.23,74.73 58.23,74.1 58.17,74.05 57.22,74.05 57.21,74.06 57.21,75.61 57.92,76.32 58.88,76.32
LG2_CHG on IN4 (solid shape): 51.63,57.17 51.02,56.56 50.74,56.47 50.64,56.19 50.51,56.05 50.51,55.83 49.85,55.18 49.67,55.18 49.49,55.36 49.49,55.85 50.11,56.48 50.11,56.72 50.62,57.22 50.62,57.84 51.63,57.84
LG_SA on TOP (solid shape): 91.61,94.49 91.61,93.75 91.44,93.58 90.52,93.58 90.34,93.76 90.34,94.58 90.52,94.75 91.34,94.75
LG_SA on BOTTOM (solid shape): 96.84,94.8 96.84,93.46 96.65,93.27 96.18,93.27 96.08,93.37 96.08,94.14 96.21,94.27 96.21,94.74 96.4,94.93 96.72,94.93
LG_SA on IN3 (solid shape): 93.86,94.34 93.94,94.26 95.88,94.26 95.95,94.33 96.75,94.33 96.84,94.24 96.84,93.44 96.62,93.22 93.45,93.22 93.05,93.62 90.52,93.62 90.35,93.79 90.35,94.52 90.56,94.73 93.47,94.73
LX1_CHG on TOP (solid shape): 60.47,73.26 60.47,70.81 59.7,70.03 55.51,70.03 55.25,70.29 55.25,71.18 55.44,71.37 55.76,71.37 55.89,71.24 58.74,71.24 59.19,71.69 59.19,73.21 59.32,73.34 60.39,73.34
LX1_CHG on TOP (solid shape): 48.78,58.41 48.78,56.56 48.71,56.48 48.23,56.48 48.03,56.29 48.03,55.51 47.98,55.46 47.87,55.46 47.81,55.51 47.81,56.4 48.21,56.79 48.21,56.99 48.22,56.99 48.22,57.77 47.71,58.29 45.18,58.29 45.08,58.38 45.08,59.17 45.18,59.26 47.93,59.26
LX1_CHG on BOTTOM (solid shape): 48.73,68.62 49,68.62 49.4,68.23 49.4,67.62 49.36,67.59 48.71,67.59 48.42,67.89 48.14,67.89 47.89,68.14 47.89,68.74 48.07,68.92 48.43,68.92
LX1_CHG on BOTTOM (solid shape): 59.89,73.05 59.89,68.7 59.7,68.51 57.66,68.51 56.76,67.61 54.23,67.61 54.11,67.73 54.11,71.22 54.22,71.33 55.26,71.33 55.76,71.84 55.76,72.91 56.12,73.27 59.67,73.27
LX1_CHG on IN1 (solid shape): 55.93,71.2 55.93,70.37 55.66,70.1 54.92,70.1 53.98,71.04 53.98,71.84 54.11,71.98 55.16,71.98
LX1_CHG on IN1 (solid shape): 49.79,58.87 49.79,58.44 48.9,57.55 48.9,56.8 48.55,56.45 48.33,56.45 48.2,56.57 48.2,58.27 49.09,59.16 49.5,59.16
LX1_CHG on IN1 (solid shape): 49.59,70.1 49.59,66.73 49.46,66.61 48.7,66.61 48.57,66.73 48.57,67.62 48.32,67.88 48.13,67.88 47.94,68.07 47.94,69.21 48.08,69.35 48.13,69.39 48.18,69.45 48.38,69.65 48.38,70.16 48.51,70.29 49.4,70.29
LX1_IA on TOP (solid shape): 83.32,94.29 83.32,92.64 83.19,92.51 81.79,92.51 81.6,92.7 81.6,94.29 81.73,94.42 83.19,94.42
LX1_IA on BOTTOM (solid shape): 87.31,96.17 87.31,92.29 87.16,92.15 85.66,92.15 85.66,93.08 84.83,93.08 84.83,92.15 80.83,92.15 80.19,91.51 80.19,90.75 80.17,90.72 79.51,90.72 79.49,90.74 79.49,92 79.29,92.2 75.27,92.2 75.2,92.27 75.2,94.01 77.65,96.45 87.03,96.45
LX2_CHG on TOP (solid shape): 63.57,75.18 63.57,73.97 63.13,73.53 59.49,73.53 59.23,73.78 59.23,74.88 59.79,75.43 63.32,75.43
LX2_CHG on TOP (solid shape): 50.87,55.92 50.97,55.9 51.08,55.92 51.09,55.92 51.79,55.92 51.82,55.89 51.82,54.99 51.73,54.9 50.56,54.9 50.49,54.97 50.07,54.97 49.97,54.88 49.94,54.84 49.61,54.51 49.58,54.48 49.44,54.34 48.6,54.34 48.53,54.41 48.53,54.5 48.59,54.57 49.33,54.57 49.75,54.99 49.78,54.99 49.9,55.11 49.91,55.12 50.02,55.19 50.09,55.29 50.09,55.3 50.2,55.4 50.29,55.4 50.81,55.92 50.86,55.92
LX2_CHG on BOTTOM (solid shape): 63.19,83.12 63.19,82.32 63,82.12 62.43,82.12 62.3,82.25 62.3,82.71 61.93,83.08 61.93,83.28 62.05,83.4 62.9,83.4
LX2_CHG on BOTTOM (solid shape): 67.13,76.89 67.13,75.56 69.06,73.62 69.06,68.92 68.9,68.76 63.95,68.76 62.94,69.78 62.94,75.24 62.29,75.89 62.29,77.17 62.39,77.27 66.74,77.27
LX2_CHG on IN4 (solid shape): 60.91,74.8 60.91,73.46 60,72.55 59.6,72.55 59.25,72.9 59.25,74.64 59.45,74.84 60.86,74.84
LX2_CHG on IN4 (solid shape): 62.99,83.62 62.99,83.09 62.83,82.94 61.93,82.94 61.14,83.73 61.14,84.25 61.3,84.4 62.21,84.4
LX2_CHG on IN4 (solid shape): 52.85,56.16 52.85,55.94 51.89,54.97 50.28,54.97 50.13,55.13 50.13,55.31 50.28,55.46 50.33,55.46 50.69,55.83 51.37,55.83 51.62,56.08 51.62,56.09 52.24,56.72 52.3,56.72
LX2_IA on TOP (solid shape): 84.43,78.2 84.43,77.18 84.14,76.89 84.14,76.54 83.6,76 83.14,76 82.74,76.41 82.74,78.18 82.83,78.27 84.36,78.27
LX2_IA on BOTTOM (solid shape): 86.11,80.43 86.11,79.1 85.14,79.1 85.14,78.29 86.11,78.29 86.11,76.26 85.86,76 80.68,76 80.35,76.33 80.35,77 80.36,77.01 81.63,77.01 81.84,77.22 81.84,80.98 81.86,81 85.54,81
