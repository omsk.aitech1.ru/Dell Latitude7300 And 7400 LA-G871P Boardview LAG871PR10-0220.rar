# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_SRC_CFG1: length 7.8
  TOP w0.127: RT338.1 35.24,84.92 35.39,84.76 v2(35.39,84.31) v1(35.39,83.6)
  BOTTOM w0.076: 31.67,83.41 31.63,83.37 31.63,83.24 31.37,82.99 31.18,82.99 30.92,82.72 UT1.AA1
  BOTTOM w0.127: v1(35.39,83.6) 35.39,83.76 35.11,84.04 32.75,84.04 32.39,83.69 31.95,83.69 31.67,83.41
TBT_TMU_CLK_OUT: length 3.4
  TOP w0.127: RT28.1 30.23,84.91 29.76,84.44 v1(29.76,83.88)
  BOTTOM w0.076: v1(29.76,83.88) 29.85,83.88 30.04,83.69 30.04,83.12 29.77,82.84 29.77,82.3 UT1.V2
TBTA_AUXN: length 33.8
  IN4 w0.094: v1(27.87,50.35) 27.87,50.35 28.04,50.52 28.04,53.49 27.25,54.28 27.25,57.47 28.29,58.51 28.29,59.6 25.72,62.17 25.72,63.75 24.16,65.31 24.16,69.57 25.56,70.96 29.18,70.96 29.63,71.41 29.63,75.34 29.88,75.59 29.88,75.64 v1(29.69,75.83)
  BOTTOM w0.114: UT1.W15 v1(29.69,75.83) ; CT81.1 28.14,50.74 28.14,50.62 v1(27.87,50.35)
TBTA_AUXN_C: length 6.1
  BOTTOM w0.076: 29.52,55.64 29.52,56.24 UT5.J2
  BOTTOM w0.089: 28.71,54.02 28.71,54.83 29.52,55.64
  BOTTOM w0.114: CT81.2 28.08,51.61 28.08,52.03 RT95.1 27.89,52.38 27.91,52.41 27.91,52.72 28.14,52.95 28.44,52.95 28.71,53.22 v4(28.71,53.69) 28.71,54.02
TBTA_AUXP: length 34
  IN4 w0.094: v1(30.36,75.83) 30.11,75.58 30.11,75.49 29.85,75.24 29.85,71.31 29.27,70.73 25.65,70.73 24.39,69.47 24.39,65.4 25.95,63.84 25.95,62.26 28.52,59.7 28.52,58.41 27.48,57.37 27.48,54.38 28.27,53.58 28.27,50.66 v1(28.58,50.35)
  BOTTOM w0.114: v1(28.58,50.35) 28.39,50.54 28.39,50.76 CT80.1 ; v1(30.36,75.83) 30.56,75.83 30.68,75.94 UT1.Y15
TBTA_AUXP_C: length 6.1
  BOTTOM w0.076: UT5.J1 29.8,55.99 29.86,55.93 29.86,55.73 29.7,55.57
  BOTTOM w0.089: 28.96,54.03 28.96,54.04 28.89,54.11 28.89,54.76 29.65,55.52 29.7,55.57
  BOTTOM w0.114: CT80.2 28.33,51.71 28.33,52 28.56,52.23 RT96.1 28.62,52.32 28.49,52.44 28.27,52.44 28.15,52.56 28.15,52.62 28.24,52.71 28.54,52.71 28.95,53.12 28.95,54.02 28.96,54.03
TBTA_BOT_N: length 3.9
  TOP w0.114: v1(27.22,59.39) 27.45,59.61 27.45,61.23 RT122.2
  BOTTOM w0.076: v1(27.22,59.39) 27.59,59.02 28.74,59.02 UT5.L7
TBTA_BOT_N_R: length 41.5
  TOP w0.114: JUSBC1.A7 8.08,85.47 8.26,85.66 11.05,85.66 11.32,85.39 DT40.8 DT40.2 13.66,85.39 13.99,85.73 14.23,85.73 14.56,85.41 14.56,85.01 14.87,84.7 15.06,84.7 v1(15.25,84.51) ; v1(15.43,71.84) 15.71,72.12 15.92,72.12 17.82,70.22 v4(19.41,70.22) 22.29,70.22 24.65,67.87 24.65,66.31 25.98,64.99 25.98,64.19 27.57,62.59 27.57,62.33 RT122.1
  IN2 w0.102: v1(15.25,84.51) 15.52,84.79 15.7,84.79 15.86,84.63 15.86,84.37 15.75,84.27 15.75,79.69 14.74,78.67 14.74,72.4 14.95,72.19 15.07,72.19 v1(15.43,71.84)
TBTA_BOT_P: length 3.9
  TOP w0.114: RT123.2 27.69,61.23 27.69,59.51 v1(27.81,59.39)
  BOTTOM w0.076: UT5.K7 29.27,59.12 29.15,59.24 28.88,59.24 28.87,59.24 28.67,59.24 28.66,59.24 27.96,59.24 v1(27.81,59.39)
TBTA_BOT_P_R: length 41.5
  TOP w0.114: v1(15.25,85.08) 15.12,84.96 14.96,84.96 14.8,85.11 14.8,85.51 14.34,85.97 13.91,85.97 13.49,86.39 DT40.4 DT40.7 11.99,86.39 11.98,86.38 11.85,86.38 11.75,86.29 11.37,86.29 10.98,85.9 8.16,85.9 8.09,85.97 JUSBC1.A6 ; RT123.1 27.82,62.07 27.82,62.69 26.22,64.29 26.22,65.09 24.9,66.41 24.9,67.97 22.4,70.47 17.92,70.47 16.03,72.37 15.48,72.37 v1(15.43,72.42)
  IN2 w0.102: v1(15.25,85.08) 15.35,84.98 15.78,84.98 16.05,84.71 16.05,84.3 15.94,84.19 15.94,79.61 14.93,78.59 14.93,72.48 15.03,72.38 15.39,72.38 v1(15.43,72.42)
TBTA_CC1: length 53.1
  TOP w0.127: v3(24.66,60.4) 25.08,60.81 v1(25.08,61.4)
  TOP w0.279: JUSBC1.B5 6.32,85.22 6.55,85 v1(6.75,85)
  IN3 w0.381: v1(13.47,84.39) 13.28,84.58 13.28,85.46 13.49,85.68 15.67,85.68 16.01,85.34 16.01,84.26 15.56,83.81 15.56,77.59 15.95,77.21 15.95,65.59 14.8,64.45 14.8,61.97 15.37,61.4 v1(25.08,61.4)
  BOTTOM w0.203: 13.66,84.77 13.53,84.89 DT39.5 DT39.6 11.69,84.89 11.63,84.96
  BOTTOM w0.254: 27.95,60.32 28.09,60.17 28.11,60.17 28.12,60.16 28.13,60.16 28.3,59.99 UT5.L9
  BOTTOM w0.305: v1(6.75,85) 7.41,85 7.55,85.13 10.62,85.13 10.8,84.95 11.63,84.96 ; RT104.2 26.64,60.48 26.8,60.32 27.95,60.32 ; 13.66,84.77 13.66,84.58 v1(13.47,84.39)
  BOTTOM w0.381: RT104.2 26.57,60.7 CT86.1 25.86,60.94 25.41,61.4 v1(25.08,61.4)
TBTA_CC2: length 49.7
  TOP w0.127: v1(25.08,62.03) v3(24.29,62.03)
  TOP w0.203: 13.82,86.89 DT40.5 DT40.6 11.76,86.89
  TOP w0.279: JUSBC1.A5 8.2,86.47
  TOP w0.305: v1(14.36,86.61) 14.1,86.61 13.82,86.89 ; 11.76,86.89 11.46,86.89 11.37,86.8 10.86,86.8 10.36,86.29 8.39,86.29 8.2,86.47
  IN2 w0.381: v1(14.36,86.61) 15.31,86.61 16.9,85.02 16.9,83.49 16.73,83.32 16.73,78.45 16.42,78.14 16.42,70.9 15.22,69.69 15.22,69.32 14.87,68.96 14.87,63.05 15.18,62.73 v1(15.75,62.73)
  IN4 w0.381: v1(25.08,62.03) 16.58,62.03 15.88,62.73 v1(15.75,62.73)
  BOTTOM w0.254: 27.86,61.23 28.08,61.02 28.08,60.98 28.56,60.49 UT5.L10
  BOTTOM w0.305: RT105.2 26.57,61.5 26.84,61.23 27.86,61.23
  BOTTOM w0.381: RT105.2 26.57,61.69 26.22,62.05 CT85.1 25.72,62.41 25.34,62.03 v1(25.08,62.03)
TBTA_DBG_CTL1: length 5.2
  TOP w0.127: RT106.1 33.39,53.85 33.39,55.46 v2(33.04,55.82) v1(31.86,57)
  BOTTOM w0.076: UT5.E4 31.77,57.08 v1(31.86,57)
TBTA_DBG_CTL2: length 3.5
  TOP w0.089: v1(32.74,57.56) 33.15,57.15 v2(33.15,57.11) 33.15,56.32 33.92,55.56 RT107.1
  BOTTOM w0.076: v1(32.74,57.56) 32.7,57.56 UT5.D5
TBTA_DEBUG3: length 4.6
  BOTTOM w0.114: 27.76,56.04 27.51,55.79 27.51,55.49 27.01,54.99 v2(26.73,54.99) 26.52,54.99 26.22,54.69 RT89.2
  BOTTOM w0.127: UT5.L3 28.45,56.99 28.41,57.03 27.88,57.03 27.76,56.9 27.76,56.04
TBTA_DEBUG4: length 4.6
  TOP w0.114: v1(26.68,56.32) v2(26.68,55.57)
  IN2 w0.102: v1(26.68,56.32) 27.01,56.65 v1(28.16,56.65)
  BOTTOM w0.076: UT5.K3 29.02,56.74 28.59,56.74 28.57,56.75 28.27,56.75 v1(28.16,56.65)
  BOTTOM w0.114: RT90.2 26.07,56.61 26.36,56.32 v1(26.68,56.32)
TBTA_HPD: length 31.6
  TOP w0.076: RT23.1 v2(25.41,81.74)
  TOP w0.127: RT23.1 26.45,81.71 v1(26.45,81.04)
  IN4 w0.084: v1(32.77,60.01) 32.77,60.83 31.95,61.65 31.95,63.24 33.01,64.31 33.01,66.85 34.36,68.19 34.36,69.97 34.17,70.16 33.6,70.16 33.47,70.29 32.77,70.29 32.33,70.73 31.25,70.73 30.74,71.24 30.74,72.32 30.99,72.57 30.99,76.22 30.62,76.59 29.01,76.59 28.2,77.4 28.2,78.04 27.5,78.73 26.87,78.73 25.98,79.62 25.98,80.51 26.45,80.99 v1(26.45,81.04)
  BOTTOM w0.102: UT5.C10 v1(32.77,60.01)
  BOTTOM w0.127: UT1.M4 v1(26.45,81.04)
TBTA_I2C_INT: length 59.1
  TOP w0.127: v2(31.13,51.12) 30.77,51.49 v1(30.42,51.49) ; RT16.1 25.13,84.86 25.24,84.74 25.24,82.41 24.91,82.09 24.91,81.28 v1(25.15,81.04)
  IN1 w0.084: v1(30.42,51.49) 27.79,54.12 27.79,57.04 28.38,57.63 28.38,59.99 26.03,62.34 26.03,62.88 24.88,64.03 24.88,71.91 26.2,73.24 30.51,73.24 30.92,73.65 30.92,81.28 30.04,82.16 28.26,82.16 27.63,81.53 25.6,81.53 25.15,81.08 v1(25.15,81.04)
  BOTTOM w0.076: 33.28,54.7 33.28,55.1 32.86,55.51 32.86,55.9 UT5.C1
  BOTTOM w0.102: v1(30.42,51.49) 30.53,51.39 33.39,51.39 33.55,51.55 33.55,51.9 33.49,51.95 33.49,53.96 33.28,54.17 33.28,54.7
  BOTTOM w0.127: UT1.J4 v1(25.15,81.04)
TBTA_LSRX: length 41.4
  TOP w0.114: RT21.1 21.02,80.89 20.74,80.89 v1(20.58,81.06)
  IN1 w0.094: v1(24.67,55.91) 24.51,55.75 23.62,55.75 23.12,56.25 23.12,60.19 21.88,61.43 20.1,61.43 17.6,63.94 17.6,68.07 18.17,68.64 20.11,68.64 21.31,69.83 21.31,80.55 20.96,80.89 20.74,80.89 v1(20.58,81.06)
  BOTTOM w0.076: UT1.A4 21.56,80.99 20.64,80.99 v1(20.58,81.06) ; UT5.K4 29.02,57.74 28.62,57.74 28.47,57.59 27.76,57.59 27.24,57.08 27.24,56.25
  BOTTOM w0.114: v1(24.67,55.91) 24.85,55.74 25.53,55.74 25.79,56 25.83,56 RT90.1 26.13,55.75 26.8,55.75 27.24,56.19 27.24,56.25
TBTA_LSTX: length 41.5
  TOP w0.114: RT22.1 20.89,80.65 20.75,80.65 v1(20.58,80.47)
  IN1 w0.094: v1(20.58,80.47) 20.77,80.67 20.87,80.67 21.08,80.45 21.08,69.92 20.02,68.86 18.07,68.86 17.37,68.16 17.37,63.85 20.01,61.21 21.79,61.21 22.89,60.1 22.89,56.16 23.53,55.52 24.48,55.52 v1(24.67,55.33)
  BOTTOM w0.076: UT5.L4 28.86,57.49 28.94,57.41 28.94,57.32 28.86,57.24 28.58,57.24 28.47,57.24 28.33,57.39 27.81,57.39 27.44,57.02 27.44,56.32 27.49,56.27 27.49,56.25 ; v1(20.58,80.47) 20.89,80.79 21.62,80.79 UT1.A5
  BOTTOM w0.114: v1(24.67,55.33) 24.84,55.49 25.63,55.49 RT89.1 26.07,55.5 26.91,55.5 27.49,56.08 27.49,56.25
TBTA_MRESET: length 2.3
  BOTTOM w0.127: UT5.E11 31.77,62.12 v2(31.87,62.22) 31.87,62.7 RT86.1
TBTA_RBIAS: length 2.4
  TOP w0.127: v1(24.5,80.39) 25.02,79.87 25.28,79.87 25.8,79.36 RT39.2
  BOTTOM w0.127: v1(24.5,80.39) UT1.H6
TBTA_RESET_N_EC_R: length 3.9
  BOTTOM w0.076: UT5.F11 31.27,61.61
  BOTTOM w0.127: 31.27,61.61 31.27,62.62 31.49,62.84 RT110.1 31.37,63.08 31.07,63.38 31.07,64.41 v2(31.17,64.51)
TBTA_ROM_CLK_PD: length 24.5
  IN4 w0.084: v1(35.38,56.19) 35.77,56.19 36.65,55.31 36.65,47.68 35.88,46.92 33.15,46.92 32.84,47.24 v1(28.52,47.24)
  BOTTOM w0.089: 34.64,57.06 34.01,57.06 33.97,57.02 33.8,57.02 UT5.A3
  BOTTOM w0.127: UT6.6 30.2,44.17 28.52,45.85 v1(28.52,47.24) ; 34.64,57.06 34.93,56.76 34.93,56.64 v1(35.38,56.19)
TBTA_ROM_CS#_PD: length 18.2
  TOP w0.127: v2(33.58,46.58) 33.41,46.76 RT51.1 33.75,47.52 33.97,47.3 v1(35.57,47.3)
  IN4 w0.084: v1(35.38,55.56) 35.5,55.56 36.14,54.92 36.14,48.13 35.57,47.56 v1(35.57,47.3)
  BOTTOM w0.076: 34.49,56.85 34.01,56.85 33.89,56.74 33.52,56.74 UT5.B3
  BOTTOM w0.089: 34.49,56.85 34.67,56.67
  BOTTOM w0.127: UT6.1 36.15,46.71 v1(35.57,47.3) ; v1(35.38,55.56) 35.19,55.56 34.68,56.06 34.68,56.66 34.67,56.67
TBTA_ROM_DI_PD: length 21.6
  TOP w0.127: v1(35.57,46.41) v2(34.85,46.41)
  IN4 w0.084: v1(35.38,56.76) 36,56.76 37.22,55.55 37.22,47.6 36.08,46.46 35.61,46.46 v1(35.57,46.41)
  BOTTOM w0.076: 34.88,57.26 33.96,57.26 33.93,57.24 33.52,57.24 UT5.B4
  BOTTOM w0.127: UT6.5 31.87,42.9 35.38,46.42 35.56,46.42 v1(35.57,46.41) ; 34.88,57.26 v1(35.38,56.76)
TBTA_ROM_DO_PD: length 20.7
  TOP w0.127: v1(35.5,45.58) 35.77,45.84 v2(36.06,45.84) 36.87,45.84 37.04,45.68 37.06,45.68 37.15,45.58 37.15,45.56 RT52.1
  IN4 w0.084: v1(35.38,57.33) 36.26,57.33 37.47,56.13 37.47,47.55 v1(35.5,45.58)
  BOTTOM w0.076: UT5.A4 34.71,57.49
  BOTTOM w0.127: v1(35.5,45.58) 35.51,45.58 35.65,45.44 UT6.2 ; 34.71,57.49 35.22,57.49 v1(35.38,57.33)
TBTA_ROM_HOLD#_PD: length 3
  TOP w0.127: RT50.1 31.54,46.09 v1(32.14,46.09) 32.18,46.09 v2(32.68,45.59)
  BOTTOM w0.127: v1(32.14,46.09) 32.17,46.06 32.17,45.88 31.74,45.44 UT6.7
TBTA_ROM_WP#_PD: length 4.6
  TOP w0.127: RT53.1 36.2,44.25 v2(35.9,43.95) v1(35.5,43.55)
  BOTTOM w0.127: UT6.3 36.12,44.17 v1(35.5,43.55)
TBTA_ROSC: length 4.8
  TOP w0.127: v1(30.17,54.29) 30.17,53.94 RT100.1 28.88,53.49 v2(28.57,53.17)
  BOTTOM w0.076: 30.55,55.49 30.52,55.52 30.52,56.24 UT5.G2
  BOTTOM w0.127: 30.55,55.49 30.55,55.28 30.61,55.22 30.61,54.91 30.17,54.46 v1(30.17,54.29)
TBTA_RSENSE: length 1.9
  TOP w0.127: v1(24.5,79.74) 24.89,79.36 RT39.1
  BOTTOM w0.127: UT1.J6 25.13,79.72 24.52,79.72 v1(24.5,79.74)
TBTA_SBU1: length 54
  TOP w0.127: JUSBC1.B8 6.62,86.72 v1(6.67,86.67) ; v1(15.44,62.16) 14.98,62.62 v2(14.98,62.8)
  IN2 w0.122: v1(15.44,62.16) 16.01,62.16 16.2,62.35 16.2,64 15.38,64.82 15.38,68.98 15.57,69.17 15.57,69.47 16.78,70.68 16.78,78 17.08,78.3 17.08,83.17 17.41,83.5 17.41,85.27 15.44,87.24 v1(14.36,87.24)
  IN4 w0.084: v1(15.44,62.16) 15.69,62.16 16.58,61.27 21.6,61.27 22.42,60.45 25.72,60.45 26.17,60 v1(26.17,59.75)
  BOTTOM w0.076: UT5.K8 29.02,59.74 28.19,59.74 28.02,59.91 28.01,59.91 28,59.92 27.96,59.92 27.89,59.99 27.12,59.99
  BOTTOM w0.114: 14,86.89 v1(14.36,87.24)
  BOTTOM w0.127: v1(26.17,59.75) 26.41,59.99 27.12,59.99 ; v1(6.67,86.67) 6.75,86.75 7.29,86.75 7.82,86.23 10.69,86.23 11.35,86.89 DT39.9 DT39.1 14,86.89
TBTA_SBU2: length 50.5
  TOP w0.127: JUSBC1.A8 8.15,84.97 8.32,85.15 10.5,85.15 v2(10.63,85.01) 10.75,84.89 DT40.9 DT40.1 13.78,84.89 v1(14.04,85.15)
  IN2 w0.122: v1(15.31,60.74) 15.14,60.74 14.48,61.4 14.48,69.08 14.87,69.46 14.87,70.03 16.07,71.24 16.07,78.29 16.36,78.58 16.36,83.64 16.52,83.8 16.52,84.83 15.37,85.97 14.23,85.97 14.04,85.78 v1(14.04,85.15)
  IN4 w0.084: v1(15.31,60.74) 15.33,60.76 21.47,60.76 22.09,60.14 25.33,60.14 25.6,59.87 25.6,59.49 v1(25.85,59.24)
  BOTTOM w0.076: UT5.L8 28.22,59.49 27.96,59.75 27.95,59.75 27.93,59.76 27.1,59.76
  BOTTOM w0.127: v1(25.85,59.24) 26.22,59.24 26.74,59.76 27.1,59.76 27.1,59.76
TBTA_TOP_N: length 5.8
  TOP w0.114: RT121.1 25.86,61.35 25.86,60.68 26.56,59.98 26.56,59.47 26.43,59.34 26.43,58.93 v1(26.3,58.8)
  BOTTOM w0.076: 27.08,58.46 27.27,58.65 28.48,58.65 28.64,58.49 UT5.L6
  BOTTOM w0.114: 27.08,58.46 27.03,58.41 26.69,58.41 v1(26.3,58.8)
TBTA_TOP_N_R: length 43.6
  TOP w0.114: v1(14.31,70.78) 14.49,70.96 15.31,70.96 16.73,69.53 v4(21.28,69.53) 22,69.53 23.95,67.58 23.95,66.05 25.16,64.84 25.16,63.65 26.11,62.69 26.11,62.33 RT121.2 ; JUSBC1.B7 6.64,86.22 6.74,86.13 v1(6.74,86.11)
  IN2 w0.102: v1(14.65,84.29) 14.65,83.92 14.76,83.81 14.93,83.81 15.31,83.43 15.31,80 14.29,78.99 14.29,72.25 14.9,71.64 14.9,71.28 14.71,71.08 14.62,71.08 v1(14.31,70.78)
  BOTTOM w0.114: v1(14.65,84.29) 14.65,84.29 14.54,84.4 14.54,84.66 14.74,84.86 14.74,85.88 14.39,86.22 13.73,86.22 13.56,86.39 DT39.2 DT39.8 11.51,86.39 11.09,85.97 6.89,85.97 6.77,86.1 6.75,86.1 v1(6.74,86.11)
TBTA_TOP_P: length 5.8
  TOP w0.114: v1(26.89,58.8) 26.68,59.01 26.68,59.24 26.8,59.37 26.8,60.09 v4(26.44,60.44) 26.1,60.78 26.1,61.1 RT120.1
  BOTTOM w0.076: UT5.K6 29.27,58.64 29.18,58.74 28.64,58.74 28.56,58.83 27.19,58.83
  BOTTOM w0.114: 27.19,58.83 27.16,58.8 v1(26.89,58.8)
TBTA_TOP_P_R: length 43.7
  TOP w0.114: v1(14.31,71.36) 14.47,71.2 15.41,71.2 16.83,69.78 22.1,69.78 24.2,67.68 24.2,66.15 25.41,64.95 25.41,63.75 26.36,62.8 26.36,62.09 RT120.2 ; JUSBC1.B6 6.56,85.72 6.73,85.55 v1(6.74,85.55)
  IN2 w0.102: v1(14.04,84.19) 14.1,84.19 14.68,83.62 14.86,83.62 15.12,83.35 15.12,80.08 14.1,79.07 14.1,72.17 14.71,71.56 14.71,71.36 14.63,71.27 14.54,71.27 14.39,71.27 v1(14.31,71.36)
  BOTTOM w0.114: v1(14.04,84.19) 14.29,84.45 14.29,84.76 14.49,84.96 14.49,85.77 14.29,85.97 13.85,85.97 13.78,85.91 13.78,85.66 13.51,85.39 DT39.4 DT39.7 11.45,85.39 11.11,85.73 6.85,85.73 6.74,85.61 6.74,85.56 v1(6.74,85.55)
TBTA_USB2_RBIAS: length 1.4
  TOP w0.127: RT41.1 24.71,73.45 v1(25.15,73.89)
  BOTTOM w0.112: UT1.H19 v1(25.15,73.89)
TBTA_USB20_N: length 20.1
  IN2 w0.102: v1(23.2,73.89) 23.44,73.66 23.44,73.21 24.39,72.26 24.39,71.43 25.47,70.35 25.47,62.86 25.79,62.54 25.79,61.48 24.64,60.33 24.64,59.06 24.53,58.95 24.31,58.95 v1(24.09,59.18)
  BOTTOM w0.104: UT1.D20 v1(23.2,73.89)
  BOTTOM w0.114: v1(24.09,59.18) 24.28,58.98 24.46,58.98 24.83,58.6 24.83,57.79 24.95,57.67 25.11,57.67 25.26,57.82 RT403.1
TBTA_USB20_N_R: length 5.2
  TOP w0.114: RT401.2 25.83,57.78 26.59,57.78 v1(26.76,57.96)
  BOTTOM w0.076: UT5.K5 28.84,58.24 27.54,58.24 27.26,57.96 v1(26.76,57.96)
  BOTTOM w0.089: v1(26.76,57.96) 26.56,57.76 26.13,57.76 RT403.2
TBTA_USB20_P: length 20.1
  IN2 w0.102: v1(24.09,58.6) 24.24,58.76 24.61,58.76 24.83,58.99 24.83,60.26 25.98,61.4 25.98,62.62 25.66,62.94 25.66,70.43 24.58,71.51 24.58,72.34 23.63,73.29 23.63,73.67 v1(23.85,73.89)
  BOTTOM w0.104: UT1.E20 v1(23.85,73.89)
  BOTTOM w0.114: v1(24.09,58.6) 24.21,58.73 24.36,58.73 24.59,58.5 24.59,57.69 24.85,57.43 25.11,57.43 RT402.1
TBTA_USB20_P_R: length 5.1
  TOP w0.114: v1(26.76,57.37) 26.6,57.54 25.81,57.54 RT400.2
  BOTTOM w0.076: UT5.L5 28.69,58.07 28.49,58.07 28.41,58 28.41,57.92 28.34,57.84 28.19,57.84 28.11,57.92 28.11,58 28.03,58.07 27.6,58.07 27.33,57.79 27.18,57.79 v1(26.76,57.37)
  BOTTOM w0.089: RT402.2 26.13,57.58 26.56,57.58 v1(26.76,57.37)
TBTB_HPD: length 6.3
  BOTTOM w0.076: RT33.1 25.57,86.91 v2(25.9,86.58) ; 24.79,84.88 24.42,84.51 24.42,83.64 24.45,83.61 24.45,82.95 24.69,82.7 24.69,82.29 24.48,82.08 UT1.G2
  BOTTOM w0.127: 24.79,84.88 24.96,85.05 RT33.1
TBTB_I2C_INT: length 5.2
  BOTTOM w0.076: v2(23.59,84.19) 23.59,83.76 23.4,83.57 23.4,83.19 23.79,82.8 23.79,82.3 UT1.E2
  BOTTOM w0.127: RT17.1 23.37,86.32 23.59,86.1 v2(23.59,84.19)
TBTB_LSRX: length 3.6
  BOTTOM w0.076: 20.26,79.88 20.64,79.88 21.22,80.46 21.96,80.46 22.18,80.68 UT1.B5
  BOTTOM w0.127: 20.26,79.88 v2(19.84,79.88) RT32.1
TBTB_LSTX: length 3.8
  BOTTOM w0.076: 20.07,81.44 20.73,81.44 20.79,81.38 21.95,81.38 UT1.B4
  BOTTOM w0.127: RT31.1 19.14,80.51 v2(19.8,81.18) 20.07,81.44
TBTB_USB2_RBIAS: length 3.4
  TOP w0.127: v2(21.11,75.09) 21.24,74.96 RT42.2 22.61,74.54 v1(23.85,74.54)
  BOTTOM w0.112: UT1.F19 v1(23.85,74.54)
TDI_XDP: length 2.6
  TOP w0.127: v1(57.66,100.32) 57.66,100.81 57.51,100.96 RC851.2 58.09,101.17 RC736.1
  BOTTOM w0.127: v1(57.66,100.32) 57.66,100.17 57.38,99.89 JXDP1.56
TDO_XDP: length 6.3
  TOP w0.127: v1(58.81,100.25) 58.81,100.64 58.93,100.76 58.93,101.4 59.1,101.57 CC306.1 59.4,101.57 59.72,101.25 RC737.1 59.92,101.24 RC850.2 60.7,101.24 61.11,101.64 61.11,102.25 v3(61.77,102.91)
  BOTTOM w0.127: JXDP1.52 58.58,100.02 v1(58.81,100.25)
TDOCK_BATLOW#: length 5.2
  BOTTOM w0.076: UT1.F2 24.25,82.3 24.25,82.68 24.12,82.81 24.12,83.47 24,83.59 24,84.98 24.31,85.28
  BOTTOM w0.127: 24.31,85.28 v2(24.31,86.05) 24.31,86.17 24.07,86.4 RT20.1
TEST_EN: length 4.8
  BOTTOM w0.076: UT1.E1 23.56,82.78 23.23,83.11 23.23,84.05 23.2,84.08 23.2,84.31
  BOTTOM w0.127: RT36.1 22.55,86.4 v2(22.91,86.04) 23.09,85.86 23.09,84.9 23.2,84.8 23.2,84.31
TEST_PWRGD: length 2.9
  BOTTOM w0.076: UT1.AB5 31.61,80.92 32.03,80.92 32.46,81.34 33.35,81.34 33.56,81.55 RT37.1
THERMDA: length 0.5
  BOTTOM w0.127: UT1.AC23 UT1.AB23
THERMTRIP1#: length 7.1
  TOP w0.127: v1(273.02,86.98) 273.42,86.58 UE1.B12 ; v1(272.25,89.75) 272.25,90.07 RE301.1 271.05,91.27 271.05,91.94 v2(270.5,92.49)
  BOTTOM w0.127: v1(272.25,89.75) 273.02,88.97 v1(273.02,86.98)
THERMTRIP2#: length 154
  TOP w0.127: v1(278.58,78.96) 278.22,79.32 UE1.H3
  IN1 w0.084: v1(278.58,78.96) 277.97,78.96 277.57,79.36 276.13,79.36 275.85,79.08 275.85,78.86 275.36,78.37 273.04,78.37 271.73,79.68 271.14,79.68 270.93,79.46 270.21,79.46 269.8,79.87 266.65,79.87 265.12,78.33 265.12,74.73 263.34,72.95 263.34,66.62 261.43,64.71 261.43,60.83 259.14,58.54 257.79,58.54 254.78,55.52 252.38,55.52 250.16,53.3 250.16,52.39 247.01,49.24 241.61,49.24 240.16,47.79 224.66,47.79 223.36,49.09 218.82,49.09 203.78,64.14 203.78,67.84 200.54,71.07 200.54,73.78 188.1,86.23 185.81,86.23 183.01,89.02 183.01,91.48 181.62,92.87 181.62,94.99 v1(179.52,97.09)
  BOTTOM w0.127: v1(179.52,97.09) v2(178.73,97.09) 178.39,97.09 178.06,97.42 RE69.2 177.63,97.47 177.63,97.81 177.64,97.82 CE36.1 177.3,98.16 176.92,97.78 QE4.1
TOUCH_SCREEN_DET#: length 269
  TOP w0.127: v1(75.96,112.88) 76.17,112.67 RV8.1 ; v1(164.21,52.44) 164.13,52.44 v3(163.59,52.98)
  IN3 w0.122: v1(164.21,52.44) 164.21,51.04 162.79,49.62 156.81,49.62 155.67,48.48 153.86,48.48 151.91,46.52 146.92,46.52 145.97,47.48 144.77,47.48 141.23,51.02 94.79,51.02 92.66,48.89 83.44,48.89 82.66,48.11 61.81,48.11 61.21,47.51 54.92,47.51 54.61,47.2 53.73,47.2 52.2,48.73 52.2,53.23 52.89,53.93 52.89,57.91 51.86,58.95 51.86,60.94 49.54,63.25 48.64,63.25 46.16,65.73 46.16,72.46 47.57,73.87 47.57,74.17 48.68,75.27 48.68,75.97 49.97,77.27 49.97,82.41 52.82,85.26 52.82,87.06 52.23,87.65 49.57,87.65 47.28,89.94 47.28,91.73 48.12,92.57 48.12,94.99 47.3,95.82 40.46,95.82 40.35,95.7 38.47,95.7 37.56,96.61 37.56,101 45.68,109.12 51.41,109.12 54.52,112.22 66.73,112.22 67.39,112.88 v1(69.41,112.88) 70,112.88 70.39,112.49 74.72,112.49 75.11,112.88 v1(75.96,112.88)
  IN4 w0.084: v1(164.21,52.44) 164.21,53.03 163.63,53.6 158.88,53.6 157.02,55.47 156.77,55.47 156.43,55.81 151.9,55.81 151.07,56.64 151.07,57.72 149.94,58.84 v1(149.94,62.38)
  BOTTOM w0.076: UC1.CC35 147.16,69.61 147.16,69.39 147.12,69.28 147.12,69.09 147.16,68.98 147.16,68.74 147.13,68.66 147.13,67.61 148.73,66.01 148.73,63.73
  BOTTOM w0.102: v1(149.94,62.38) 149.9,62.38 148.73,63.55 148.73,63.73
  BOTTOM w0.127: JEDP1.32 69.83,111.62 69.41,112.03 v1(69.41,112.88)
TOUCH_SCREEN_PD: length 5.5
  BOTTOM w0.127: v2(171.38,95.99) 171.38,97.43 171.09,97.72 RC104.2 170.66,97.92 169.59,97.92 169.46,98.06 QC4.6 169.46,98.83 169.34,98.95 169.12,98.95 168.96,98.79 QC4.5
TOUCH_SCREEN_PD#: length 21.3
  IN1 w0.102: v1(156.38,92.06) 156.76,92.45 158.59,92.45 160.2,94.06 160.49,94.06 161.76,95.33 v1(167.46,95.33)
  BOTTOM w0.076: UC1.CN3 153.01,90.3 153.01,90.69 153.17,90.84 153.52,90.84
  BOTTOM w0.089: v1(156.38,92.06) 155.67,91.36 154.13,91.36 153.62,90.84 153.52,90.84
  BOTTOM w0.127: v1(167.46,95.33) 167.63,95.5 168.98,95.5 169.16,95.68 RC566.1 ; RC566.1 169.51,95.94 169.52,95.94 RC82.2 ; RC566.1 169.16,96.17 168.96,96.37 QC4.2
TOUCH_SCREEN_PD#_R: length 95.3
  TOP w0.127: v3(164.89,108.92) 164.06,109.75 v1(164.06,109.75)
  IN2 w0.122: v1(169.93,99.88) 169.93,100.08 169.15,100.86 169.15,104.88 164.29,109.75 v1(164.06,109.75)
  IN3 w0.122: v1(164.06,109.75) 163.68,109.36 163.15,109.36 163.03,109.49 163.03,111.16 161.35,112.85 153.76,112.85 152.74,111.83 149.63,111.83 149.37,111.57 146.98,111.57 145.7,112.85 109.76,112.85 108.95,112.03 105.85,112.03 105.25,111.44 103.15,111.44 101.97,110.26 95.24,110.26 v1(94.5,111)
  BOTTOM w0.127: v1(169.93,99.88) 169.88,99.82 168.24,99.82 167.91,99.5 167.91,97.95 168.46,97.41 QC4.3 168.46,96.06 RC566.2 ; v1(94.5,111) 94.72,111.22 JIRTS1.9
TOUCHPAD_INTR#: length 190.6
  TOP w0.127: v1(180.21,55.87) 180.21,56.37 181.24,57.4 RC567.1 ; v1(247.81,38.12) v3(248.95,36.99) 249.37,36.57 250.6,36.57 v1(253.45,33.72) ; RE318.2 278.91,73.16 v1(278.96,73.21)
  IN2 w0.122: v1(160.28,58.79) 160.86,58.22 163.25,58.22 163.64,57.82 165.99,57.82 166.05,57.89 167.52,57.89 167.67,58.04 167.9,58.04 170.38,60.52 172.71,60.52 174.78,58.44 174.78,57.71 176.33,56.16 179.91,56.16 v1(180.21,55.87)
  IN3 w0.122: v1(180.21,55.87) 180.58,55.49 182.71,55.49 189.51,48.7 206.93,48.7 216.49,39.13 224.98,39.13 226.8,37.31 237.87,37.31 237.98,37.42 243.4,37.42 243.61,37.21 244.93,37.21 245.18,37.46 246.44,37.46 246.7,37.72 247.1,38.12 v1(247.81,38.12) 248.12,38.12 248.39,37.86 249.74,37.86 251.78,39.9 255.96,39.9 256.36,40.29 256.36,40.77 257.98,42.39 258.79,42.39 259.76,43.36 262.64,43.36 263.72,44.44 266.39,44.44 266.58,44.63 266.58,45.19 267.41,46.03 267.41,47.12 268.49,48.19 268.49,49.57 270.47,51.55 270.69,51.55 271.15,52.02 271.15,52.64 272.5,53.99 272.5,56.27 273.32,57.09 274.48,57.09 275.51,58.12 275.51,58.93 276.02,59.44 276.02,64.37 277.09,65.44 277.09,67.84 279.1,69.85 279.1,73.07 v1(278.96,73.21)
  BOTTOM w0.076: UC1.CB34 147,69.9 147,69.42 146.96,69.3 146.96,69.07 147,68.95 147,68.77 146.97,68.69 146.97,67.54 148.54,65.97 148.54,63.73
  BOTTOM w0.102: v1(160.28,58.79) 159.77,59.3 158.5,59.3 157.17,60.64 154.25,60.64 153.35,61.53 149.48,61.53 148.54,62.47 148.54,63.73
  BOTTOM w0.127: v1(253.45,33.72) 253.25,33.52 252.67,33.52 252.58,33.43 JKBTP1.16
TOUCHPAD_INTR#_R: length 5.2
  TOP w0.102: UE1.G2 277.83,78.14 277.83,76.82 277.56,76.55 277.56,75.67 v2(277.64,75.6) 277.91,75.33 RE318.1
TPM_GPIO0: length 9.4
  TOP w0.127: v1(186.69,81.97) 186.77,81.9 RZ112.2 ; v2(184.17,84.6) 184.11,84.54 v1(182.52,84.54) 182.41,84.43 UZ12.6
  BOTTOM w0.127: v1(186.69,81.97) 184.22,81.97 183.84,82.35 183.84,83.43 182.73,84.54 v1(182.52,84.54)
TPM_GPIO0_NU: length 3.3
  TOP w0.127: v2(187.53,80.12) 187.53,80.75 187.74,80.96 RZ1407.2 186.77,81.27 186.63,81.13 UZ12.29
TPM_PIRQ#: length 65.1
  TOP w0.127: UZ12.18 181.91,77.76 v1(181.55,77.4) 180.3,77.4 v2(180.17,77.28) RZ69.2
  IN3 w0.122: v1(181.55,77.4) 181.36,77.21 180.03,77.21 179.39,76.57 179.39,75.88 182.44,72.83 182.44,71.56 182.97,71.03 182.97,63.7 v1(182.37,63.11)
  IN4 w0.076: 148.18,71.07 148.11,71.14 148.11,72.69 v1(147.58,73.22)
  IN4 w0.102: v1(182.37,63.11) 182,62.73 181.36,62.73 181.2,62.57 181.2,61.93 181.04,61.78 175.94,61.78 175.18,61.02 167.37,61.02 166.2,62.19 164.14,62.19 163.51,61.55 159.06,61.55 152.26,68.35 150.1,68.35 148.61,69.84 148.61,70.64 148.18,71.07
  BOTTOM w0.089: UC1.CC29 v1(147.58,73.22)
TRST#_XDP: length 5.4
  TOP w0.127: v1(55.42,98.54) 55.07,98.89 RC853.2 54.69,99.1 v2(53.94,99.85)
  BOTTOM w0.127: v1(55.42,98.54) 55.48,98.48 57.54,98.48 57.98,98.93 JXDP1.54
TS_I2C_SCL: length 100.6
  TOP w0.127: RV99.2 89.16,105.78 89.04,105.91 v1(89.03,105.91) 89.03,105.99 89.17,106.12 CV55.1 89.17,107.03 89.26,107.12 90.4,107.12 v4(90.66,107.38) 91.93,108.65 91.93,108.9 92.21,109.18 DZ10.2 92.39,109.35 92.02,109.72 92.02,110.12 91.64,110.5 91.09,110.5 90.94,110.65 90.94,110.88 v1(91.07,111.01)
  IN2 w0.089: 142.75,92.41 142.75,92.39 142.75,92.39 142.75,90.17 143.72,89.2 143.72,85.39 143.9,85.21 146.07,85.21 146.31,84.97 146.31,83.77 146.7,83.37 147.83,83.37 147.92,83.28 152.83,83.28 154.11,84.57 155.64,84.57 156,84.93 156,85.06 v1(155.81,85.25)
  IN2 w0.122: v1(89.03,105.91) 89.03,105.91 89.29,105.65 89.56,105.65 91.67,107.75 101.73,107.75 103.64,105.84 110.56,105.84 113.87,102.54 121.16,102.54 122.13,103.51 133.44,103.51 136.38,100.58 138.03,100.58 140.24,98.36 140.24,95.79 140.85,95.18 141.58,95.18 142.75,94.01 142.75,92.41
  BOTTOM w0.076: UC1.CN11 153.22,84.89 153.43,84.68 153.53,84.64 153.71,84.64 153.83,84.69 154.96,84.69 155.08,84.57 155.73,84.57 156.05,84.89 156.05,85.01 155.82,85.25 v1(155.81,85.25)
  BOTTOM w0.127: JIRTS1.4 90.72,111.34 91.05,111.01 v1(91.07,111.01)
TS_I2C_SDA: length 102.5
  TOP w0.127: v1(90.5,111) 90.68,110.82 90.68,110.54 90.98,110.24 91.53,110.24 91.76,110.01 91.76,109.77 91.39,109.39 DZ10.3 91.55,109.18 91.68,109.06 91.68,108.76 90.29,107.37 88.44,107.37 RV98.2 88.33,106.69 CV54.1 88.3,106.1 88.45,105.96 v1(88.45,105.89)
  IN2 w0.089: v1(156.45,85.25) 156.22,85.01 156.22,84.9 155.71,84.39 154.19,84.39 152.9,83.1 147.84,83.1 147.76,83.19 146.61,83.19 146.12,83.69 146.12,84.89 145.98,85.03 143.82,85.03 143.54,85.31 143.54,89.12 142.57,90.1 142.57,92.32 142.56,92.33 142.56,92.34 142.51,92.4 142.51,92.41
  IN2 w0.122: v1(88.45,105.89) 88.45,105.87 88.91,105.4 89.67,105.4 91.77,107.5 101.63,107.5 103.54,105.59 110.46,105.59 113.76,102.29 121.26,102.29 122.23,103.26 133.34,103.26 136.27,100.33 137.92,100.33 139.99,98.26 139.99,95.69 140.75,94.93 141.48,94.93 142.51,93.91 142.51,92.41
  BOTTOM w0.076: UC1.CM11 152.47,84.89 152.72,84.64 153.24,84.64 153.34,84.54 153.49,84.48 153.75,84.48 153.86,84.53 154.89,84.53 155.01,84.41 155.79,84.41 156.21,84.83 156.21,85.01 v1(156.45,85.25)
  BOTTOM w0.127: v1(90.5,111) 89.92,111.58 JIRTS1.3
TS_INT#: length 124
  TOP w0.127: RV311.2 RV319.2 90.34,110.05 89.72,110.68 v1(89.72,111) ; v1(161.45,109.75) v3(160.66,109.75)
  IN2 w0.089: 153.66,92.41 153.66,88.15 155.53,86.28 156.81,86.28 157.72,85.37 v1(157.87,85.37)
  IN2 w0.122: v1(154.49,101.81) 154.72,101.57 154.72,100.24 156.86,98.11 156.86,95.06 156.47,94.67 155.24,94.67 153.66,93.09 153.66,92.41
  IN3 w0.122: v1(161.45,109.75) 161.45,111.27 160.9,111.82 158.01,111.82 157.89,111.69 153.87,111.69 152.46,110.28 151.42,110.28 151.15,110.55 146.75,110.55 146.02,111.28 138.99,111.28 138.13,112.15 136.57,112.15 136.51,112.08 112.95,112.08 110.83,109.97 106,109.97 105.24,110.74 103.4,110.74 102.1,109.44 91.5,109.44 89.95,111 v1(89.72,111)
  BOTTOM w0.076: v1(157.87,85.37) 157.61,85.63 155.46,85.63 154.95,85.12 153.83,85.12 153.71,85.16 153.53,85.16 153.41,85.12 153.18,85.12 153.06,85.16 152.85,85.16 152.84,85.17 152.17,85.17 152,85 UC1.CM12
  BOTTOM w0.127: v1(89.72,111) 89.12,111.59 JIRTS1.2 ; v1(154.49,101.81) 153.87,102.43 153.87,104.58 159.04,109.75 v1(161.45,109.75)
TYPEC_CON_SEL1: length 18.5
  TOP w0.127: v1(167.46,82.73) v2(167.46,83.5)
  IN2 w0.089: v1(159.39,83.84) 159.92,83.84 160.32,84.23 161.76,84.23
  IN2 w0.122: v1(167.46,82.73) 165.96,84.23 161.76,84.23
  BOTTOM w0.076: UC1.CN14 152.79,82.8 153.09,82.8 153.2,82.76 153.39,82.76 153.5,82.8 153.74,82.8 153.85,82.76 156.91,82.76 157.35,83.2
  BOTTOM w0.102: v1(159.39,83.84) 158.77,83.21 157.36,83.21 157.35,83.2
  BOTTOM w0.127: RC745.1 167.46,81.92 v1(167.46,82.73) 167.46,83.26 RC744.1
TYPEC_CON_SEL2: length 24.6
  TOP w0.127: RC63.1 173.92,86.07 RC743.1 173.29,85.44 173.29,85.01 v1(173.17,84.89)
  IN1 w0.102: v1(156.29,83.84) 156.66,84.21 162.3,84.21 162.52,83.99 170.38,83.99 171.24,84.84 173.12,84.84 v1(173.17,84.89)
  BOTTOM w0.076: UC1.CM14 152.4,83.34 153.59,83.34 153.79,83.45 154.17,83.45 154.36,83.25 155.71,83.25 v1(156.29,83.84)
TYPEC_ID: length 8.4
  TOP w0.102: CE62.1 275.3,72.9 275.3,75.48 276.3,76.48 276.3,78.23 UE1.F2
  TOP w0.127: RE343.2 273.98,73.29 CE62.1
UART_MISO: length 4.7
  TOP w0.089: v1(31.03,54.36) 31.03,54.58 v2(30.71,54.9)
  TOP w0.127: RT82.1 30.91,52.73 RT83.1 30.91,54.24 v1(31.03,54.36)
  BOTTOM w0.076: UT5.F2 31.27,56.44 31.02,56.19 31.02,55.84 31.02,55.83 31.02,55.74 31.03,55.73
  BOTTOM w0.127: 31.03,55.73 31.03,55.57 31.16,55.43 31.16,54.49 v1(31.03,54.36)
UART_MOSI: length 6
  TOP w0.089: v2(31.74,55.72) 32.15,55.32 v1(32.15,54.35)
  TOP w0.127: RT81.1 31.81,53.15 RT83.2 31.49,53.77 32.08,54.35 v1(32.15,54.35)
  BOTTOM w0.076: UT5.E2 32.01,56.25 32.01,56.1 32.02,56.09 32.02,55.88 31.9,55.76 31.9,54.88 32.14,54.64 32.14,54.4
  BOTTOM w0.127: v1(32.15,54.35) 32.14,54.36 32.14,54.4
UG1_CHG: length 8.1
  TOP w0.127: v1(48.13,67.48) v2(48.66,67.48)
  IN1 w1.016: 47.5,58.79 47.25,59.05 47.25,64.27 47.57,64.59 47.57,66.12 47.59,66.15
  vias: v1(47.61,57.26) v1(47.61,56.69) v1(48.13,66.9)
UG2_CHG: length 37.1
  IN4 w1.016: 51.5,54.16 52.46,54.16 53.74,55.44 53.74,56.61 54.92,57.79 54.92,58.5 56.22,59.8 56.22,62.07 64.79,70.65 64.79,75.89 64.13,76.55 62.52,76.55 60.5,78.57 60.5,81.41
  BOTTOM w0.127: v1(49.8,54.21) 49.21,54.21 v2(48.85,53.85)
  vias: v1(50.2,54.62) v1(60.76,82.92) v1(60.76,82.35)
UG_SA:
  vias: v1(96.31,98.04) v1(96.88,98.04)
UIM_CLK: length 52.9
  TOP w0.127: v1(300.81,54.16) 300.73,54.08 299.95,54.08 299.37,54.67 v2(299.05,54.67) 298.65,54.67 297.57,55.75 297.18,55.75 296.93,56 DZ13.2 DZ13.8 294.7,56 v1(294.37,56.32) 294.25,56.45 CZ38.1
  IN1 w0.084: v1(274.96,63.05) 275,63.01 275.74,63.01 276.63,62.12 278.02,62.12 278.7,61.44 280.98,61.44 282.79,59.62 282.79,58.42 284,57.21 288.91,57.21 289.1,57.4 289.1,57.95 289.91,58.76 291.49,58.76 291.84,58.4 291.84,56.77 292.41,56.21 294.26,56.21 v1(294.37,56.32)
  IN4 w0.084: v1(300.81,54.16) 300.92,54.04 305.19,54.04 307.77,56.62 307.77,58.18 306.9,59.05 301.09,59.05 v1(301.05,59.01)
  BOTTOM w0.127: v1(274.96,63.05) 274.93,63.08 274.93,63.35 274.93,63.35 JNGFF2.32 ; JSIM1.C3 301.47,58.59 v1(301.05,59.01)
UIM_DATA: length 56.1
  TOP w0.127: RZ335.2 292.35,56 292.41,55.94 293.26,55.94 CZ39.1 293.97,55.63 v1(294.37,55.63) 294.51,55.5 DZ13.9 DZ13.1 296.19,55.49 296.72,55.49 296.97,55.24 297.36,55.24 v2(297.51,55.09) 298.44,54.16 299.15,54.16 299.74,53.58 v1(300.81,53.58)
  IN1 w0.084: v1(274.99,62.45) 275.09,62.54 275.55,62.54 276.44,61.65 277.83,61.65 278.51,60.97 280.79,60.97 282.33,59.43 282.33,58.22 283.81,56.74 289.1,56.74 289.57,57.21 289.57,57.76 290.1,58.29 291.29,58.29 291.38,58.21 291.38,56.58 292.21,55.74 294.26,55.74 v1(294.37,55.63)
  IN4 w0.084: v1(314.71,58.73) 313.82,58.73 313.44,59.11 309.12,59.11 308.24,58.22 308.24,56.42 305.39,53.58 v1(300.81,53.58)
  BOTTOM w0.127: JSIM1.C7 314.95,58.49 v1(314.71,58.73) ; JNGFF2.34 275.43,62.88 v1(274.99,62.45)
UIM_RESET: length 37
  TOP w0.127: v1(290.96,57.92) 291.11,58.07 293.23,58.07 CZ40.1 294.31,57 DZ13.7 DZ13.4 297.25,57 v1(297.31,56.94)
  IN1 w0.084: v1(275.22,60.89) 275.72,61.4 277.82,61.4 278.01,61.21 278.01,59.19 278.09,59.11 280.64,59.11 283.19,56.56 289.39,56.56 289.63,56.32 290.43,56.32 290.51,56.4 290.51,57.73 290.7,57.92 v1(290.96,57.92)
  BOTTOM w0.127: JSIM1.C2 300.88,60.47 297.35,56.94 v1(297.31,56.94) ; v1(275.22,60.89) 274.43,61.68 JNGFF2.30
UPD1_SMBCLK: length 306.2
  TOP w0.127: UE1.C3 274.21,79.36 v1(273.82,78.96) ; v1(220.82,49.46) 220.98,49.3 220.98,48.78 220.86,48.66 218.51,48.66 209.15,58.02 194.38,58.02 194.15,57.78 192.63,57.78 192.41,58 192.41,58.32 v1(192.6,58.52) ; RE303.1 264.01,73.91 263.69,74.23 262.88,74.23 262.39,73.74 262.39,66.19 261.35,65.14 260.71,65.14 v1(260.55,64.98) ; RT58.1 38.4,58.03 39.07,58.03 v1(39.23,58.2)
  IN1 w0.084: v1(260.55,64.98) 260.73,65.17 261.13,65.17 262.34,66.39 262.34,75.73 264.29,77.67 264.29,79.11 265.59,80.41 270.03,80.41 270.43,80 272.17,80 272.87,79.31 273.47,79.31 v1(273.82,78.96)
  IN2 w0.122: v1(192.6,58.52) 192.44,58.35 192.44,57.39 189.14,54.1 186.6,54.1 185.62,53.11 185.62,50.18 182.87,47.43 158.78,47.43 156.61,45.26 139.11,45.26 135.62,48.75 84.17,48.75 80.63,45.2 59.43,45.2 58.81,44.59 53.75,44.59 52.21,43.04 44.98,43.04 40.33,47.69 40.33,48.4 38.87,49.87 38.87,51.08 39.44,51.66 39.44,53.93 39,54.37 39,54.95 38.45,55.5 38.45,57.72 38.76,58.03 39.07,58.03 v1(39.23,58.2) ; v1(260.55,64.98) 260.38,65.15 259.97,65.15 259.85,65.03 259.85,64.2 261.1,62.95 261.1,60.26 258.82,57.98 256.34,57.98 255.59,57.23 255.59,55.49 252.76,52.66 250.54,52.66 246.86,48.98 242.16,48.98 240.88,47.69 235.67,47.69 235.5,47.52 229.36,47.52 229.19,47.69 222.36,47.69 220.99,49.06 220.99,49.29 v1(220.82,49.46)
UPD1_SMBCLK_R: length 20.9
  TOP w0.127: RT58.2 37.05,58.03 36.29,58.03 36.16,58.16 RT67.2 35.91,58.16 v1(35.38,58.16)
  IN2 w0.122: v1(26.23,53.48) 26.23,54.19 27.98,55.94 32.65,55.94 34.04,57.33 34.55,57.33 v1(35.38,58.16)
  BOTTOM w0.076: 27.71,55.36 27.71,55.69 28.14,56.12 28.23,56.12 28.6,56.49 UT5.L2 ; 34.49,57.74 33.52,57.74 UT5.B5
  BOTTOM w0.127: v1(26.23,53.48) 26.23,53.88 27.71,55.36 ; 34.49,57.74 35.25,57.74 35.38,57.86 v1(35.38,58.16)
UPD1_SMBDAT: length 304.2
  TOP w0.127: v1(221.4,49.46) 221.24,49.3 221.24,48.68 220.96,48.4 v4(219.42,48.4) 218.4,48.4 209.04,57.76 194.49,57.76 194.25,57.52 192.52,57.52 192.15,57.89 192.15,58.38 v1(192.02,58.52) ; v1(39.23,57.61) 39.07,57.78 38.4,57.78 RT59.1 ; UE1.B4 273.4,80.16 v1(272.98,79.74) ; RE302.1 264.03,74.78 263.72,74.48 262.77,74.48 262.13,73.84 262.13,66.29 261.24,65.4 260.72,65.4 v1(260.55,65.57)
  IN1 w0.084: v1(272.98,79.74) 272.92,79.67 272.8,79.67 272.26,80.21 270.52,80.21 270.12,80.62 265.5,80.62 264.08,79.2 264.08,77.76 262.13,75.81 262.13,66.48 261.04,65.38 260.73,65.38 v1(260.55,65.57)
  IN2 w0.122: v1(39.23,57.61) 39.06,57.78 38.86,57.78 38.7,57.62 38.7,55.6 39.25,55.05 39.25,54.48 39.69,54.03 39.69,51.56 39.12,50.98 39.12,49.97 40.58,48.51 40.58,47.79 44.88,43.49 52.31,43.49 53.65,44.83 58.71,44.83 59.33,45.45 80.52,45.45 84.06,49 135.73,49 139.21,45.51 156.51,45.51 158.68,47.68 182.77,47.68 185.37,50.28 185.37,53.21 186.5,54.34 189.04,54.34 192.19,57.49 192.19,58.35 v1(192.02,58.52) ; v1(260.55,65.57) 260.38,65.4 259.87,65.4 259.6,65.13 259.6,64.1 260.85,62.85 260.85,60.37 258.71,58.23 256.23,58.23 255.34,57.33 255.34,55.59 252.66,52.91 250.44,52.91 246.76,49.23 242.06,49.23 240.77,47.94 235.57,47.94 235.4,47.77 229.46,47.77 229.29,47.94 222.46,47.94 221.24,49.16 221.24,49.29 v1(221.4,49.46)
UPD1_SMBDAT_R: length 23
  TOP w0.127: v1(34.83,58.35) 34.83,58.02 v2(35.1,57.75) 35.11,57.74 35.82,57.74 RT66.2 36.16,57.55 36.39,57.78 37.05,57.78 RT59.2
  IN2 w0.122: v1(26.23,52.71) 26.09,52.71 25.79,53.02 25.79,54.12 27.86,56.19 32.52,56.19 34.04,57.72 34.49,57.72 34.83,58.06 v1(34.83,58.35)
  BOTTOM w0.076: UT5.A5 34.58,57.99 ; 27.95,55.27 27.95,55.67 28.21,55.93 28.35,55.93 28.65,56.24 29.02,56.24 UT5.K2
  BOTTOM w0.127: 27.95,55.27 26.65,53.97 26.65,53.03 26.33,52.71 v1(26.23,52.71) ; 34.58,57.99 34.73,57.99 34.86,58.11 34.86,58.3 34.83,58.33 v1(34.83,58.35)
UPD1_SMBINT#: length 304.6
  TOP w0.127: RE91.1 263.02,84.32 v1(262.83,84.51) ; v1(276.17,85.39) 276.19,85.39 UE1.F10 ; v1(219.5,50.17) v2(218.61,50.17) 217.71,50.17 209.09,58.79 193.57,58.79 v1(193.22,58.45) ; v1(37.98,59.62) 37.28,59.62 37.15,59.49 RT60.1
  IN1 w0.084: v1(276.17,85.39) 276.01,85.23 275.85,85.23 275.64,85.01 274.89,85.01 274.89,85.01 271.86,85.01 271.12,85.75 270.23,85.75 270.09,85.89 268.11,85.89 267.86,86.14 265.52,86.14 265.41,86.02 264.34,86.02 v1(262.83,84.51)
  IN2 w0.122: v1(37.98,59.62) 37.92,59.56 37.92,55.3 38.46,54.76 38.46,53.11 38.74,52.83 38.74,51.94 37.85,51.05 37.85,47.3 38.36,46.79 39.38,46.79 39.69,47.11 40.2,47.11 44.77,42.54 52.42,42.54 53.96,44.08 59.02,44.08 59.64,44.7 80.83,44.7 84.38,48.24 135.32,48.24 138.81,44.76 156.82,44.76 158.99,46.93 183.08,46.93 186.12,49.97 186.12,52.9 186.81,53.59 189.35,53.59 193.05,57.29 193.05,58.27 v1(193.22,58.45) ; v1(262.83,84.51) 262.16,83.84 262.16,80.61 262.16,72.79 261.71,72.33 261.71,68.72 260.99,68 260.99,63.77 261.6,63.16 261.6,60.05 259.03,57.48 258.29,57.48 252.97,52.15 250.75,52.15 247.07,48.47 242.37,48.47 241.08,47.18 235.88,47.18 235.71,47.02 222.19,47.02 219.5,49.71 v1(219.5,50.17)
UPD1_SMBINT#_R: length 4.7
  TOP w0.127: v2(34.72,58.99) 34.8,58.99 v1(35.19,59.37) 35.5,59.37 35.63,59.49 RT60.2 RT68.2
  BOTTOM w0.076: UT5.B6 33.52,58.74 34.58,58.74
  BOTTOM w0.127: v1(35.19,59.37) 35.19,59.1 34.82,58.74 34.58,58.74
USB2_ID: length 12.5
  TOP w0.127: RC337.1 152.53,95.12 v1(152.47,95.05) 152.33,94.91 v2(151.86,94.91)
  IN4 w0.102: v1(148.72,86.77) 149.19,87.23 149.19,88.8 149.43,89.04 150.85,89.04 152.57,90.76 152.57,94.96 v1(152.47,95.05)
  BOTTOM w0.089: v1(148.72,86.77) UC1.CE8
USB3_PRX_DTX_N2: length 215.3
  TOP w0.104: v1(297.17,83.24) 297.05,83.12 295.87,83.12 295.72,83.28 DI4.9 DI4.1 294.06,83.28 293.9,83.12 293.56,83.12 v1(293.36,83.32)
  IN1 w0.084: 147.36,90.24 147.36,90.22 147.37,90.21 147.37,89.75 147.23,89.62 147.23,85.98 147.02,85.77 146.72,85.77 146.51,85.98 146.51,86.31 146.33,86.49 146.22,86.49 v1(145.95,86.77)
  IN1 w0.094: JUSB1.5 302.61,86.42 302.51,86.32 301.98,86.32 301.38,85.72 300.3,85.72 297.63,83.05 297.36,83.05 v1(297.17,83.24) ; v1(293.36,83.32) 293.16,83.12 292.89,83.12 292.69,82.92 292.69,81.96 293.02,81.63 293.02,77.28 292.55,76.82 292.55,75.32 290.16,72.93 290.16,71.78 288.49,70.11 286.39,70.11 285.02,68.73 274.78,68.73 273.78,67.73 271.58,67.73 271.17,67.33 267.13,67.33 265.63,65.82 265.63,63.68 263.55,61.6 263.55,60.71 256.17,53.33 255.82,53.33 253.05,50.56 250.21,50.56 247.49,47.84 242.09,47.84 240.71,46.46 224.11,46.46 222.81,47.76 218.27,47.76 202.32,63.71 202.32,66.14 198.79,69.67 198.79,70.29 196.77,72.31 196.63,72.31 195.64,73.3 195.64,73.92 190.2,79.36 188.04,79.36 185.6,81.81 184.28,81.81 183.94,82.15 183.94,83.43 183.38,83.98 183.38,85.08 179.45,89.02 179.45,90.27 179.12,90.6 177.65,90.6 175.9,92.35 171.63,92.35 166.83,97.14 157.47,97.14 151.64,91.31 148.09,91.31 147.36,90.58 147.36,90.24
  BOTTOM w0.089: UC1.BY8 145.66,86.61 v1(145.95,86.77)
USB3_PRX_DTX_N3: length 228.7
  TOP w0.104: v1(20.91,40.23) 21.09,40.41 22.3,40.41 22.46,40.26 DI1.9 DI1.1 24.18,40.26 24.26,40.34 24.26,40.48 24.34,40.56 24.65,40.56 25.06,40.15 25.38,40.15 25.61,39.92 25.61,39.62 25.44,39.45 25.33,39.45 v1(25.23,39.55)
  IN1 w0.084: 146.81,90.24 146.81,90.22 146.81,90.21 146.81,89.12 146.51,88.82 146.51,87.76 146.32,87.57 146.12,87.57 v1(145.95,87.4)
  IN1 w0.094: 146.81,90.24 146.81,96.28 147.99,97.46 147.99,106.43 142.82,111.59 138.91,111.59 138.16,112.35 110.37,112.35 109.78,111.76 106.47,111.76 105.88,112.35 88.45,112.35 86.45,110.35 79.11,110.35 77.69,111.77 53.58,111.77 50.56,108.74 49.51,108.74 47.78,107.01 46.89,107.01 42.3,102.42 39.82,102.42 37.43,100.03 37.43,98.41 36.88,97.86 36.88,97.18 36.32,96.61 36.32,93.51 35.71,92.9 35.71,92.24 33.56,90.09 32.44,90.09 30.61,88.26 28.58,88.26 27.73,87.4 27.73,86.24 26.21,84.72 24.36,84.72 23.19,83.56 23.19,82.47 22.64,81.92 22.64,72.66 23.54,71.76 23.54,62.05 25.25,60.35 25.25,57.43 25.89,56.79 25.89,53.92 25.67,53.71 25.67,48.71 28.49,45.89 28.49,41.6 27.4,40.51 25.47,40.51 25.23,40.27 v1(25.23,39.55)
  IN4 w0.094: JUSB2.5 14.85,38.56 14.95,38.66 15.56,38.66 15.95,39.05 18.81,39.05 20.17,40.41 20.72,40.41 v1(20.91,40.23)
  BOTTOM w0.076: v1(145.95,87.4) UC1.BY7
USB3_PRX_DTX_N4: length 134.6
  TOP w0.104: v1(235.97,44.7) 235.57,44.31 235.57,42.53 236.08,42.03 v4(238.92,42.03) 240.97,42.03 241.3,42.37 241.68,42.37 241.78,42.47 241.78,42.52 241.93,42.67 UZ29.18
  IN1 w0.084: 148.52,90.24 148.18,89.9 148.18,85.8 147.62,85.24 145.08,85.24 144.63,85.68 144.63,88.23 144.73,88.32 144.91,88.32 145.03,88.21 v1(145.03,88.04)
  IN1 w0.094: v1(235.97,44.7) 235.72,44.94 235.72,45.52 235.52,45.72 223.8,45.72 222.5,47.02 217.97,47.02 201.58,63.41 201.58,65.48 192.59,74.48 191.85,74.48 185.25,81.07 183.98,81.07 183.2,81.85 183.2,82.53 180.72,85.01 180.72,86.49 175.6,91.61 168.36,91.61 165.58,94.4 162.2,94.4 159.17,91.37 153.99,91.37 153.2,90.58 148.86,90.58 148.52,90.24
  BOTTOM w0.089: v1(145.03,88.04) 144.74,87.9 UC1.BW6
USB3_PRX_DTX_P2: length 215.3
  TOP w0.104: v1(297.17,82.66) 296.9,82.93 295.87,82.93 295.72,82.78 DI4.8 DI4.2 294.05,82.78 293.89,82.93 293.56,82.93 v1(293.36,82.73)
  IN1 w0.084: 147.55,90.24 147.55,90.22 147.54,90.21 147.54,89.68 147.4,89.54 147.4,85.91 147.09,85.6 146.65,85.6 146.34,85.91 146.34,86.24 146.26,86.32 146.14,86.32 v1(145.95,86.13)
  IN1 w0.094: v1(293.36,82.73) 293.16,82.94 292.96,82.94 292.87,82.84 292.87,82.04 293.2,81.7 293.2,77.21 292.73,76.74 292.73,75.24 290.35,72.85 290.35,71.71 288.57,69.93 286.47,69.93 285.09,68.55 274.85,68.55 273.85,67.55 271.66,67.55 271.25,67.14 267.21,67.14 265.81,65.74 265.81,63.6 263.73,61.53 263.73,60.64 256.24,53.14 255.89,53.14 253.12,50.37 250.28,50.37 247.56,47.65 242.16,47.65 240.79,46.28 224.03,46.28 222.73,47.57 218.2,47.57 202.13,63.64 202.13,66.06 198.6,69.59 198.6,70.22 196.69,72.13 196.55,72.13 195.46,73.22 195.46,73.84 190.12,79.18 187.97,79.18 185.52,81.62 184.21,81.62 183.75,82.08 183.75,83.35 183.2,83.91 183.2,85.01 179.26,88.94 179.26,90.19 179.04,90.41 177.58,90.41 175.83,92.16 171.55,92.16 166.76,96.95 157.54,96.95 151.72,91.13 148.17,91.13 147.55,90.51 147.55,90.24 ; v1(297.17,82.66) 297.38,82.87 297.71,82.87 300.37,85.54 301.45,85.54 302.06,86.14 302.51,86.14 302.61,86.04 JUSB1.6
  BOTTOM w0.089: v1(145.95,86.13) 145.66,85.97 UC1.BY9
USB3_PRX_DTX_P3: length 228.7
  TOP w0.104: v1(25.8,39.2) 25.8,40 25.46,40.34 25.14,40.34 24.73,40.76 DI1.2 DI1.8 22.47,40.76 22.31,40.6 21.12,40.6 v1(20.91,40.81)
  IN1 w0.084: 146.63,90.24 146.63,90.22 146.63,90.21 146.63,89.2 146.34,88.9 146.34,87.83 146.24,87.74 146.07,87.74 145.95,87.86 v1(145.95,88.04)
  IN1 w0.094: v1(25.8,39.2) 25.8,39.3 25.8,39.3 25.8,39.78 25.71,39.87 25.51,39.87 25.41,39.97 25.41,40.19 25.55,40.33 27.48,40.33 28.68,41.52 28.68,45.97 25.86,48.79 25.86,53.63 26.07,53.84 26.07,56.87 25.43,57.51 25.43,60.43 23.73,62.13 23.73,71.84 22.82,72.74 22.82,81.85 23.38,82.4 23.38,83.49 24.43,84.54 26.29,84.54 27.91,86.16 27.91,87.33 28.66,88.07 30.68,88.07 32.52,89.91 33.63,89.91 35.89,92.17 35.89,92.82 36.5,93.43 36.5,96.54 37.07,97.1 37.07,97.79 37.61,98.33 37.61,99.95 39.89,102.24 42.37,102.24 46.96,106.83 47.85,106.83 49.59,108.56 50.63,108.56 53.66,111.58 77.61,111.58 79.03,110.17 86.53,110.17 88.53,112.17 105.8,112.17 106.39,111.58 109.86,111.58 110.45,112.17 138.08,112.17 138.84,111.41 142.75,111.41 147.8,106.35 147.8,97.54 146.63,96.36 146.63,90.24
  IN4 w0.094: v1(20.91,40.81) 20.7,40.6 20.1,40.6 18.73,39.23 15.87,39.23 15.49,38.84 14.95,38.84 14.85,38.94 JUSB2.6
  BOTTOM w0.089: UC1.BY6 145.66,87.9 v1(145.95,88.04)
USB3_PRX_DTX_P4: length 134.7
  TOP w0.104: UZ29.19 241.38,42.17 241.05,41.84 239.19,41.84 239.18,41.83 238.66,41.83 238.65,41.84 236,41.84 235.38,42.45 v1(235.38,44.7)
  IN1 w0.084: v1(145.02,88.67) 144.85,88.5 144.66,88.5 144.46,88.3 144.46,85.61 145.01,85.06 147.69,85.06 148.36,85.73 148.36,89.83 148.59,90.06 148.6,90.06 148.63,90.1 148.64,90.1 148.78,90.24
  IN1 w0.094: v1(235.38,44.7) 235.54,44.86 235.54,45.45 235.45,45.54 223.73,45.54 222.43,46.84 217.89,46.84 201.4,63.33 201.4,65.41 192.51,74.3 191.77,74.3 185.18,80.89 183.9,80.89 183.02,81.77 183.02,82.45 180.54,84.93 180.54,86.42 175.52,91.43 168.28,91.43 165.5,94.21 162.27,94.21 159.25,91.19 154.07,91.19 153.28,90.39 148.94,90.39 148.78,90.24
  BOTTOM w0.089: UC1.BW5 144.74,88.54 v1(145.02,88.67)
USB3_PTX_C_DRX_N2: length 11.1
  TOP w0.104: v1(297.17,81.4) 296.17,81.4 295.79,81.78 DI4.7 DI4.4 294.13,81.78 293.88,81.53 293.27,81.53 CI13.1
  IN1 w0.094: v1(297.17,81.4) 297.49,81.08 301.51,81.08 302.08,80.51 302.51,80.51 302.61,80.61 JUSB1.8
USB3_PTX_C_DRX_N3: length 12.6
  TOP w0.104: CI5.1 24.76,41.91 24.75,41.91 24.7,41.96 24.26,41.96 24.05,41.76 DI1.4 DI1.7 22.43,41.76 22.28,41.9 21.13,41.9 v1(20.91,41.69)
  IN4 w0.094: JUSB2.8 14.85,44.56 14.95,44.66 15.34,44.66 16.12,43.88 18.48,43.88 20.44,41.91 20.68,41.91 v1(20.91,41.69)
USB3_PTX_C_DRX_N4: length 1.9
  TOP w0.104: CZ151.2 241.23,43.55 241.74,43.55 241.87,43.67 UZ29.16
USB3_PTX_C_DRX_P2: length 11.2
  TOP w0.104: CI16.1 293.36,81.33 293.89,81.33 293.94,81.28 DI4.5 DI4.6 296.02,81.28 296.09,81.21 296.75,81.21 v1(297.17,80.78)
  IN1 w0.094: JUSB1.9 302.61,79.72 301.43,80.9 297.29,80.9 v1(297.17,80.78)
USB3_PTX_C_DRX_P3: length 12.6
  TOP w0.104: CI4.1 24.66,42.16 24.14,42.16 24.04,42.26 DI1.5 DI1.6 22.43,42.26 22.27,42.1 21.09,42.1 v1(20.91,42.27)
  IN4 w0.094: v1(20.91,42.27) 20.74,42.1 20.52,42.1 18.55,44.06 16.2,44.06 15.42,44.84 14.95,44.84 14.85,44.94 JUSB2.9
USB3_PTX_C_DRX_P4: length 1.9
  TOP w0.104: CZ150.2 241.2,43.35 241.76,43.35 241.94,43.17 UZ29.17
USB3_PTX_DRX_N2: length 201.8
  TOP w0.104: CI13.2 291.6,81.51 291.33,81.51 v1(291.14,81.71)
  IN1 w0.094: v1(148.36,99.34) 149.33,99.34 149.49,99.18 149.49,98.64 149.96,98.16 154.5,98.16 154.98,97.69 167.06,97.69 171.02,93.73 175.51,93.73 177.81,91.43 179.06,91.43 180,90.5 180,89.28 183.95,85.33 183.95,84.2 184.96,83.19 187.15,83.19 199.4,70.93 199.4,69.83 203,66.24 203,63.81 218.5,48.31 223.04,48.31 224.34,47.01 240.48,47.01 241.86,48.39 247.26,48.39 249.98,51.11 252.81,51.11 255.69,53.98 255.99,53.98 262.91,60.9 262.91,61.79 265.07,63.95 265.07,66.05 267.31,68.28 272.67,68.28 273.67,69.28 284.79,69.28 286.16,70.66 288.26,70.66 289.61,72.01 289.61,73.16 292,75.54 292,77.12 292.47,77.58 292.47,81.1 291.86,81.71 v1(291.14,81.71)
  BOTTOM w0.076: 147.85,96.67 147.82,96.64 147.82,96.37 146.6,95.16 146.6,94.01 146.16,93.57 146.16,92.41 145.64,91.9 145.64,91.59 145.87,91.37 145.87,91.06 UC1.CA2
  BOTTOM w0.104: 147.85,96.67 v4(147.85,97.72) 147.85,98.82 v1(148.36,99.34)
USB3_PTX_DRX_N3: length 215.7
  TOP w0.104: v1(27.63,41.66) 27.33,41.96 26.27,41.96 CI5.2
  IN1 w0.094: v1(148.36,101.24) 148.82,101.45 149.02,101.65 149.02,103.73 149.1,103.81 149.1,106.36 144.17,111.29 144.17,111.97 143.05,113.08 110.07,113.08 109.48,112.49 106.77,112.49 106.18,113.08 88.15,113.08 86.15,111.08 79.41,111.08 77.99,112.5 53.28,112.5 50.25,109.48 48.02,109.48 43.41,104.87 42.33,104.87 41.14,103.68 39.77,103.68 36.15,100.06 36.15,97.81 35.59,97.25 35.59,93.84 34.91,93.16 34.91,92.6 33.14,90.83 31.49,90.83 29.65,88.99 28.28,88.99 26.99,87.71 26.99,86.58 25.87,85.46 24.05,85.46 22.46,83.87 22.46,82.78 21.91,82.23 21.91,71.6 22.61,70.89 22.61,61.81 24.51,59.9 24.51,56.96 25.15,56.32 25.15,54.22 24.94,54.01 24.94,48.81 24.49,48.36 24.49,43.13 25.96,41.66 v1(27.63,41.66)
  BOTTOM w0.076: 147.09,98.35 147.09,98.33 147.08,98.32 147.08,96.27 146.09,95.28 146.09,94.2 145.73,93.83 145.73,92.62 145.15,92.04 145.15,90.96 145.27,90.84 145.27,90.57 145.32,90.52 145.32,90.04 145.05,89.77 UC1.BY4
  BOTTOM w0.104: 147.09,98.35 v4(147.09,100.44) 147.09,101.11 147.33,101.34 148.27,101.34 v1(148.36,101.24)
USB3_PTX_DRX_N4: length 157.6
  TOP w0.104: CZ151.1 239.35,43.39 239.21,43.39 239.07,43.52 239.07,44.24 v1(239.46,44.64)
  IN4 w0.094: v1(145.97,97.98) 145.71,97.98 145.61,97.89 145.61,97.72 145.42,97.53 144.85,97.53 144.22,96.91 143.06,96.91 142.68,97.29 142.68,103.24 144.17,104.72 145.63,104.72 146.41,105.5 149.5,105.5 149.83,105.84 154.72,105.84 156.3,107.41 162,107.41 162.6,108.02 165.3,108.02 170.68,102.64 173.08,102.64 174.02,101.7 174.69,101.7 178.77,97.62 178.77,96.95 180.43,95.29 180.43,94.23 181.45,93.21 181.45,89.47 184.95,85.97 185.71,85.97 186.03,85.65 186.03,83.66 186.37,83.31 187.36,83.31 189.66,81.01 190.35,81.01 198.19,73.17 198.19,64.18 215.21,47.16 216.97,47.16 219.83,44.29 223.1,44.29 223.52,43.87 231.5,43.87 232.41,42.97 238.22,42.97 239.26,44.01 239.26,44.44 v1(239.46,44.64)
  BOTTOM w0.076: v1(145.97,97.98) 146.55,97.98 146.75,97.79 146.75,96.45 145.59,95.28 145.59,94.33 145.28,94.02 145.28,92.82 144.79,92.32 144.79,91.14 UC1.BW2
USB3_PTX_DRX_P2: length 201.8
  TOP w0.104: CI16.2 291.54,81.32 291.33,81.32 v1(291.14,81.13)
  IN1 w0.094: v1(148.36,99.97) 148.63,99.97 148.72,99.88 148.72,99.65 148.85,99.52 149.4,99.52 149.67,99.26 149.67,98.72 150.04,98.35 154.58,98.35 155.05,97.87 167.14,97.87 171.1,93.91 175.59,93.91 177.88,91.62 179.14,91.62 180.18,90.57 180.18,89.35 184.13,85.4 184.13,84.27 185.04,83.37 187.23,83.37 199.59,71.01 199.59,69.91 203.18,66.31 203.18,63.89 218.58,48.49 223.11,48.49 224.41,47.19 240.41,47.19 241.78,48.57 247.18,48.57 249.9,51.29 252.74,51.29 255.61,54.16 255.91,54.16 262.73,60.98 262.73,61.86 264.89,64.03 264.89,66.12 267.24,68.47 272.59,68.47 273.59,69.47 284.71,69.47 286.09,70.84 288.19,70.84 289.43,72.09 289.43,73.23 291.82,75.62 291.82,77.19 292.28,77.66 292.28,81.03 291.78,81.53 291.54,81.53 291.44,81.43 291.44,81.24 291.32,81.13 v1(291.14,81.13)
  BOTTOM w0.076: UC1.CA1 145.62,91.38 145.48,91.52 145.48,91.97 145.99,92.48 145.99,93.64 146.44,94.08 146.44,95.22 147.66,96.44 147.66,96.71 147.66,96.71 147.66,96.72
  BOTTOM w0.104: v1(148.36,99.97) 147.98,99.59 147.98,99.23 147.66,98.9 147.66,98.04 147.62,98 147.62,97.41 147.66,97.38 147.66,96.72
USB3_PTX_DRX_P3: length 215.6
  TOP w0.104: CI4.2 26.31,42.16 27.42,42.16 v1(27.63,42.37)
  IN1 w0.094: v1(148.36,101.88) 148.61,101.63 148.74,101.63 148.84,101.73 148.84,102.95 148.74,103.04 148.63,103.04 148.54,103.14 148.54,103.32 148.63,103.42 148.74,103.42 148.84,103.51 148.84,103.81 148.91,103.88 148.91,106.28 143.99,111.21 143.99,111.89 142.98,112.9 110.14,112.9 109.55,112.31 106.7,112.31 106.11,112.9 88.23,112.9 86.23,110.9 79.33,110.9 77.92,112.32 53.35,112.32 50.33,109.29 48.09,109.29 43.48,104.68 42.4,104.68 41.22,103.5 39.85,103.5 36.33,99.99 36.33,97.74 35.77,97.17 35.77,93.76 35.1,93.08 35.1,92.53 33.21,90.64 31.57,90.64 29.73,88.81 28.35,88.81 27.18,87.63 27.18,86.51 25.95,85.28 24.13,85.28 22.64,83.79 22.64,82.7 22.09,82.15 22.09,71.67 22.79,70.97 22.79,61.88 24.7,59.98 24.7,57.03 25.33,56.39 25.33,54.15 25.12,53.94 25.12,48.73 24.67,48.28 24.67,43.21 26.04,41.85 26.93,41.85 27.02,41.94 27.02,42.42 27.18,42.59 27.42,42.59 v1(27.63,42.37)
  BOTTOM w0.076: 146.9,98.35 146.9,98.33 146.91,98.32 146.91,96.34 145.93,95.35 145.93,94.27 145.56,93.9 145.56,92.68 144.99,92.11 144.99,90.89 145.1,90.77 145.1,90.6 145.03,90.52 144.87,90.52 144.79,90.45 144.79,90.27 144.87,90.19 145.05,90.19 UC1.BY3
  BOTTOM w0.104: v1(148.36,101.88) 148.02,101.53 147.25,101.53 146.9,101.19 146.9,100.71 146.89,100.7 146.89,100.18 146.9,100.17 146.9,98.35
