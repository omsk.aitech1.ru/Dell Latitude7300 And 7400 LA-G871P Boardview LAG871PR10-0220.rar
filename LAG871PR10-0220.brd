# Allegro board LAG871PR10-0220.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AR_DP1_P3: length 33.5
  IN2 w0.102: v1(24.81,83.61) 24.6,83.81 23.55,83.81 21.49,81.76 21.49,78.36 20.71,77.58 20.71,72 23.69,69.02 23.69,63.94 22.17,62.41 22.17,59.43 21.66,58.92 21.35,58.92 v1(21.22,58.78)
  BOTTOM w0.089: v1(24.81,83.61) 25.3,83.11 25.3,82.86 25.17,82.73 25.17,82.27 25.37,82.07 UT1.J2
  BOTTOM w0.114: CV37.2 20.27,58.93 20.47,58.93 20.64,58.76 CT204.1 20.82,58.93 21.07,58.93 v1(21.22,58.78)
AUD_HP_NB_SENSE: length 54.9
  TOP w0.254: v1(299.15,39.87) v3(299.88,39.14) 301.44,37.59 301.44,33.9 302.77,32.57 306.9,32.57 307.26,32.93 JHP1.6 ; v1(274.62,45.21) 274.31,45.51 RA60.2
  IN2 w0.254: v1(299.85,46.12) 298.41,46.12 v1(294.32,42.03)
  BOTTOM w0.254: v1(299.85,46.12) 300.39,46.12 DA2.2 300.88,43.54 300.4,43.06 300.4,41.12 v1(299.15,39.87) ; v1(274.62,45.21) 276.87,45.21 278.39,46.73 283.11,46.73 284.33,45.51 284.33,45.23 284.93,44.63 284.93,42.09 285.44,41.59 286.15,41.59 287.1,40.63 292.92,40.63 v1(294.32,42.03)
AUD_HP_OUT_L: length 11.1
  TOP w0.127: v1(289.19,38.22) v2(289.93,38.22)
  TOP w0.381: v1(295.92,37.4) 296.79,38.26 LA15.1 ; RA7.2 288.54,38.74 289.06,38.22 v1(289.19,38.22)
  IN1 w0.381: v1(289.19,38.22) 290.01,37.4 v1(295.92,37.4)
AUD_HP_OUT_L1: length 17.3
  TOP w0.127: v1(299.41,36.63) 299.6,36.63 300.11,37.14 v3(300.23,37.14)
  TOP w0.381: v1(299.41,36.63) 298.66,37.38 CA3.2 298.23,37.41 LA15.2
  BOTTOM w0.381: JHP1.1 303.91,43.55 302.58,43.55 301,41.97 301,38.6 300.23,37.84 298.9,37.84 298.33,37.27 298.33,35.85 DA1.2 298.32,35.86 299.09,36.63 v1(299.41,36.63)
AUD_HP_OUT_R: length 10.1
  TOP w0.127: v1(289.63,35.8) 290.04,35.39 v2(290.37,35.39)
  TOP w0.381: RA8.2 v1(289.63,35.8) ; v1(295.92,36.7) 296.98,35.64 LA16.1
  IN1 w0.381: v1(289.63,35.8) 290.12,35.8 291.03,36.7 v1(295.92,36.7)
AUD_HP_OUT_R1: length 17.3
  TOP w0.127: v3(300.23,35.43) 299.8,35.43 v1(299.41,35.82)
  TOP w0.381: LA16.2 298.23,36.49 CA2.2 298.44,36.52 299.14,35.82 v1(299.41,35.82)
  BOTTOM w0.381: JHP1.2 310.01,32.94 309.57,32.51 301.96,32.51 301.12,33.34 301.12,35.45 300.74,35.83 DA1.3 299.47,35.83 299.46,35.82 v1(299.41,35.82)
AUD_PC_BEEP: length 21
  TOP w0.127: v1(287.98,56) 287.98,55.84 v2(287.67,55.53)
  TOP w0.203: UA1.34 284.88,41.84 285.27,42.23 v1(285.51,42.23) ; CA27.2 CA28.2 287.67,56.31 v1(287.98,56)
  IN1 w0.203: v1(286.9,47.05) 286.39,46.54 286.39,43.11 v1(285.51,42.23)
  BOTTOM w0.203: v1(287.98,56) 288.74,55.24 288.99,55.24 289.63,54.6 289.63,53.08 287.6,51.05 287.6,49.35 287.98,48.97 287.98,47.68 287.34,47.05 v1(286.9,47.05)
AUD_PWR_EN: length 231.5
  TOP w0.127: RC279.1 180.09,62.03 v1(180.24,62.18) ; UZ5.3 294.23,49.08 294.48,48.83 v1(294.71,48.83) 294.83,48.83 295.03,49.03 UZ5.5 ; v1(155.22,65.93) 155.14,65.85 155.14,65.14 v2(154.64,64.65)
  IN1 w0.084: v1(289.76,22.73) 289.76,24.98 286.98,27.76 237.77,27.76 235.55,29.97 233.5,29.97 229.81,26.29 226.88,26.29 224.6,28.57 224.6,28.8 223.16,30.24 219.82,30.24 217.4,32.66 207.64,32.66 207.12,33.18 207.12,34.75 207,34.87 207,35.55 207.46,36.01 207.46,40.54 199.05,48.94 197.63,48.94 195.1,51.47 193.56,51.47 191.52,53.51 190.74,53.51 189.21,55.04 188.44,55.04 184.17,59.31 184.17,61.23 183.48,61.92 182.43,61.92 182.02,61.51 180.79,61.51 180.24,62.05 v1(180.24,62.18)
  IN2 w0.122: v1(289.76,22.73) 289.76,23.17 285.18,27.74 280.59,27.74 276.46,31.87 276.46,32.41 274.89,33.98 274.89,34.47 275.85,35.44 275.85,37.2 275.5,37.55 275.5,39.78 275.85,40.13 275.85,41.52 275.66,41.71 275.66,42.22 275.15,42.73 275.15,44.33 275.79,44.96 275.79,46.09 277.25,47.56 280.68,47.56 282,48.88 282,50.53 282.39,50.92 290.2,50.92 292.87,48.25 294.27,48.25 294.71,48.7 v1(294.71,48.83) ; v1(180.24,62.18) 179.86,62.57 179,62.57 178.67,62.9 176.42,62.9 175.44,63.88 174.86,63.88 174.6,64.14 166.57,64.14 165.78,64.93 161.31,64.93 161.06,65.18 156.52,65.18 155.77,65.93 v1(155.22,65.93)
  BOTTOM w0.076: UC1.CK36 151.21,69.12 151.21,68.81 151.4,68.36 151.4,68.09 153.56,65.93
  BOTTOM w0.114: 153.56,65.93 v1(155.22,65.93)
AUD_SENSE_A: length 5.4
  TOP w0.203: CA41.1 276.37,44.63 277.07,43.94 v2(277.26,43.94) 278.96,43.94 279.12,43.78 UA1.48
  TOP w0.254: CA41.1 276.37,45.09 RA59.2 275.71,45.49 RA60.1
AUD_SENSE_B: length 2.8
  TOP w0.203: RA61.1 277.93,44.52 v2(278.56,44.52) 278.78,44.29 279.11,44.29 279.52,43.89 UA1.47
AUX_EN_WOWL: length 76.9
  TOP w0.127: v1(274.62,78.96) UE1.D3
  IN3 w0.122: v1(283.06,72.16) 282.55,72.16 281.63,71.24 281.63,68.96 280.59,67.92 280.59,65.43 280.23,65.07 280.23,61.87 281.46,60.65 281.46,58.43 281.63,58.25 281.63,57.74 280.68,56.79 280.68,55.01 280.05,54.39 278.16,54.39 276.9,53.13 275.26,53.13 274.64,52.51 274.64,51.39 272.49,49.24 272.49,48.23 272.27,48.01 272.27,43.95 270.83,42.51 269.14,42.51 268.63,42 265.22,42 262.33,39.12 261.12,39.12 259.55,37.54 257.18,37.54 256.4,36.76 254.06,36.76 253.94,36.88 v1(253.94,37.15)
  IN4 w0.084: v1(283.06,72.16) 282.69,72.54 278.52,72.54 276.56,74.5 276.56,77.85 275.92,78.48 275.09,78.48 v1(274.62,78.96)
  BOTTOM w0.127: DZ9.2 251.21,38.58 RZ379.2 251.09,37.6 RZ1483.2 251.22,37.46 RZ70.1 251.94,37.37 252.42,36.89 252.67,36.89 253.24,37.46 253.64,37.46 v1(253.94,37.15)
BAT1_LED#: length 174.7
  TOP w0.102: v1(309.92,11.9) v2(309.92,11.38)
  TOP w0.127: UE1.D10 274.67,85.31 v1(274.67,85.39)
  IN2 w0.254: v1(276.93,34.66) 277.11,34.49 277.11,32.14 280.68,28.57 285.38,28.57 290.46,23.49 290.97,23.49 292.17,22.29 292.17,19.22 292.54,18.85 297.06,18.85 298.42,17.49 304.32,17.49 v1(309.92,11.9)
  IN4 w0.254: v1(276.93,34.66) 276.93,35.93 275.39,37.47 275.39,39.44 274.33,40.51 274.33,41.46 272.48,43.3 272.48,45.59 274.39,47.49 275.6,47.49 275.61,47.51 275.85,47.51 276.12,47.78 276.12,48.02 277.44,49.33 280.04,49.33 281.07,50.36 282.08,50.36 282.53,50.81 284.47,50.81 285.11,50.17 287.93,50.17 287.99,50.24 291.86,50.24 293.72,52.09 296.96,52.09 300.05,55.18 300.05,70.1 298.96,71.18 298.96,84.18 296.36,86.79 296.36,89.64 298.81,92.09 298.81,94.76 296.91,96.66 296.91,98.3 296,99.21 292.05,99.21 291.12,98.28 288.77,98.28 288.34,97.85 287.69,97.85 286.99,97.15 276.87,97.15 274.64,94.92 274.64,88.51 274.24,88.11 274.24,85.82 v1(274.67,85.39)
  BOTTOM w0.254: v1(309.92,11.9) 309.43,11.41 RZ28.1
BAT1_LED#_R: length 10.9
  TOP w0.127: v1(305.26,14.61) 304.82,14.17 v2(303.68,14.17) 303.54,14.31 300.86,14.31 QZ21.1
  BOTTOM w0.127: v1(305.26,14.61) 305.44,14.44 QZ3.2
BAT2_LED#: length 177.4
  TOP w0.127: UE1.D11 275,85.76 274.7,86.06 v1(274.7,86.16)
  TOP w0.254: RZ361.1 311.18,7.78 v1(311.18,8.08)
  IN2 w0.254: v1(311.18,8.08) 311.18,9.99 304.06,17.11 294.73,17.11 293.63,18.22 292.63,18.22 291.66,19.19 291.66,22.29 290.85,23.11 290.3,23.11 285.22,28.19 280.55,28.19 276.75,31.99 276.75,32.94 275.85,33.84 275.85,34.67 276.23,35.05 v1(276.42,35.05)
  IN4 w0.254: v1(274.7,86.16) 274.7,86.66 274.99,86.96 274.99,94.77 277.01,96.79 287.14,96.79 287.84,97.49 288.49,97.49 288.92,97.92 291.27,97.92 292.19,98.85 295.84,98.85 296.55,98.14 296.55,96.51 298.46,94.61 298.46,92.31 295.94,89.8 295.94,86.7 298.61,84.04 298.61,71.03 299.63,70.01 299.63,55.26 296.81,52.44 293.44,52.44 291.59,50.59 287.84,50.59 287.78,50.53 285.25,50.53 284.62,51.16 282.38,51.16 281.93,50.72 280.92,50.72 279.89,49.69 277.16,49.69 276.61,49.14 273.88,49.14 272.04,47.3 272.04,42.98 273.82,41.21 273.82,40.44 274.96,39.3 274.96,37.4 276.42,35.94 v1(276.42,35.05)
BATGONE_CHG: length 8.2
  TOP w0.127: PR723.1 40.7,48.67 v2(40.7,47.19)
  TOP w0.203: PR724.2 42.12,50.06 42.6,50.54 43.33,50.54 44.2,51.42 45.32,51.42 45.53,51.62 PU700.25
  TOP w0.254: PR723.1 41.25,49.22 PC744.1 42.14,49.26 42.14,50.01 PR724.2
BATT_WHITE#: length 2.5
  TOP w0.102: v1(309.58,5.9) v2(309.58,5.39)
  TOP w0.254: v1(309.58,5.9) 309.2,6.28 RZ361.2
  BOTTOM w0.254: JLED1.2 v1(309.58,5.9)
BATT_YELLOW#: length 6.6
  BOTTOM w0.254: JLED1.3 v2(310.08,9.2) 310.08,9.71 309.29,10.5 RZ28.2 307.28,10.5 QZ3.3
BC_CLK_ECE1117: length 88.6
  TOP w0.127: UE1.D13 274.87,87.5 274.87,87.84 273.37,89.34 v4(272.79,89.34) 272.02,89.34 271.5,89.86 271.28,89.86 v1(270.96,90.18)
  IN2 w0.122: v1(249.29,35.63) 248.9,35.24 248.9,34.98 249.02,34.86 249.88,34.86 250.64,35.62 252.03,35.62 252.36,35.29 257.11,35.29 257.63,35.81 260.63,35.81 261.52,36.7 266.13,36.7 267.34,37.9 267.34,40.27 270.11,43.04 270.11,45.06 270.39,45.34 270.39,47.09 269.47,48 269.47,50.48 270.97,51.98 270.97,53.25 272.36,54.65 272.36,57.08 272.03,57.41 272.03,58.42 272.51,58.89 272.51,59.85 273.43,60.78 273.43,62.41 272.99,62.85 272.99,64.59 272.24,65.35 272.24,68.34 271.47,69.11 271.47,76.09 271.02,76.54 271.02,78.1 272.3,79.37 272.3,82.48 271.73,83.05 271.73,84.41 270.96,85.18 270.96,88.58 270.71,88.83 270.71,89.3 270.46,89.55 270.46,90 270.64,90.18 v1(270.96,90.18)
  BOTTOM w0.127: v1(249.29,35.63) 249.14,35.47 249.14,34.52 249.27,34.39 249.63,34.39 CZ87.1 249.58,33.83 JKBTP1.10
BC_DAT_ECE1117: length 91.2
  TOP w0.127: v3(268.94,90.77) 269.31,90.41 RE365.1 270.26,90.04 270.69,89.61 v1(270.96,89.61) 271.39,89.61 271.91,89.08 273.27,89.08 274.62,87.74 274.62,87.36 UE1.D12
  IN2 w0.122: v1(248.65,35.63) 248.65,34.73 248.77,34.61 249.98,34.61 250.75,35.37 251.93,35.37 252.26,35.05 257.22,35.05 257.73,35.56 260.73,35.56 261.62,36.45 266.24,36.45 267.59,37.8 267.59,40.17 270.36,42.93 270.36,44.95 270.64,45.23 270.64,47.19 269.72,48.11 269.72,50.38 271.21,51.87 271.21,53.15 272.61,54.54 272.61,57.18 272.28,57.51 272.28,58.31 272.75,58.79 272.75,59.75 273.68,60.67 273.68,62.51 273.24,62.95 273.24,64.7 272.48,65.45 272.48,68.45 271.72,69.21 271.72,76.19 271.27,76.64 271.27,78 272.55,79.27 272.55,82.58 271.98,83.15 271.98,84.51 271.21,85.28 271.21,88.68 270.96,88.93 v1(270.96,89.61)
  BOTTOM w0.127: JKBTP1.8 248.58,33.73 CZ86.1 248.44,34.39 248.58,34.39 248.88,34.68 248.88,35.4 v1(248.65,35.63)
BC_INT#_ECE1117: length 89
  TOP w0.127: v1(283.67,58.31) v3(282.73,58.31) ; v1(275.04,76.09) 275.34,76.38 275.34,77.38 275.43,77.48 275.43,78.17 UE1.E2
  IN1 w0.084: v1(284.33,76.32) 283.83,76.83 282.7,76.83 282.16,76.28 280.94,76.28 280.42,76.8 277.23,76.8 276.37,75.94 275.56,75.94 275.41,76.09 v1(275.04,76.09)
  IN3 w0.122: v1(246.64,34.13) 246.76,34.25 250.42,34.25 250.53,34.14 251.26,34.14 251.82,34.71 255.93,34.71 256.61,35.39 258.33,35.39 259.14,36.21 259.93,36.21 261.53,37.81 263.06,37.81 265.24,39.99 269.9,39.99 272.14,42.23 273.14,42.23 273.96,43.06 273.96,47.5 273.6,47.86 273.6,48.67 275.39,50.46 275.81,50.46 278.61,53.26 280.51,53.26 281.81,54.56 282.25,54.56 282.48,54.79 282.48,55.95 283.67,57.15 v1(283.67,58.31) 283.67,60.4 282.26,61.81 282.26,62.55 282.08,62.74 282.08,63.06 282.27,63.26 282.27,65.28 282.02,65.52 282.02,66.93 283.11,68.02 283.11,69.74 283.95,70.58 283.95,71.02 284.12,71.19 284.12,72.28 284.28,72.44 284.28,75.26 283.96,75.59 283.96,75.95 v1(284.33,76.32)
  BOTTOM w0.127: JKBTP1.7 248.08,33.35 CZ85.1 v1(246.64,34.13)
BCM5882_ALERT#: length 113.4
  TOP w0.127: UE1.G10 277.42,85 v1(277.08,85.33) ; v1(297,84.44) 291.98,84.44 290.6,85.83 289.25,85.83 288.5,85.08 v1(288.5,84.32) 289.13,83.7 RE532.1 ; v1(267.93,31.49) 267.93,31.12 268.19,30.85 268.19,29.47 v2(267.96,29.24)
  IN1 w0.084: v1(288.5,84.32) 286.76,84.32 286.48,84.04 286.11,84.04 285.85,83.78 284.01,83.78 283.34,84.46 282.22,84.46 281.95,84.18 278.47,84.18 277.32,85.33 v1(277.08,85.33)
  IN4 w0.084: v1(297,84.44) 297.28,84.44 297.97,83.76 297.97,74.51 296.76,73.3 296.76,72.26 296.16,71.66 296.16,69.33 295.48,68.64 295.48,67.56 296.46,66.58 297.23,65.81 298.17,65.81 298.43,65.55 298.43,62.5 295.65,59.73 295.65,56.35 291.55,52.25 290.19,52.25 289.63,52.81 287.98,52.81 287.64,53.14 285.4,53.14 284.75,52.49 281.98,52.49 281.43,51.94 280.26,51.94 279.21,50.89 276.6,50.89 276.07,50.35 272.97,50.35 272.69,50.63 270.38,50.63 269.58,49.83 269.58,49.74 269.57,49.73 269.57,47.72 269.56,47.72 269.56,45.26 267.16,42.86 267.16,37.95 267.79,37.32 268.36,37.32 269.37,36.31 269.37,35.8 269.73,35.45 270.52,35.45 270.81,35.15 270.81,33.84 269.47,32.5 268.94,32.5 v1(267.93,31.49)
  BOTTOM w0.127: JUSH1.14 v1(267.93,31.49)
BEEP: length 71.8
  TOP w0.127: v1(278.74,88.13) 278.68,88.08 278.68,86.22 UE1.H11 ; RA13.2 289.17,56.95 290.73,58.52 292.06,58.52 292.46,58.92 v2(294.96,58.92) 297.19,58.92 297.69,59.43 297.69,60.32 296.8,61.22 v1(296.51,61.22)
  IN4 w0.084: v1(278.74,88.13) 279.17,88.13 279.79,88.76 279.79,90.12 282.2,92.53 287.7,92.53 288.07,92.9 288.32,92.9 288.94,93.51 290.79,93.51 291.47,92.84 291.47,83.7 292.64,82.53 292.64,78.06 292.36,77.78 290.58,77.78 290.14,77.34 290.14,75.61 290.27,75.47 290.99,75.47 291.47,74.99 295.09,74.99 295.66,74.42 295.66,73.63 294.9,72.87 294.9,70.84 295.71,70.04 295.71,69.4 294.92,68.61 294.92,67.59 296.46,66.06 296.46,61.27 v1(296.51,61.22)
BEEP_R: length 6.1
  TOP w0.127: RA45.1 285.74,58.08 285.43,58.4 v2(285.43,60)
  TOP w0.203: CA28.1 286.14,57.82 RA45.1 CA62.1 287.41,57.26 RA13.1
BGATE_CHG: length 231.4
  TOP w0.127: v3(241.52,33.26) 241.97,33.7 v1(242.07,33.7)
  TOP w0.203: PU700.32 48.33,51.38 48.53,51.17 v1(48.77,51.17)
  IN3 w0.122: v1(242.07,33.7) 237.55,33.7 236.98,34.27 225.09,34.27 224.83,34.53 220.75,34.53 218.99,36.29 214.79,36.29 210.15,40.93 207.69,40.93 204.94,43.69 201.39,43.69 200.15,44.92 196.09,44.92 195.49,44.33 154.45,44.33 153.81,43.69 141.57,43.69 137.89,47.36 95.34,47.36 93.26,45.28 68.1,45.28 67.83,45.02 60.3,45.02 60.05,44.77 58.59,44.77 58.37,44.98 53.03,44.98 48.77,49.23 v1(48.77,51.17)
  BOTTOM w0.127: PC743.1 229.69,43.49 239.91,43.49 241.12,42.29 241.12,40.38 243.68,37.81 243.68,35.49 242.07,33.88 v1(242.07,33.7)
  BOTTOM w0.254: PC743.1 229.18,42.42 229.95,41.66 PQ702.4
BGPO0: length 9.5
  TOP w0.127: v1(274.63,81.4) 274.64,81.4 274.67,81.4 UE1.D6 ; v1(267.91,81.75) 267.99,81.67 T341.1
  IN1 w0.084: v1(267.91,81.75) 268.28,82.12 268.52,82.12 269.12,82.72 271.28,82.72 272.38,81.63 272.38,81.21 272.76,80.83 273.31,80.83 273.44,80.96 274.26,80.96 274.63,81.33 v1(274.63,81.4)
BIA_PWM: length 4.8
  TOP w0.127: DV1.1 68.35,104.95 v2(67.25,104.95) RV1.1 67.82,106.56 67.82,107.49 67.54,107.77 LV1.2
BIA_PWM_EC: length 404.1
  TOP w0.127: UE1.N1 282.3,77.76 283.35,76.71 283.92,76.71 284.04,76.83 284.42,76.83 284.94,76.31 285.8,76.31 286.45,75.66 286.45,74.35 286.2,74.09 286.2,73.62 286.92,72.89 286.92,72.52 286.42,72.02 286.42,71.46 285.9,70.94 v1(284.48,70.94) ; v1(39.88,40.29) v2(39.88,39.17) ; DV1.2 68.34,104.5 67.76,103.93 v1(67.76,103.56)
  IN1 w0.084: v1(39.88,40.29) 40.43,40.29 41.73,41.59 41.73,46.21 42.38,46.86 42.38,47.09 44.84,49.56 44.84,50.16 44.58,50.41 v1(44.58,50.6)
  IN2 w0.122: v1(39.88,40.29) 40.99,40.29 42.21,39.07 42.75,39.07 44,37.82 55.14,37.82 56.31,38.99 64.9,38.99 65.13,39.22 93.33,39.22 97.39,43.28 113,43.28 115.02,41.27 117.15,41.27 119.1,39.33 123.28,39.33 124.22,40.27 125.05,40.27 125.42,39.89 134,39.89 135.08,38.81 159.13,38.81 162.37,42.05 185.1,42.05 189.76,46.7 191.38,46.7 196.08,42.01 197.33,42.01 197.56,41.78 199.27,41.78 200.26,40.79 200.26,39.52 201.27,38.51 203.69,38.51 203.85,38.35 206.4,38.35 208.24,36.51 212.51,36.51 217.34,31.68 223.76,31.68 224.3,31.14 230.26,31.14 230.88,30.52 233.17,30.52 233.8,31.14 239.13,31.14 241.76,28.51 252.22,28.51 252.97,29.26 259.85,29.26 260.23,28.89 262.01,28.89 262.22,29.1 265.59,29.1 266.13,29.65 266.13,30.28 265.25,31.17 265.25,31.75 265.8,32.3 269.66,32.3 271.31,33.95 271.31,34.78 272.6,36.07 272.6,37.16 273.18,37.73 273.18,40.15 274.15,41.13 274.15,46.2 273.91,46.45 273.91,48.53 275.64,50.26 275.98,50.26 277.68,51.96 278.59,51.96 278.63,52 278.66,52 279.95,53.29 284.98,53.29 286.18,54.49 286.18,54.84 286.18,59.94 285.32,60.81 285.32,62.56 285.44,62.69 285.44,66.1 285.32,66.21 285.32,67.23 284.87,67.69 284.87,70.55 v1(284.48,70.94) ; v1(67.76,103.56) 67.7,103.63 67.38,103.63 65.83,102.08 61.57,102.08 60.51,103.14 59.87,103.14 59.54,103.47 57.08,103.47 52.08,98.46 52.08,97.87 50.51,96.31 50.51,94.87 49.95,94.31 49.95,87.02 49.25,86.32 49.25,81 46.25,78 46.25,76.25 45.08,75.08 45.08,66.72 42.59,64.24 42.59,59.7 43.13,59.17 43.13,57.02 42.28,56.17 42.28,55.07 42.4,54.94 42.4,53.33 44.18,51.55 44.18,50.86 44.44,50.6 v1(44.58,50.6)
BL_PWR_MONITOR: length 10.5
  TOP w0.127: RV625.2 77.61,105 79.6,105 v2(79.84,104.76) 81.86,104.76 85.53,101.1 QV19.2
BL_PWR_SRC_ON:
  vias: v2(93.97,100.35)
BOARD_ID: length 16.8
  TOP w0.102: UE1.J13 279.02,87.87 279.13,87.99 v1(279.13,90.16)
  TOP w0.127: v1(281.25,98.8) v2(281.25,97.56) 281.25,97.15 280.79,96.69 RE79.2 CE40.1
  IN3 w0.122: v1(281.25,98.8) 281.25,97.28 279.13,95.16 v1(279.13,90.16)
BOOT1_CHG:
  vias: v2(46.96,57.13)
BOOT2_CHG:
  vias: v2(50.31,53.98)
BREATH_LED#: length 74.6
  TOP w0.127: v1(273.78,86.2) 274.22,85.77 UE1.C11
  IN2 w0.122: v1(308.01,68.83) 307.43,69.4 307.43,69.98 304.71,72.69 301.52,72.69 299.57,74.64 299.57,74.64 298.23,75.98 298.23,91.97 298.39,92.13 298.39,93.85 297.76,94.48 295.58,94.48 295.07,93.97 294.18,93.97 293.81,93.61 293.81,93.43 291.68,91.29 291.68,89.89 291.24,89.46 288.94,89.46 288.29,90.11 287.66,90.11 286.84,90.93 283.35,90.93 282.55,91.72 281.85,91.72 281.12,90.99 278.3,90.99 278.14,90.82 276.5,90.82 275.5,91.83 272.24,91.83 271.9,91.49 270.51,91.49 269.95,90.94 v1(269.95,88.89)
  IN4 w0.084: v1(269.95,88.89) 270.14,88.7 272.99,88.7 273.78,87.91 v1(273.78,86.2)
  BOTTOM w0.127: v1(308.01,68.83) 308.18,68.83 308.52,69.17 QZ7.1
BREATH_LED#_Q: length 1.1
  BOTTOM w0.127: RZ32.1 308.58,72.14 308.52,72.08 QZ7.6
BREATH_WHITE_LED_SNIFF#: length 57.6
  TOP w0.127: v2(308.13,72.69) 307.67,73.15 v1(307.67,73.23)
  TOP w0.254: LED3.1 v1(309.71,105.92)
  IN1 w0.084: v1(309.71,105.92) 310.13,106.34 312.63,106.34 313.77,105.2 313.77,100.3 314.51,99.56 314.51,98.09 312.76,96.34 309.17,96.34 307.14,94.3 v1(306.72,94.3)
  IN2 w0.122: v1(306.72,94.3) 306.42,94.3 305.64,93.52 301.24,93.52 298.9,91.18 298.9,76.26 300.74,74.42 306.49,74.42 v1(307.67,73.23)
  BOTTOM w0.127: RZ32.2 v1(307.67,73.23)
BS_DDR:
  vias: v2(219.73,31.16)
BS_DDR_R: length 1.3
  TOP w0.127: v2(217.09,32.95) 217.3,32.73 217.3,31.74
BSMB_WP_INT#: length 357.5
  TOP w0.127: RE819.1 274.77,92.96 272.36,95.37 272.36,96.83 270.26,98.93 v1(270.01,98.93) ; v1(272.13,69.43) 272.13,69.38 272.74,68.77 RE92.1
  TOP w0.254: v1(44.84,40.76) 44.84,39.36 v2(44.58,39.11) 44.14,38.67 39.76,38.67 39.13,39.29 PD902.3 39.13,40.38 38.83,40.68 v1(38.19,40.68)
  IN1 w0.084: v1(272.13,69.43) 272.71,69.43 273.5,70.22 275.01,70.22 275.66,70.88 277.47,70.88 278.1,71.5 279.82,71.5 280.84,70.48 281.57,70.48 281.65,70.4 284.54,70.4 286.28,72.14 v1(287.12,72.14)
  IN3 w0.122: v1(270.01,98.93) 270.01,98.71 268.74,97.44 268.74,89.47 267.86,88.59 267.86,85.74 270.81,82.79 270.81,76.22 272.31,74.71 272.31,73.68 272.54,73.45 272.54,69.64 272.33,69.43 v1(272.13,69.43) ; v1(287.12,72.14) 286.74,71.76 286.74,70.55 285.99,69.8 285.99,69.29 286.68,68.6 286.68,65.66 288.43,63.91 288.43,61.59 287.52,60.69 287.52,59.04 286.54,58.06 286.54,57.8 285.65,56.91 285.65,54.72 283.92,52.99 282.51,52.99 281.2,51.68 280.4,51.68 279.29,50.57 278.36,50.57 276.55,48.77 276.55,47.62 276.36,47.43 276.36,40.82 274.91,39.38 274.06,39.38 273.43,38.74 273.43,37.93 272.48,36.98 269.47,36.98 268.2,35.72 267.43,35.72 266.91,36.25 265.57,36.25 264.25,34.92 263.69,34.92 262.42,33.65 261.18,33.65 260.23,32.7 259.66,32.7 258.64,31.68 256.42,31.68 255.9,31.15 249.93,31.15 249.65,30.87 248.21,30.87 247.63,30.28 245.96,30.28 245.16,29.49 240.26,29.49 238.52,31.24 231.4,31.24 231.27,31.36 225.46,31.36 224.61,32.22 220.53,32.22 218.25,34.5 213.66,34.5 209.86,38.29 207.8,38.29 204.53,41.57 139.65,41.57 135.9,45.31 121.74,45.31 121.22,44.79 95.83,44.79 94.53,43.49 68.84,43.49 68.23,42.89 45.84,42.89 44.84,41.88 v1(44.84,40.76)
  BOTTOM w0.254: PR955.2 37.73,41.15 v1(38.19,40.68)
BSMB_WP_INT#_R: length 4
  TOP w0.102: 275.34,87.96 275.34,87.03 UE1.E12
  TOP w0.127: 275.34,87.96 274.77,88.53 v2(274.77,89.26) RE819.2
BST1_CHG_R: length 1.1
  TOP w0.127: v2(43.33,58.55) 43.55,58.78 44.37,58.78
BST1_IA_R: length 1.3
  BOTTOM w0.127: v2(77.46,85.13) 77.34,85.01 PR660.1
BST2_CHG_R: length 1.3
  TOP w0.127: 52.84,54.22 v2(54.11,54.22)
BST_1.05VALWP_R: length 1.8
  TOP w0.127: v3(185.48,110.07) 186.42,109.14 PC304.1
BST_3V: length 1.6
  TOP w0.127: 191.97,101.04 192.13,101.2 192.45,101.2 v3(193.17,101.92)
BST_3V_R: length 1.7
  TOP w0.127: v3(194.89,101.9) 194.89,101.13 PC102.1
BST_GT_R: length 0.9
  BOTTOM w0.127: PC663.1 v2(71.11,72.54)
BST_SA_R: length 1.9
  TOP w0.508: PC611.1 94.81,96.96 v1(95.14,96.96)
  BOTTOM w0.508: PR619.1 v1(95.14,96.96)
BT_RADIO_DIS#: length 35
  TOP w0.127: UE1.C2 273.8,78.14 273.8,77.55 273.41,77.15 v1(273.41,76.66) 272.71,75.96 RE11.1 ; DZ2.1 272.55,50.69 v2(272.55,55.15) v1(273.12,55.72)
  IN2 w0.122: v1(273.41,76.66) 273.41,75.23 274.43,74.21 274.43,73.55 274.9,73.08 274.9,71.24 273.87,70.21 273.87,68.59 274.85,67.61 274.85,65.35 275.72,64.48 275.72,62.19 274.63,61.1 274.63,60.27 275.22,59.68 275.22,57.36 274.05,56.19 273.59,56.19 v1(273.12,55.72)
BT_RADIO_DIS#_R: length 15.3
  TOP w0.127: v1(270.75,43.93) 270.45,44.22 v2(270.45,46.55) 270.45,49.78 270.71,50.03 271.51,50.03 DZ2.2
  BOTTOM w0.127: JNGFF1.54 265.83,41.13 265.98,40.98 268.06,40.98 269.78,42.7 269.78,42.96 v1(270.75,43.93)
CAM_MIC_CBL_DET#: length 256.3
  TOP w0.127: v1(165.58,52.44) 165.38,52.64 v2(165.38,53.68) 165.38,58.33 165.11,58.6 165.11,59.76 RC725.1 v1(165.7,60.94) ; v1(63.21,112.88) 63.21,111.59 RZ1470.2
  IN3 w0.122: v1(165.58,52.44) 165.17,52.04 165.17,51.68 162.88,49.39 156.9,49.39 155.77,48.25 153.96,48.25 152,46.3 146.83,46.3 145.88,47.25 144.68,47.25 141.14,50.79 94.89,50.79 92.73,48.63 83.5,48.63 82.75,47.89 61.9,47.89 61.3,47.29 55.01,47.29 54.7,46.97 53.65,46.97 51.98,48.64 51.98,53.33 52.67,54.02 52.67,57.82 51.63,58.86 51.63,60.84 49.46,63.01 48.54,63.01 45.92,65.63 45.92,72.53 47.35,73.96 47.35,74.26 48.45,75.36 48.45,76.06 49.73,77.34 49.73,82.55 52.6,85.42 52.6,86.97 52.14,87.43 48.36,87.43 46.39,89.4 46.39,91.21 47.9,92.71 47.9,94.9 47.2,95.59 40.56,95.59 40.44,95.48 38.38,95.48 37.34,96.52 37.34,101.09 45.52,109.28 45.59,109.34 50.68,109.34 53.8,112.47 62.79,112.47 v1(63.21,112.88)
  IN4 w0.084: v1(151.66,66.53) 153.24,66.53 154.82,64.95 154.82,64.76 159.02,60.57 165.33,60.57 v1(165.7,60.94)
  BOTTOM w0.076: UC1.CH36 149.9,69.13 150.15,68.67 150.15,68.37 149.99,68.21 149.99,67.76 151.22,66.53 v1(151.66,66.53)
CBN: length 2.4
  TOP w0.203: UA1.24 283.52,37.08 283.77,36.82 284.09,36.82 284.61,36.3 CA29.2 CA76.2
CBP: length 2.2
  TOP w0.203: CA76.1 CA29.1 283.75,36.48 283.61,36.48 283.12,36.97 UA1.23
CFG0: length 94.5
  TOP w0.127: RC120.2 115.91,98.15 v1(116.46,98.15) ; v1(71.48,97.23) 70.84,97.23 v2(70.27,97.8) 69.78,98.28 68.95,98.28 67.95,99.29 67.95,100.7 67.82,100.83 66.78,100.83 66.43,100.48 v1(66.43,100.19) ; v1(59.51,95.78) 59.21,95.48 RC126.1
  IN2 w0.122: v1(71.48,97.23) 71.48,96.99 71.19,96.7 67.3,96.7 66.86,96.26 59.99,96.26 v1(59.51,95.78)
  BOTTOM w0.076: UC1.T4 118.21,89.77 118.47,90.04 118.47,90.34 118.29,90.53 118.29,92.58 118.24,92.63 118.24,92.91
  BOTTOM w0.114: v1(116.47,98.15) 116.71,98.15 117.42,97.44 117.42,95.5 118.24,94.67 118.24,92.91
  BOTTOM w0.127: v1(116.47,98.15) 116.45,98.15 116.06,98.54 116.06,100.05 108.8,107.31 102.3,107.31 101.11,108.5 89.75,108.5 89.39,108.14 84.38,108.14 83.53,108.99 80.15,108.99 76.88,105.71 67.77,105.71 66.82,104.76 66.82,101.01 66.43,100.62 v1(66.43,100.19) ; JXDP1.9 v1(71.48,97.23)
CFG1: length 74.3
  TOP w0.127: v1(116.35,93.95) 115.89,94.4 115.89,95.59 114.5,96.98 RC405.2 ; v1(73.49,102.99) 73.49,105.14 v2(73.42,105.2)
  IN2 w0.122: v1(116.35,93.95) 116.08,93.95 114.64,95.38 114.64,95.93 113.91,96.66 113.25,96.66 112.85,96.26 111.03,96.26 110.58,96.7 110.58,98.99 108.49,101.09 106.06,101.09 105.47,101.68 104.03,101.68 103.88,101.84 102.57,101.84 101.27,103.14 93.22,103.14 92.21,102.13 80.31,102.13 79.93,102.51 73.97,102.51 v1(73.49,102.99)
  BOTTOM w0.076: UC1.R4 117.64,89.45 117.36,89.73 117.36,90.04 117.22,90.38 117.22,90.63 117.25,90.73 117.25,90.95 117.22,91.05 117.22,91.39 117.21,92.14 117.11,92.24 117.11,92.59
  BOTTOM w0.114: 117.11,92.59 117.11,93.19 v1(116.35,93.95)
  BOTTOM w0.127: JXDP1.11 70.88,96.02 71.01,95.89 71.11,95.89 71.11,95.89 71.83,95.89 72.14,95.58 74.81,95.58 75.83,96.6 75.83,98.23 75.42,98.63 75.42,100.81 73.49,102.75 v1(73.49,102.99)
CFG2: length 74.7
  TOP w0.127: v1(66.98,100.2) 66.98,99.64 v2(68.85,97.78) 69.4,97.23 v1(69.68,97.23) ; v1(116.41,96.97) 116.41,97.08 115.74,97.75 RC406.2
  BOTTOM w0.076: UC1.T3 118.1,90.3 118.1,92.5 118.04,92.56 118.04,92.88
  BOTTOM w0.114: 118.04,92.88 118.04,94.36 117.1,95.31 117.1,96.51 116.65,96.97 v1(116.41,96.97) 115.63,97.75 115.63,99.87 108.62,106.89 101.96,106.89 100.77,108.08 89.92,108.08 89.56,107.72 79.48,107.72 77.06,105.29 67.94,105.29 67.24,104.58 67.24,100.76 66.98,100.5 v1(66.98,100.2)
  BOTTOM w0.127: JXDP1.15 v1(69.68,97.23)
CFG3: length 74.8
  TOP w0.127: v1(116.35,94.58) 116.98,94.58 117.54,95.14 117.54,97.66 117.32,97.89 RC407.2 ; v2(68.49,95.56) v1(69.16,95.56) 69.25,95.56 RC121.2
  IN2 w0.122: v1(74.67,103.03) 74.76,102.94 80.1,102.94 80.38,102.66 88.83,102.66 89.14,102.97 92.45,102.97 93.05,103.57 101.44,103.57 102.75,102.26 104.06,102.26 104.21,102.11 105.64,102.11 106.24,101.51 108.67,101.51 111.73,98.46 111.73,96.81 111.85,96.69 112.67,96.69 113.07,97.09 114.08,97.09 115.07,96.11 115.07,95.56 116.05,94.58 v1(116.35,94.58)
  BOTTOM w0.076: UC1.R3 117.6,89.91 117.38,90.42 117.38,90.61 117.41,90.7 117.41,90.98 117.38,91.07 117.38,92.21 117.35,92.23 117.35,92.58
  BOTTOM w0.114: v1(116.35,94.58) 117.35,93.58 117.35,92.58
  BOTTOM w0.127: v1(74.67,103.03) 74.67,102.33 75.85,101.15 75.85,98.81 76.27,98.39 76.27,96.43 74.99,95.15 71.96,95.15 71.65,95.46 71.29,95.46 69.26,95.46 v1(69.16,95.56) 69.08,95.64 JXDP1.17
CFG4: length 62.2
  TOP w0.127: v1(66.43,95.78) 66.43,95.66 v2(66.9,95.19)
  IN4 w0.084: v1(66.43,95.78) 66.43,95.75 66.71,96.03 81.59,96.03 82.73,97.17 92.21,97.17 92.98,96.41 97.64,96.41 99.32,98.08 101.64,98.08 101.99,98.43 107.3,98.43 107.94,97.78 109.14,97.78 109.23,97.88 111,97.88 v1(111.07,97.81)
  BOTTOM w0.076: UC1.J4 113.89,89.21 113.89,89.45 114.17,89.73 114.17,90.04 114.31,90.38 114.31,90.63 114.28,90.73 114.28,90.95 114.31,91.05 114.31,91.36 113.93,91.75 113.53,91.75 112.72,92.56 112.72,94.02
  BOTTOM w0.127: v1(66.43,95.78) 66.08,96.13 JXDP1.27 ; RC723.2 111,98.59 111,97.88 v1(111.07,97.81) 112.08,96.79 112.08,94.65 112.72,94.02
CFG5: length 72
  BOTTOM w0.076: UC1.M4 115.76,89.77 116.03,90.04 116.03,90.34 115.86,90.51 115.86,91.69 115.03,92.53 115.03,92.63
  BOTTOM w0.114: 115.03,92.63 115.03,95.81 113.81,97.03
  BOTTOM w0.127: 113.81,97.03 113.65,97.19 112.92,97.19 111.86,98.25 111.86,99.17 RC409.2 111.63,99.21 110.69,100.15 v2(110.69,101.06) 110.69,102.48 107.93,105.23 95.34,105.23 95.24,105.33 87.57,105.33 87.2,104.96 83.38,104.96 81.15,102.73 76.72,102.73 76.29,102.29 76.29,98.99 76.7,98.57 76.7,96.11 75.31,94.72 71.78,94.72 71.47,95.03 68.93,95.03 68.33,95.62 67.25,95.62 66.99,95.36 66.22,95.36 65.48,96.1 JXDP1.29
CFG6: length 63.2
  TOP w0.127: v1(64.52,95.75) v2(64.52,95.09)
  IN4 w0.084: v1(111.09,97.25) 110.85,97.49 109.39,97.49 109.3,97.4 104.47,97.4 103.83,98.04 102.3,98.04 101.72,97.46 100.41,97.46 98.97,96.02 92.82,96.02 92.05,96.78 82.89,96.78 81.75,95.64 69.78,95.64 69.25,95.12 68.97,95.12 68.46,95.62 67,95.62 66.68,95.31 65.16,95.31 64.71,95.75 v1(64.52,95.75)
  BOTTOM w0.076: UC1.J3 113.89,89.86 113.93,89.91 114.15,90.42 114.15,90.61 114.12,90.7 114.12,90.98 114.15,91.07 114.15,91.3 113.89,91.56 113.49,91.56 112.51,92.55 112.51,93.59
  BOTTOM w0.127: JXDP1.33 64.28,96.12 64.52,95.88 v1(64.52,95.75) ; 112.51,93.59 111.87,94.23 111.87,96.46 v1(111.09,97.25) 110.57,97.77 110.57,98.39 RC410.2
CFG7: length 66.6
  TOP w0.127: v1(112.12,97.3) v2(112.12,97.94)
  IN4 w0.084: v1(63.95,95.69) 64.29,95.35 64.57,95.35 65,94.92 66.84,94.92 66.85,94.93 66.94,94.93 67.19,95.18 68.33,95.18 68.84,94.67 69.35,94.67 69.94,95.25 81.91,95.25 83.05,96.39 91.89,96.39 92.66,95.63 99.13,95.63 100.51,97.01 103.71,97.01 103.72,97.01 109.12,97.01 109.39,96.74 111.56,96.74 v1(112.12,97.3)
  BOTTOM w0.076: 114.79,94.34 114.79,92.54 115.67,91.66 115.67,90.29 UC1.M3
  BOTTOM w0.114: 113.54,96.96 113.59,96.96 114.79,95.76 114.79,94.34
  BOTTOM w0.127: RC411.2 111.43,98.79 111.43,97.99 v1(112.12,97.3) 112.46,96.96 113.54,96.96 ; v1(63.95,95.69) 63.95,95.83 63.68,96.1 JXDP1.35
CFG8: length 66
  TOP w0.127: RC412.2 115.74,96.43 v2(115.9,96.26) 116.31,96.26 v1(116.41,96.37)
  BOTTOM w0.076: 117.85,92.85 117.85,92.49 117.91,92.43 117.91,91.01 117.64,90.75 UC1.R2
  BOTTOM w0.114: 117.85,92.85 117.85,94.18 116.78,95.24 116.78,96 v1(116.41,96.37) 116.14,96.37 115.21,97.29 115.21,99.7 108.45,106.47 101.68,106.47 100.49,107.66 90.1,107.66 89.74,107.3 79.66,107.3 77.23,104.87 72.24,104.87 70.86,103.49 70.86,101.37 71.52,100.71 71.52,100.21 71.18,99.87 JXDP1.10
CFG9: length 60.9
  IN2 w0.122: v1(69.73,103.56) 69.87,103.42 80.24,103.42 80.58,103.08 88.65,103.08 88.97,103.4 92.28,103.4 92.87,103.99 101.62,103.99 102.51,103.1 107.74,103.1 v1(112.29,98.55)
  BOTTOM w0.076: UC1.N2 116.33,90.75 116.06,91.01 116.06,91.73 115.27,92.52 115.27,92.62
  BOTTOM w0.114: 114.05,97.08 115.27,95.86 115.27,92.62
  BOTTOM w0.127: 114.05,97.08 114.05,97.09 113.74,97.4 113.39,97.4 112.31,98.48 112.31,98.53 v1(112.29,98.55) 112.29,98.95 112.4,99.05 RC413.2 ; JXDP1.12 70.58,99.87 70.98,100.27 70.98,100.65 69.73,101.9 v1(69.73,103.56)
CFG10: length 64
  TOP w0.127: v1(116.35,95.22) 116.44,95.13 116.88,95.13 v2(116.88,95.13) 117.04,95.28 RC414.2
  IN2 w0.122: v1(69.09,103.56) 69.09,103.66 69.39,103.95 80.31,103.95 80.7,103.56 83.76,103.56 84.31,104.11 86.9,104.11 87.18,103.83 92.1,103.83 92.69,104.42 101.8,104.42 102.69,103.53 108.82,103.53 111.77,100.58 111.77,99.68 112.72,98.72 112.72,98.42 113.62,97.52 114.26,97.52 115.51,96.27 115.51,95.72 116.02,95.22 v1(116.35,95.22)
  BOTTOM w0.076: UC1.R1 117.64,92.32 117.59,92.36 117.59,92.72
  BOTTOM w0.114: 117.59,92.72 117.59,93.97 v1(116.35,95.22)
  BOTTOM w0.127: v1(69.09,103.56) 69.09,101.92 69.96,101.06 69.96,100.23 69.38,99.66 JXDP1.16
CFG11: length 63.1
  IN2 w0.122: v1(113.53,98.74) 113.42,98.74 112.19,99.96 112.19,100.75 108.99,103.95 102.87,103.95 101.98,104.85 92.52,104.85 91.92,104.25 87.36,104.25 87.08,104.53 84,104.53 83.6,104.13 80.74,104.13 80.48,104.38 69.02,104.38 68.46,103.82 v1(68.46,103.56)
  BOTTOM w0.076: UC1.N1 116.33,91.7 115.47,92.56 115.47,92.66
  BOTTOM w0.114: 115.47,92.66 115.47,95.96 113.63,97.8 113.63,98.64 v1(113.53,98.74)
  BOTTOM w0.127: v1(68.46,103.56) 68.21,103.31 68.21,100.24 68.78,99.66 JXDP1.18 ; v1(113.53,98.74) 113.51,98.74 RC415.2
CFG12: length 65.8
  TOP w0.127: v2(65.61,96.51) 65.16,96.97 v1(65.16,97.28)
  IN4 w0.084: v1(111.79,93.2) 112.12,93.2 112.62,93.71 112.62,96.04 113.1,96.51 113.1,99.12 112.34,99.88 106.32,99.88 105.39,100.81 99,100.81 97.87,99.67 94.38,99.67 92.65,97.95 82.41,97.95 81.27,96.81 65.5,96.81 65.16,97.16 v1(65.16,97.28)
  BOTTOM w0.127: JXDP1.28 65.78,97.83 65.23,97.28 v1(65.16,97.28) ; RC416.2 111.13,93.86 v1(111.79,93.2) 112.08,92.91 112.08,92.32 UC1.J2
CFG13: length 64
  TOP w0.127: v1(64.98,98.28) 64.98,98.66 v2(64.46,99.18)
  IN1 w0.084: v1(113.8,95.71) 112.43,95.71 112.17,95.45 110.49,95.45 110.3,95.64 110.3,95.78 108.75,97.32 104.54,97.32 103.91,97.96 99.47,97.96 97.53,96.02 94.16,96.02 93.32,96.86 84.42,96.86 84.2,96.64 82.5,96.64 81.53,95.67 73.91,95.67 73.05,96.54 65.09,96.54 64.76,96.88 64.76,97.77 64.98,97.99 v1(64.98,98.28)
  BOTTOM w0.076: UC1.L2 115.2,90.75 115.47,91.01 115.47,91.62 114.62,92.47 114.62,94.18 114.54,94.26 114.54,94.36 ; v1(113.8,95.71) 113.38,96.13 112.62,96.13 112.49,96.26 RC417.2
  BOTTOM w0.114: 114.54,94.36 114.54,94.97 v1(113.8,95.71)
  BOTTOM w0.127: JXDP1.30 65.13,99.33 65.13,98.44 v1(64.98,98.28)
CFG14: length 70.3
  TOP w0.127: v2(64.15,96.49) 64.39,96.72 v1(64.39,97.34)
  IN4 w0.084: v1(111.8,93.76) 112.13,93.76 112.23,93.87 112.23,96.2 112.71,96.67 112.71,98.96 112.37,99.3 106.35,99.3 105.23,100.42 99.16,100.42 98.03,99.28 94.54,99.28 92.82,97.56 82.57,97.56 81.43,96.42 64.81,96.42 64.39,96.85 v1(64.39,97.34)
  BOTTOM w0.127: UC1.J1 113.68,91.37 113.41,91.37 112.29,92.49 112.29,93.26 v1(111.8,93.76) 111.58,93.98 111.58,96.08 110.13,97.52 110.13,98.12 RC418.2 ; v1(64.39,97.34) 64.39,98.64 63.98,99.05 JXDP1.34
CFG15: length 61.8
  TOP w0.127: v2(64.43,97.86) 64.01,98.28 v1(63.95,98.28)
  IN1 w0.084: v1(113.8,95.15) 112.76,95.15 112.31,94.71 110.68,94.71 109.91,95.48 109.91,95.62 108.59,96.93 98.99,96.93 97.69,95.63 94,95.63 93.16,96.47 84.58,96.47 84.36,96.25 82.66,96.25 81.69,95.29 73.75,95.29 72.89,96.15 64.93,96.15 63.95,97.13 v1(63.95,98.28)
  BOTTOM w0.076: v1(113.8,95.15) 113.23,95.73 RC419.2 ; 114.3,94.36 114.3,94.26 114.45,94.11 114.45,92.4 115.2,91.66 UC1.L1
  BOTTOM w0.114: v1(113.8,95.15) 114.3,94.65 114.3,94.36
  BOTTOM w0.127: JXDP1.36 63.38,99.04 63.95,98.47 63.95,98.28 v1(63.95,98.28)
CFG16: length 55.9
  TOP w0.127: v2(71.46,99.22) 71.95,98.72 v1(71.95,98.52)
  IN1 w0.084: v1(71.95,98.52) 71.95,98.19 74.08,96.06 81.37,96.06 82.33,97.03 84.04,97.03 84.26,97.25 93.48,97.25 94.32,96.41 97.37,96.41 99.31,98.35 107.69,98.35 108.33,97.71 109.47,97.71 110.42,96.77 114.04,96.77 114.17,96.64 114.17,94.81 113.65,94.29 v1(113.44,94.29)
  BOTTOM w0.076: UC1.L3 115.16,89.91 114.94,90.42 114.94,90.61 114.97,90.7 114.97,90.98 114.94,91.07 114.94,91.69 114.9,91.72 114.89,91.73 114.29,92.33 114.29,93.91 113.91,94.29 v1(113.44,94.29)
  BOTTOM w0.127: JXDP1.6 72.38,99.1 71.95,98.67 v1(71.95,98.52)
CFG17: length 58.2
  TOP w0.127: v2(72.87,99.14) 72.51,98.79 v1(72.51,98.52)
  IN1 w0.084: v1(72.51,98.52) 72.51,98.18 74.24,96.45 81.21,96.45 82.17,97.42 83.88,97.42 84.1,97.64 95.51,97.64 96.22,96.92 97.33,96.92 99.15,98.74 103.32,98.74 104.55,99.97 106.64,99.97 107.32,99.29 113.63,99.29 115.14,97.79 115.14,95.23 v1(113.72,93.81)
  BOTTOM w0.076: v1(113.72,93.81) 114.12,93.4 114.12,92.27 114.77,91.62 114.77,91.61 114.77,91.05 114.81,90.95 114.81,90.73 114.77,90.63 114.77,90.38 114.92,90.04 114.92,89.73 115.2,89.45 UC1.L4
  BOTTOM w0.127: JXDP1.4 72.98,99.09 72.51,98.62 v1(72.51,98.52)
CFG18: length 71.9
  BOTTOM w0.076: 115.66,92.74 115.66,92.6 116.59,91.67 116.59,91.07 116.56,90.98 116.56,90.7 116.59,90.61 116.59,90.42 116.37,89.91 UC1.N3
  BOTTOM w0.102: JXDP1.24 66.98,98.59 67.84,97.73 72.92,97.73 73.68,98.49 73.88,98.49 74.29,98.91 74.29,99.98 74.05,100.22 73.3,100.97 72.42,100.97 72.12,101.27 72.12,103.59 72.37,103.84 77.36,103.84 79.46,105.94 81.98,105.94 82.52,106.48 91.17,106.48 91.9,105.75 95.42,105.75 95.52,105.65 108.11,105.65 113.93,99.83 113.93,99.01 114.4,98.54 v2(114.4,97.75) 114.4,97.31 115.66,96.04 115.66,92.74
CFG19: length 72.5
  BOTTOM w0.076: 115.85,92.75 115.85,92.65 116.76,91.73 116.76,91.39 116.76,91.05 116.72,90.95 116.72,90.73 116.76,90.63 116.76,90.38 116.61,90.04 116.61,89.73 116.33,89.45 UC1.N4
  BOTTOM w0.102: JXDP1.22 67.58,99 68.44,98.14 72.75,98.14 73.51,98.9 73.71,98.9 73.89,99.07 73.89,99.81 73.14,100.56 72.25,100.56 71.71,101.1 71.71,103.76 72.41,104.46 77.4,104.46 79.83,106.88 89.91,106.88 90.27,107.25 100.27,107.25 101.46,106.06 108.27,106.06 v2(113.15,101.18) 114.8,99.53 114.8,97.17 115.85,96.12 115.85,92.75
CFG_RCOMP: length 10.9
  TOP w0.381: v1(118.88,96.83) RC624.1
  IN1 w0.2: v1(121.93,88.67) 121.35,89.25 121.22,89.25 118.43,92.04 118.43,96.39 v1(118.88,96.83)
  BOTTOM w0.2: v1(121.93,88.67) UC1.AB5
CLK_CNV_PRX_DTX_N: length 147.9
  IN4 w0.094: v1(258.73,38.77) 258.53,38.57 258.53,38.26 258.24,37.97 257.42,37.97 257.27,37.83 257.27,37.03 257.06,36.83 256.51,36.83 256.31,37.03 256.31,38.09 257.11,38.89 257.11,39.23 257.02,39.32 255.69,39.32 255.28,39.73 253.94,39.73 252.62,38.41 250.07,38.41 249.76,38.73 247.26,38.73 245.73,37.19 241.17,37.19 241.12,37.14 229.65,37.14 229.17,36.66 225.89,36.66 224.69,37.86 221.29,37.86 220.69,38.47 217.42,38.47 214.58,41.3 212.82,41.3 199.84,54.28 193.27,54.28 189.29,58.26 189.29,62.17 189.71,62.6 189.71,65.28 188.13,66.87 186.87,66.87 180.98,72.76 171.49,72.76 170.46,73.79 166.98,73.79 166.96,73.81 162.22,73.81 161.08,72.66 159.57,72.66 159.06,72.16 158.67,72.16 158.16,72.66 157.88,72.66 157.71,72.49 157.71,71.88 v1(157.93,71.66)
  BOTTOM w0.076: v1(157.93,71.66) 157.72,71.87 157.72,72 157.52,72.2 155.49,72.2 155.48,72.2 155.41,72.2 155.37,72.24 154.35,72.24 154.16,72.42 154.16,72.43 154.08,72.51 153.97,72.51 153.68,72.51 UC1.CN31
  BOTTOM w0.104: v1(258.73,38.77) 258.58,38.92 258.58,39.23 258.26,39.55 258.26,41.26 259.38,42.39 259.38,47.07 258.58,47.87 258.58,49.14 258.34,49.38 JNGFF1.21
CLK_CNV_PRX_DTX_P: length 147.9
  IN4 w0.094: v1(258.14,38.71) 258.34,38.51 258.34,38.34 258.16,38.16 257.34,38.16 257.09,37.9 257.09,37.11 256.99,37.01 256.59,37.01 256.5,37.1 256.5,38.02 257.29,38.82 257.29,39.3 257.09,39.5 255.77,39.5 255.36,39.91 253.86,39.91 252.54,38.59 250.15,38.59 249.83,38.91 247.18,38.91 245.65,37.38 241.09,37.38 241.04,37.32 229.57,37.32 229.09,36.84 225.96,36.84 224.76,38.04 221.37,38.04 220.76,38.65 217.49,38.65 214.66,41.48 212.9,41.48 199.92,54.46 193.35,54.46 189.47,58.34 189.47,62.09 189.9,62.52 189.9,65.36 188.21,67.05 186.94,67.05 181.06,72.94 171.56,72.94 170.6,73.91 170.53,73.97 167.06,73.97 167.04,73.99 162.14,73.99 161,72.85 159.49,72.85 158.98,72.34 158.74,72.34 158.24,72.85 157.81,72.85 157.52,72.56 157.52,71.95 v1(157.23,71.66)
  BOTTOM w0.076: UC1.CP31 153.91,72.34 154.02,72.34 154.28,72.07 155.3,72.07 155.34,72.04 155.51,72.04 155.58,71.97 155.58,71.85 155.64,71.78 155.74,71.78 155.8,71.85 155.8,71.97 155.87,72.04 155.97,72.04 156.03,71.97 156.03,71.79 156.1,71.73 156.19,71.73 156.26,71.79 156.26,71.97 156.33,72.04 157.46,72.04 157.56,71.94 157.56,71.76 157.43,71.63 157.26,71.63 v1(157.23,71.66)
  BOTTOM w0.104: v1(258.14,38.71) 258.38,38.95 258.38,39.16 258.07,39.47 258.07,41.34 259.19,42.47 259.19,46.99 258.39,47.79 258.39,49.06 258.26,49.19 257.99,49.19 257.91,49.11 257.91,48.98 257.81,48.88 JNGFF1.23
CLK_CNV_PTX_DRX_N: length 132.1
  IN4 w0.094: v1(254.62,35.74) 254.67,35.74 254.82,35.89 254.82,36.03 254.67,36.18 247.35,36.18 245.82,34.65 239.52,34.65 238.78,35.4 230.37,35.4 229.89,34.91 225.16,34.91 224.68,35.4 221.29,35.4 219.96,36.72 216.69,36.72 213.93,39.49 212.17,39.49 199.14,52.52 194.97,52.52 194.1,51.65 192.58,51.65 186.96,57.27 186.96,62.31 187.97,63.32 187.97,64.56 187.56,64.97 185.5,64.97 182.06,68.42 179.89,68.42 179.39,68.91 175.81,68.91 174.82,67.92 167.31,67.92 165.29,65.9 161.16,65.9 158.95,68.1 158.95,68.7 158.95,68.83 v1(158.71,69.04)
  BOTTOM w0.076: UC1.CP34 153.21,70.24 153.29,70.16 153.42,70.16 153.52,70.27 153.52,70.45 153.6,70.53 153.68,70.53 153.88,70.61 154.53,70.61 155.6,69.54 155.72,69.54 155.89,69.37 156.03,69.37 156.2,69.54 156.33,69.54 156.5,69.37 156.63,69.37 156.8,69.54 156.94,69.54 157.11,69.37 157.24,69.37 157.41,69.54 157.65,69.54 157.65,69.54 158.86,69.54 158.98,69.42 158.98,69.31 v1(158.71,69.04)
  BOTTOM w0.104: v1(254.62,35.74) 254.62,36.24 255.15,36.77 256.04,36.77 256.15,36.88 JNGFF1.71
CLK_CNV_PTX_DRX_P: length 132.2
  IN4 w0.094: v1(159.34,69.08) 159.13,68.84 159.14,68.71 159.14,68.18 161.24,66.08 165.21,66.08 167.24,68.11 174.75,68.11 175.74,69.1 179.46,69.1 179.96,68.6 182.13,68.6 185.58,65.15 187.64,65.15 188.15,64.64 188.15,63.25 187.15,62.24 187.15,57.35 192.66,51.83 194.03,51.83 194.89,52.7 199.22,52.7 212.24,39.67 214,39.67 216.77,36.9 220.04,36.9 221.36,35.58 224.76,35.58 225.24,35.1 229.81,35.1 230.3,35.58 238.86,35.58 239.6,34.84 245.74,34.84 247.27,36.37 254.74,36.37 255.01,36.1 255.01,35.94 v1(255.21,35.74)
  BOTTOM w0.076: v1(159.34,69.08) 159.15,69.27 159.15,69.52 158.96,69.71 157.58,69.71 157.58,69.71 155.67,69.71 154.6,70.78 153.85,70.78 153.67,70.7 153.45,70.7 153.42,70.73 153.1,70.73 152.82,70.45 UC1.CN34
  BOTTOM w0.104: JNGFF1.73 256.17,36.38 255.99,36.21 255.82,36.21 255.72,36.31 255.72,36.47 255.62,36.58 255.24,36.58 254.88,36.22 254.88,36.07 v1(255.21,35.74)
CLK_ITPXDP_N: length 4.9
  BOTTOM w0.076: RC530.1 131.3,94.74 131.3,94.29 v4(131.14,94.13) 130.93,93.91 130.93,92.45 130.88,92.41 130.88,91.59 130.98,91.5 131.18,91.5 131.26,91.42 131.26,91.24 131.18,91.16 UC1.AU1
CLK_ITPXDP_N_R: length 99.7
  IN4 w0.094: v1(131.9,97.8) 132.01,97.91 132.38,97.91 132.59,98.12 132.59,100.33 132.19,100.73 132.19,108.87 128.55,112.5 110.54,112.5 109.95,111.91 106.53,111.91 105.94,112.5 88.51,112.5 86.51,110.5 78.73,110.5 78.05,111.18 65.61,111.18 65.13,110.7 65.13,110.27 64.43,109.58 63.22,109.58 62.67,109.03 v1(62.67,107.54)
  BOTTOM w0.076: v1(131.9,97.8) 131.26,97.8 131.19,97.72 131.19,97.22 131.59,96.82 131.59,95.97 RC530.2
  BOTTOM w0.104: v1(62.67,107.54) 62.87,107.34 62.87,106.95 63.09,106.73 63.49,106.73 63.76,106.46 63.76,105.23 63.87,105.12 63.87,103.28 61.79,101.2 61.79,99.94 61.58,99.73 61.58,99.38 JXDP1.42
CLK_ITPXDP_P: length 4.9
  BOTTOM w0.076: RC298.1 131.13,94.38 130.76,94.01 130.76,92.52 130.71,92.47 130.71,91.01 UC1.AU2
CLK_ITPXDP_P_R: length 99.7
  IN4 w0.094: v1(131.96,98.43) 131.96,98.26 132.12,98.1 132.31,98.1 132.4,98.2 132.4,100.26 132,100.66 132,108.79 128.47,112.32 110.62,112.32 110.03,111.73 106.46,111.73 105.87,112.32 88.59,112.32 86.59,110.32 78.65,110.32 77.97,111 65.69,111 65.31,110.62 65.31,110.2 64.51,109.39 63.3,109.39 62.86,108.95 62.86,107.94 v1(63.26,107.54)
  BOTTOM w0.076: RC298.2 131.43,96.08 131.43,96.75 131.02,97.15 131.02,97.79 131.19,97.96 131.5,97.96 131.89,98.35
  BOTTOM w0.104: JXDP1.40 62.18,99.74 61.98,99.94 61.98,101.12 64.06,103.2 64.06,105.2 63.95,105.31 63.95,106.54 63.57,106.93 63.17,106.93 63.06,107.03 63.06,107.34 v1(63.26,107.54) ; 131.89,98.35 v1(131.96,98.43)
CLK_PCIE_N0: length 213
  IN4 w0.094: v1(132.88,94.09) 133.33,93.64 134.29,93.64 135.25,94.6 135.25,102.04 134.98,102.31 134.98,104.48 140.78,110.28 152.34,110.28 153.63,111.57 157.58,111.57 157.79,111.78 166.15,111.78 170.55,107.38 174.69,107.38 179.96,102.11 179.96,101.25 181.4,99.81 182.22,99.81 183.65,98.38 183.65,95.58 184.97,94.25 184.97,89.98 185.62,89.34 186.47,89.34 189.84,85.96 190.25,85.96 192.15,84.06 192.15,83.39 201.18,74.36 201.18,66.03 205.75,61.46 205.75,60.57 216.36,49.95 218.31,49.95 221.18,47.08 224.26,47.08 224.68,46.66 241.55,46.66 242.64,47.75 248.68,47.75 251.28,50.36 253.01,50.36 258.02,55.36 259.43,55.36 263.83,59.76 270.05,59.76 270.68,59.13 272.02,59.13 273.08,60.18 274.62,60.18 274.86,59.93 278.33,59.93 278.93,59.33 279.31,59.33 279.72,58.92 279.72,58.13 279.82,58.03 280.28,58.03 280.37,58.13 280.37,58.27 v1(280.16,58.48)
  BOTTOM w0.076: v1(132.88,94.09) 132.64,93.85 132.45,93.85 132.24,93.64 132.24,92.82 132.7,92.36 132.7,90.77 132.45,90.51 UC1.AW2
  BOTTOM w0.104: JNGFF2.53 280.18,57.72 280.33,57.88 280.33,58.3 v1(280.16,58.48)
CLK_PCIE_N1: length 187.3
  IN4 w0.094: v1(136.45,97.19) 136.67,96.97 136.98,96.97 137.93,97.92 137.93,100.26 138.93,101.26 138.93,104.53 142.94,108.54 153.25,108.54 154.26,109.55 155.07,109.55 155.35,109.83 156.66,109.83 158.04,111.2 165.24,111.2 171.6,104.85 176.4,104.85 179.12,102.12 179.12,101.26 181.53,98.86 182.35,98.86 183.07,98.14 183.07,94.74 183.66,94.15 183.66,90.44 185.35,88.76 186.2,88.76 189.57,85.38 190.01,85.38 191.46,83.93 191.46,83.26 200.6,74.12 200.6,65.47 205.11,60.95 205.11,60.38 216.12,49.37 218.07,49.37 220.94,46.5 224.02,46.5 224.44,46.08 242.53,46.08 243.14,46.69 248.44,46.69 250.32,48.57 252.05,48.57 254.31,50.82 255.17,50.82 v1(255.28,50.93)
  BOTTOM w0.076: v1(136.45,97.19) 136.45,97.06 136.11,96.72 135.01,96.72 134.88,96.6 134.88,92.07 134.88,91.32 UC1.BC1
  BOTTOM w0.104: v1(255.28,50.93) 255.47,50.74 255.81,50.74 255.97,50.57 255.97,48.7 256.28,48.39 257.42,48.39 257.82,48 257.82,47.68 258.71,46.78 258.71,42.67 258.42,42.38 JNGFF1.49
CLK_PCIE_N2: length 198.8
  IN1 w0.094: v1(20.9,24.12) 20.57,24.45 20.57,24.49 22.73,26.65 22.73,27.6 23.02,27.89 24.3,27.89 25.02,27.18 27.62,27.18 29.16,25.63 34.12,25.63 36.87,28.38 36.87,47.65 38.18,48.96 40.04,48.96 41.8,50.72 41.8,53.83 41.66,53.97 41.66,56.13 41.41,56.38 41.41,58.07 42.45,59.11 42.45,64.43 44.15,66.13 44.15,68.85 44.75,69.45 44.75,76.09 44.92,76.27 44.92,77.66 49.59,82.32 49.59,86.53 49.94,86.88 49.94,91.54 52.84,94.44 52.84,95.1 55.98,98.25 55.98,99.27 56.37,99.65 59.49,99.65 60.41,100.57 70.49,100.57 70.54,100.53 74.54,100.53 76.18,98.88 80.77,98.88 81.34,99.44 82.76,99.44 83.41,100.09 93.41,100.09 95.73,102.42 100.74,102.42 101.13,102.02 105.87,102.02 106.27,102.42 109.25,102.42 109.66,102.01 113.49,102.01 113.79,101.72 121.1,101.72 121.42,102.04 122.98,102.04 123.67,101.35 127.28,101.35 128,102.06 129.68,102.06 130.88,100.87 134.3,100.87 135.25,99.92 135.25,95.56 135.5,95.32 135.55,95.32 v1(136,94.87)
  BOTTOM w0.076: v1(136,94.87) 135.66,95.21 135.46,95.21 135.37,95.12 135.37,90.91 135.19,90.73 135.19,90.6 135.27,90.52 135.5,90.52 135.57,90.45 135.57,90.22 135.52,90.16 135.32,90.16 UC1.BD3
  BOTTOM w0.104: JNGFF3.53 20.88,23.35 20.69,23.54 20.69,23.92 v1(20.9,24.12)
CLK_PCIE_N4: length 233.5
  TOP w0.104: UR1.6 289.88,65.94 289.67,66.15 289.3,66.15 289.13,65.97 288.88,65.97 288.71,66.15 287.73,66.15 287.6,66.02 287.6,65.87 v1(287.88,65.59)
  IN4 w0.094: v1(287.88,65.59) 287.74,65.73 287.74,66.65 286.58,67.81 286.58,68.4 285.44,69.54 280.69,69.54 279.53,68.38 279.53,67 279.44,66.91 278.13,66.91 278.01,66.78 264.68,66.78 262.4,64.51 262.4,59.16 259.19,55.94 257.52,55.94 252.51,50.94 251.04,50.94 248.43,48.33 242.4,48.33 241.31,47.24 224.92,47.24 224.5,47.66 221.42,47.66 218.56,50.53 216.6,50.53 206.38,60.76 206.38,61.65 201.76,66.27 201.76,74.88 194.24,82.4 194.24,82.62 192.92,83.95 192.92,84.14 190.51,86.54 190.1,86.54 188.03,88.61 188.03,92.14 184.92,95.25 184.92,96.16 184.23,96.85 184.23,98.79 174.89,108.13 170.63,108.13 166.22,112.54 157.57,112.54 157.18,112.15 153.39,112.15 152.79,111.56 149.47,111.56 148.78,110.86 147.24,110.86 145.72,112.38 142.87,112.38 142.38,111.89 142.38,111.58 142.23,111.43 139.18,111.43 138.26,112.35 137.06,112.35 135.7,110.99 135.7,106.94 134.4,105.64 134.4,102.07 134.67,101.8 134.67,98.32 134.27,97.92 134.27,96.03 134.18,95.93 v1(132.98,95.93)
  BOTTOM w0.076: v1(132.98,95.93) 133.34,95.58 133.34,95.17 133.9,94.61 133.9,92.99 133.27,92.35 133.27,91.31 UC1.BA1
CLK_PCIE_N5: length 181.2
  IN4 w0.094: v1(28.42,73.89) 28.42,73.89 28.64,73.67 28.64,73.17 28.55,73.07 23.49,73.07 22.83,73.74 22.83,77.5 21.84,78.49 21.84,79.25 21.03,80.06 20.27,80.06 19.69,80.64 19.69,83.27 20.69,84.27 21.28,84.86 21.28,88.64 22.04,89.4 23.06,89.4 24.83,91.18 28.96,91.18 29.23,91.45 33.97,91.45 36.2,93.68 36.2,99.37 39.01,102.17 43.96,102.17 45.45,103.67 45.99,103.67 47.19,104.86 47.19,105.34 53.82,111.96 78.21,111.96 79.28,110.9 86.23,110.9 88.23,112.9 106.11,112.9 106.7,112.31 109.55,112.31 110.14,112.9 128.72,112.9 132.59,109.03 132.59,100.96 132.99,100.57 132.99,97.82 132.27,97.1 132.27,91.46 132.59,91.14 134.59,91.14 135.13,91.69 135.13,93 135.36,93.22 136.56,93.22 136.66,93.13 136.66,92.91 136.56,92.82 v1(136.25,92.82)
  BOTTOM w0.076: UC1.BE1 135.8,91.11 135.8,90.95 135.88,90.88 136.08,90.88 136.16,90.95 136.16,91.34 136.02,91.48 135.89,91.48 135.85,91.52 135.85,93.1 135.93,93.18 136.07,93.18 136.25,93 v1(136.25,92.82)
  BOTTOM w0.094: UT1.T19 28.73,74.2 v1(28.42,73.89)
CLK_PCIE_P0: length 212.9
  IN4 w0.094: v1(280.74,58.48) 280.55,58.3 280.55,58.05 280.35,57.85 279.74,57.85 279.54,58.05 279.54,58.85 279.24,59.15 278.85,59.15 278.26,59.75 274.79,59.75 274.54,60 273.15,60 272.1,58.94 270.6,58.94 269.97,59.58 263.9,59.58 259.5,55.18 258.09,55.18 253.09,50.17 251.36,50.17 248.75,47.57 242.72,47.57 241.63,46.48 224.6,46.48 224.18,46.9 221.11,46.9 218.24,49.77 216.29,49.77 205.56,60.49 205.56,61.39 201,65.95 201,74.28 191.97,83.31 191.97,83.99 190.17,85.78 189.77,85.78 186.39,89.16 185.54,89.16 184.79,89.9 184.79,94.18 183.46,95.5 183.46,98.31 182.15,99.63 181.32,99.63 179.77,101.17 179.77,102.04 174.61,107.2 170.48,107.2 166.08,111.6 157.87,111.6 157.65,111.39 153.7,111.39 152.42,110.1 140.86,110.1 135.17,104.41 135.17,102.39 135.44,102.12 135.44,94.53 134.37,93.45 v1(132.98,93.45)
  BOTTOM w0.076: v1(132.98,93.45) 132.76,93.68 132.52,93.68 132.4,93.57 132.4,92.89 132.87,92.43 132.87,90.7 132.75,90.58 132.75,90.29 UC1.AY3
  BOTTOM w0.104: v1(280.74,58.48) 280.53,58.28 280.53,57.87 280.68,57.72 JNGFF2.55
CLK_PCIE_P1: length 187.3
  IN4 w0.094: v1(254.9,50.22) 254.99,50.31 254.99,50.45 254.79,50.64 254.38,50.64 252.13,48.39 250.39,48.39 248.51,46.51 243.21,46.51 242.6,45.9 224.36,45.9 223.94,46.32 220.87,46.32 218,49.19 216.05,49.19 204.93,60.3 204.93,60.88 200.42,65.39 200.42,74.04 191.28,83.18 191.28,83.85 189.93,85.2 189.5,85.2 186.12,88.57 185.27,88.57 183.48,90.37 183.48,94.07 182.88,94.67 182.88,98.07 182.28,98.67 181.45,98.67 178.94,101.18 178.94,102.05 176.32,104.66 171.52,104.66 165.16,111.02 158.11,111.02 156.74,109.65 155.43,109.65 155.15,109.37 154.34,109.37 153.33,108.36 143.02,108.36 139.11,104.45 139.11,101.18 138.11,100.18 138.11,97.84 137.06,96.79 136.67,96.79 v1(136.45,96.56)
  BOTTOM w0.076: UC1.BC2 134.91,90.94 134.94,90.98 135.05,91.24 135.05,91.35 135.05,92.07 135.05,96.48 135.12,96.56 v1(136.45,96.56)
  BOTTOM w0.104: JNGFF1.47 257.98,42.88 258.07,42.79 258.07,42.67 258.16,42.57 258.34,42.57 258.51,42.75 258.51,46.7 257.62,47.6 257.62,47.92 257.34,48.2 256.2,48.2 255.78,48.62 255.78,50.44 255.68,50.54 255.22,50.54 v1(254.9,50.22)
CLK_PCIE_P2: length 198.8
  IN1 w0.094: v1(20.31,24.12) 20.39,24.2 20.39,24.57 22.54,26.72 22.54,27.68 22.94,28.08 24.38,28.08 25.09,27.36 27.69,27.36 29.24,25.82 34.04,25.82 36.69,28.46 36.69,47.73 38.1,49.14 39.97,49.14 41.62,50.8 41.62,53.76 41.48,53.9 41.48,56.05 41.23,56.31 41.23,58.15 42.26,59.19 42.26,64.5 43.97,66.21 43.97,68.93 44.57,69.53 44.57,76.17 44.74,76.34 44.74,77.73 49.41,82.4 49.41,86.61 49.76,86.96 49.76,91.62 52.66,94.52 52.66,95.18 55.8,98.32 55.8,99.35 56.29,99.84 59.41,99.84 60.33,100.76 70.57,100.76 70.61,100.71 74.61,100.71 76.26,99.06 80.7,99.06 81.26,99.62 82.68,99.62 83.33,100.27 93.33,100.27 95.66,102.6 100.81,102.6 101.21,102.2 105.8,102.2 106.19,102.6 109.33,102.6 109.74,102.19 113.57,102.19 113.86,101.9 121.02,101.9 121.34,102.22 123.05,102.22 123.74,101.53 127.2,101.53 127.92,102.25 129.76,102.25 130.95,101.05 134.38,101.05 135.44,99.99 135.44,95.64 135.58,95.5 v1(136,95.5)
  BOTTOM w0.076: v1(136,95.5) 135.87,95.37 135.39,95.37 135.21,95.19 135.21,90.98 135.1,90.87 135.03,90.8 135.03,90.16 UC1.BC3
  BOTTOM w0.104: v1(20.31,24.12) 20.5,23.94 20.5,23.52 20.38,23.4 JNGFF3.55
